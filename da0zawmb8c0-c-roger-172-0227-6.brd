# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_WT_LANE1_DN: length 131.9
  IN1 w0.089: v2(184.85,17.46) 184.92,17.46 185.1,17.64 185.1,17.99 185.3,18.19 185.63,18.19 185.71,18.28 185.71,18.52 185.63,18.61 184.09,18.61 184,18.52 184,17.56 183.79,17.34 183.42,17.34 183.2,17.56 183.2,18.44 183.11,18.53 174.54,18.53 174.1,18.08 164.68,18.08 164.21,18.55 158.9,18.55 158.46,18.99 158.46,19.29 158.05,19.7 155.25,19.7 154.69,20.25 145.31,20.25 144.94,20.62 137.48,20.62 136.93,21.18 134.97,21.18 134.31,20.52 132.73,20.52 132.01,19.8 130.77,19.8 130.05,20.52 126.87,20.52 125.59,21.79 123.09,21.79 121.99,22.89 120.72,22.89 119.66,21.84 113.62,21.84 113.45,21.67 110.58,21.67 110.39,21.48 103.96,21.48 103.77,21.67 99.81,21.67 96.69,24.78 95.94,24.78 94.81,25.92 94.27,25.92 93.53,26.66 93.53,27.14 93.17,27.51 91.67,27.51 91.27,27.9 87.25,27.9 85.91,29.25 83.89,29.25 83.35,29.79 83.35,29.93 82.99,30.29 82.23,30.29 81.57,30.95 76.05,30.95 75.77,31.23 75.77,32.12 76.66,33.01 77.83,33.01 78.04,33.22 78.04,33.73 77.94,33.83 77.72,33.83 77.61,33.72 v2(77.61,33.59)
  BOTTOM w0.079: U1.CP33 77.27,34.95 77.27,34.38 77.15,34.26 77.15,33.57 77.27,33.46 77.48,33.46 v2(77.61,33.59)
  BOTTOM w0.102: CN17.59 184,16.63 184.28,16.35 184.44,16.35 185.06,16.97 185.06,17.29 184.89,17.46 v2(184.85,17.46)
CNV_WT_LANE1_DP: length 131.9
  IN1 w0.089: v2(77.58,34.2) 77.75,34.03 78.03,34.03 78.24,33.82 78.24,33.13 77.91,32.8 76.74,32.8 75.98,32.03 75.98,31.31 76.13,31.15 81.66,31.15 82.32,30.49 83.08,30.49 83.55,30.02 83.55,29.87 83.98,29.45 85.99,29.45 87.34,28.1 91.36,28.1 91.75,27.71 93.25,27.71 93.74,27.22 93.74,26.74 94.36,26.12 94.89,26.12 96.02,24.99 96.77,24.99 99.89,21.87 103.85,21.87 104.04,21.68 110.3,21.68 110.49,21.87 113.37,21.87 113.54,22.04 119.58,22.04 120.63,23.1 122.07,23.1 123.17,22 125.68,22 126.95,20.72 130.14,20.72 130.86,20 131.93,20 132.65,20.72 134.22,20.72 134.88,21.38 137.01,21.38 137.57,20.82 145.03,20.82 145.4,20.45 154.78,20.45 155.33,19.9 158.14,19.9 158.66,19.38 158.66,19.08 158.98,18.76 164.3,18.76 164.77,18.29 174.01,18.29 174.45,18.73 183.2,18.73 183.41,18.52 183.41,17.65 183.5,17.55 183.7,17.55 183.8,17.64 183.8,18.6 184.01,18.81 185.71,18.81 185.92,18.6 185.92,18.19 185.71,17.98 185.38,17.98 185.31,17.91 185.31,17.59 v2(185.43,17.46)
  BOTTOM w0.079: v2(77.58,34.2) 77.43,34.35 77.43,34.78 77.47,34.81 77.47,35.2 77.23,35.43 U1.CN33
  BOTTOM w0.102: CN17.61 184.53,16.13 185.28,16.88 185.28,17.31 v2(185.43,17.46)
CNV_WT_RCOMP: length 15.6
  TOP w0.102: R146.2 75,22.99 74.89,23.1 74.66,23.1 v1(74.56,23.2) 74.56,23.94 75.83,25.21 75.83,25.41 76.26,25.84 76.26,26.33 76.39,26.45 76.39,26.96 76.45,27.03 76.45,28.73 76.32,28.86 76.32,32.43 77.18,33.28 77.18,34.38 77.4,34.61 77.93,34.61 v2(78.14,34.39)
  BOTTOM w0.079: U1.CP32 77.76,34.71 U1.CR32 77.85,34.69 v2(78.14,34.39)
CODEC_VREF: length 5.2
  BOTTOM w0.102: U20.28 203.66,36.28 203.52,36.43 203.52,37.45 203.64,37.58 203.64,38.89 C563.2 204.52,39.37 205.01,39.86 v1(205.01,40.04)
COMP_CORE: length 5.5
  BOTTOM w0.102: PC7011.1 142.99,48.53 142.99,48.97 142.7,49.26 PR7048.2 142.12,49.26 141.44,49.95 140.44,49.95 139.75,50.65 PU7000.4
COMP_GT: length 5.1
  BOTTOM w0.102: PU7000.26 136.95,58.15 136.79,58.3 134.17,58.3 133.65,58.82 PC7017.1 PR7055.2
COMP_SA: length 4.5
  BOTTOM w0.102: PU7000.43 143.7,54.27 PC7021.1 144.21,54.78 144.21,54.98 144.26,55.03 PR7060.2 144.55,55.58 v1(145.12,56.15)
CON_DE: length 3.9
  BOTTOM w0.102: R25278.1 15.97,25.03 16.34,25.41 R25275.2 16.47,25.57 16.57,25.47 v1(16.57,24.88) 16.95,24.5 17.26,24.5 17.5,24.26 U6502.15
CON_EQ: length 4.7
  BOTTOM w0.102: v1(21.09,24.45) 20.84,24.45 19.87,25.41 R25274.1 19.75,25.06 19.9,24.9 R25272.2 19.11,24.24 18.7,23.83 U6502.18
CPU_C10_GATE#: length 10.1
  BOTTOM w0.079: U1.CN27 81.39,35.29 81.39,34.53 81.62,34.3 81.62,33.64 81.49,33.51
  BOTTOM w0.102: R161.1 79.76,28.38 81.57,28.38 v1(81.62,28.43) 81.62,28.76 81.36,29.02 81.36,30.89 81.22,31.04 81.22,33.24 81.49,33.51
CPU_C10_GATE#_R: length 92.4
  TOP w0.102: PQ35.4 105.72,38.37 105.85,38.24 105.85,37.78 105.75,37.68 PR2060.1 105.54,37.99 105.17,38.37 v2(105.04,38.37)
  IN2 w0.089: v2(111.16,44.03) 111.16,43 111.25,42.91 113.09,42.91 114.52,41.48 115.8,41.48 116.8,40.49 117.21,40.49 117.77,39.93 118.29,39.93 119.59,38.62 119.59,38.1 120.2,37.49 120.2,37.08 117.85,34.73 v2(117.3,34.73) 116.92,35.1 106.71,35.1 106.23,35.57 106.23,36.44 105.22,37.45 105.22,38.19 v2(105.04,38.37) ; v2(80.2,27.95) 80.4,27.95 81.72,29.27 81.72,29.7 82.4,30.38 85.79,30.38 87.36,28.82 88.2,28.82 89.41,27.6 93.22,27.6 93.64,27.19 93.64,26.4 94.02,26.02 95.46,26.02 95.91,25.57 96.92,25.57 102.28,20.21 103.75,20.21 104.52,20.98 108.33,20.98 110.45,23.1 111.9,23.1 112.28,23.48 v2(112.71,23.48)
  IN3 w0.089: v2(117.3,34.73) 117.3,32.78 116.79,32.27 115,32.27 111.57,28.84 111.57,24.62
  IN3 w0.102: v2(112.71,23.48) 111.57,24.62
  BOTTOM w0.102: R161.2 79.53,27.28 v2(80.2,27.95) 80.51,27.64 R1252.1 ; v1(111.42,44.89) 111.16,44.64 PR9272.2 110.68,44.52 v2(111.16,44.03)
CTL2: length 2
  TOP w0.102: U14.7 22.33,48.88 22.6,49.15 23.28,49.15 R418.2
CTL3: length 2
  TOP w0.102: U14.8 23.03,49.38 R417.2
D/C#: length 2.6
  TOP w0.102: TP9001.1 136.97,33.26 136.85,33.14 PC20.2 137.73,32.75 v2(137.86,32.88)
  BOTTOM w0.203: v2(137.86,32.88) 137.68,32.7 PR26.1
DC-DET: length 3
  TOP w0.102: v2(205.93,28.54) 205.87,28.48 R25495.1
  BOTTOM w0.102: R732.1 205.93,28.09 v2(205.93,28.54) 205.93,28.71 205.66,28.98 U20.4
DCPRTC: length 1.3
  TOP w0.254: v2(83.25,47.84) 83.27,47.87 C225.2
  BOTTOM w0.089: U1.BP24 82.75,47.24 83.25,47.73 v2(83.25,47.84)
DDCCLK_RIN: length 4.7
  TOP w0.102: Q41.4 23.67,61.19 24.04,60.82 v1(24.73,60.82) 25.08,60.82 25.97,61.71 R775.2
DDCDATA_RIN: length 1.2
  TOP w0.102: Q41.1 25.34,64.51 25.73,64.89 R777.2
DDR4_DRAMRST#: length 136.7
  TOP w0.102: v1(32.75,80.48) 32.78,80.5 34.62,80.5 U7.P1 ; U4.P1 34.95,45.6 32.52,45.6 v1(32.47,45.66) ; C249.2 48.7,69.46 48.19,68.95 v1(48.19,68.74) ; v1(34.85,93.63) 34.88,93.63 35.87,92.63 U6.P1 ; v2(48.96,32.63) 48.96,32.12 49.37,31.71 C3.2 49.85,31.99 49.72,32.12 R27.1 ; v1(32.75,59.32) 34.48,59.32 35.87,57.93 U5.P1
  IN1 w0.089: v1(48.19,68.74) 48.19,68.44 49.36,67.27 49.36,59.73 49.46,59.63 49.46,33.13 v2(48.96,32.63) ; v1(32.47,45.66) 32.45,45.67 32.45,47.77 31.33,48.88 31.33,50.46 32.22,51.35 32.22,51.91 32.05,52.08 32.05,53.54 31.63,53.95 31.63,55.85 32.14,56.35 32.14,58.7 v1(32.75,59.32) 32.4,59.68 32.4,64.58 32.55,64.73 32.55,65.31 32.02,65.84 32.02,72.57 32.22,72.77 32.22,73.33 31.96,73.59 31.96,74.92 31.66,75.22 31.66,75.94 31.54,76.06 31.54,77.18 32.14,77.78 32.14,79.52 32.75,80.14 v1(32.75,80.48) 32.78,80.5 32.78,82.46 31.74,83.5 31.74,83.8 32.4,84.46 32.4,86.41 32.65,86.65 32.65,88.05 33.29,88.68 33.29,88.99 32.83,89.44 32.83,90.54 33.97,91.68 33.97,93.33 34.27,93.63 v1(34.85,93.63)
  BOTTOM w0.102: JDIM1.108 48.68,69.46 48.19,68.97 v1(48.19,68.74) ; v2(48.96,32.63) 48.96,33.13 48.27,33.82 36.59,33.82 32.95,37.45 32.95,45.17 v1(32.47,45.66)
DDR4_SUSON_2V5: length 326.1
  TOP w0.102: v1(66.08,125.56) 65.59,125.08 65.59,124.52 65.29,124.21 PR9273.2 ; U37.122 187.25,28.9 v2(186.88,28.54) ; v2(31.86,27.01) 31.43,26.58 PR9252.1
  IN1 w0.089: v2(63.08,111.52) 63.16,111.6 63.16,120.88 64.94,122.65 65.86,122.65 66.32,123.11 66.32,124.08 66.08,124.32 v1(66.08,125.56)
  IN2 w0.089: v2(63.08,111.52) 62.6,111.04 57.57,111.04 56.92,110.39 56.92,109.41 56.52,109.02 55.23,109.02 54.89,108.68 54.89,108.08 53.06,106.25 53.06,105.4 51.74,104.08 50.4,104.08 49.77,103.44 49.36,103.44 48.93,103.01 48.93,102.5 49.08,102.35 49.08,100.49 47.94,99.34 44.71,99.34 43.48,98.11 31.8,98.11 29.48,95.79 29.48,94.59 26.96,92.06 26.96,89.74 24.33,87.12 24.33,84.92 24.92,84.33 25.55,84.33 26,83.88 26,82.49 25.16,81.65 25.16,74.18 25.36,73.98 25.36,53.61 25.49,53.48 25.49,51.25 25.23,50.98 24.41,50.98 24.17,50.74 24.17,50.43 23.61,49.87 23.61,48.64 22.41,47.45 22.41,47.08 22.69,46.81 22.69,44.29 22.92,44.06 23.5,44.06 24.37,43.18 24.37,40.97 24.49,40.85 24.49,38.79 24.14,38.44 24.14,35.24 26.61,32.77 26.74,32.77 27.47,32.03 27.47,27.26 28.12,26.62 28.93,26.62 29.23,26.32 31.17,26.32 v2(31.86,27.01) 31.86,26.73 32.07,26.53 34.81,26.53 35.67,25.67 38.55,25.67 40.09,24.14 40.09,23.79 41.57,22.31 45.61,22.31 45.97,21.95 45.97,21.69 46.25,21.41 46.25,18.6 47.2,17.66 59.3,17.66 61,15.96 71.9,15.96 72.84,16.9 79.28,16.9 84.12,21.73 88.47,21.73 93.61,16.6 95.82,16.6 95.95,16.72 97.51,16.72 98.3,15.94 99.83,15.94 100.47,15.3 107.48,15.3 108.65,16.47 112.9,16.47 114.23,17.8 118.61,17.8 119.01,18.21 120.5,18.21 121.29,19 123.94,19 124.37,18.57 128.12,18.57 128.47,18.92 129.44,18.92 130.51,17.85 136.7,17.85 137.62,18.77 144.16,18.77 145.03,17.89 148.91,17.89 149.45,18.43 162.93,18.43 163.5,19.01 164.76,19.01 165.18,18.58 169.9,18.58 170.15,18.83 172.55,18.83 173.34,19.61 177.87,19.61 178.23,19.98 179.27,19.98 179.34,20.05 180.47,20.05 180.59,19.93 181.28,19.93 181.77,19.44 183.98,19.44 184.26,19.73 186.83,19.73 v2(186.88,19.77)
  BOTTOM w0.102: v2(186.88,19.77) 187.31,20.2 187.31,22.53 187.22,22.62 187.22,24.59 187.63,25 187.63,26 187.5,26.12 187.5,26.95 187.26,27.19 187.13,27.19 186.87,27.45 186.87,28.52 v2(186.88,28.54)
DDR_VTT_CNTL: length 14.3
  BOTTOM w0.079: U1.C35 76.02,78.15 75.73,78.45 75.73,78.98 75.53,79.18 75.53,79.89 75.08,80.34 73.96,80.34
  BOTTOM w0.102: TP1.1 71.59,85.97 74.23,83.32 74.23,81.88 73.72,81.37 73.72,80.58 73.96,80.34
DE1: length 6
  TOP w0.102: U42.9 208.44,15.87 208.29,16.02 208.29,16.24 208.06,16.47 207.71,16.47 207.47,16.23 207.47,15.85 207.22,15.61 R1235.2 207.04,15.77 206.67,16.14 205.65,16.14 v1(205.42,15.91) 205.19,16.14 204.94,16.14 204.76,15.96 R503.1
DE2: length 4.8
  TOP w0.102: R505.1 205.24,16.67 205.55,16.37 206.94,16.37 207.04,16.47 R504.2 208.11,16.75 208.49,16.37 U42.8
DEVSLP0: length 140.7
  IN1 w0.089: v2(207.83,17.16) 207.66,17.33 207.66,18.78 207.01,19.42 207.01,19.95 207.4,20.33 207.4,22.24 206.43,23.2 206.28,23.2 206.02,23.46 205.63,23.46 204.05,25.04 202.69,25.04 201.95,24.31 201.95,24.21 200.64,22.9 197.01,22.9 196.1,21.98 195.18,21.98 194.84,21.65 194.4,21.65 193.86,22.19 193.86,23.51 192.93,24.44 192.93,24.79 192.56,25.16 190.81,25.16 190.47,24.83 188.78,24.83 188.68,24.93 187.03,24.93 185.5,23.4 179,23.4 178.46,23.93 177.67,23.93 177.33,23.6 174.17,23.6 173.53,22.96 170.61,22.96 170.49,23.08 165.83,23.08 164.63,24.29 161.01,24.29 160,25.29 154.28,25.29 153.67,25.91 145.04,25.91 144.77,25.63 143.67,25.63 143.42,25.39 138.27,25.39 137.59,26.07 131.11,26.07 130.66,25.62 127.22,25.62 125.48,27.36 111.64,27.36 111.45,27.17 105.79,27.17 105.14,27.82 103.35,27.82 102.63,28.54 99.88,28.54 98.46,29.96 96.38,29.96 95.48,30.86 94.72,30.86 93.79,31.79 v2(93.79,32.19)
  BOTTOM w0.079: U1.CP8 92.88,35.18 92.71,34.81 92.71,34.52 93.03,34.21 93.03,32.73 93.56,32.19 v2(93.79,32.19)
  BOTTOM w0.102: v2(93.79,32.19) 93.91,32.07 R25434.1 ; R25484.2 211.49,13.47 211.01,13.96 210.88,13.96 v1(210.48,14.36) 209.64,15.2 209.64,15.96 208.44,17.16 v2(207.83,17.16)
DEVSLP0_R: length 2.4
  BOTTOM w0.102: HD1.5 213.3,14.32 212.56,13.58 212.07,13.58 R25484.1
DEVSLP1: length 6.3
  BOTTOM w0.079: U1.CR8 92.97,34.51 93.2,34.28 93.2,32.83 93.38,32.65 93.97,32.65 94.3,32.32 94.3,31.99
  BOTTOM w0.102: 94.3,31.99 94.3,29.85 R554.1
DEVSLP2: length 91.4
  TOP w0.102: v1(31.66,4.69) R645.2
  IN3 w0.089: v1(31.66,4.69) 31.73,4.61 37.01,4.61 41.53,9.13 43.7,9.13 47.18,12.62 47.18,12.77 49.32,14.91 49.62,14.91 49.94,15.23 71.51,15.23 72.81,16.53 78.15,16.53 83.58,21.96 89.61,21.96 90.67,20.89 95.15,20.89 96.26,22.01 96.26,23.74 95.58,24.42 95.58,25.5 94.93,26.15 94.84,26.15 94.39,26.61 v2(94.39,26.63)
  BOTTOM w0.079: 92.85,32.63 92.85,34.15 92.55,34.45 92.55,34.84 92.63,35.03 92.63,35.42 92.77,35.56 92.77,36.34 U1.CM8
  BOTTOM w0.102: R551.1 94.22,26.22 94.39,26.39 v2(94.39,26.63) 94.31,26.63 93.47,27.47 v1(93.28,27.47) 93.08,27.67 93.08,28.76 93.43,29.12 93.43,32.04 92.85,32.63
DEW1: length 12.6
  TOP w0.102: R499.2 207.04,12.35 v2(206.64,11.95) 206.11,11.95 205.98,12.08 205.45,12.08 205.12,12.41 205.12,12.61 204.91,12.81 R500.1 204.76,13.06 v1(205.42,13.73) ; v1(212.53,14.82) 212.78,15.07 U42.16
  IN2 w0.089: v1(212.53,14.82) 208.65,14.82 206.64,12.81 v2(206.64,11.95)
DEW2: length 5.3
  TOP w0.102: R1237.1 205.27,19.16 205.45,19.34 v1(205.93,19.34) 206.92,19.34 207.04,19.22 R506.2 207.55,18.91 208.52,17.94 208.52,17.47 208.62,17.37 U42.6
DGPU_EDIDCLK: length 7
  BOTTOM w0.102: R363.1 96.69,89.24 96.79,89.34 96.79,89.66 97.22,90.09 98.81,90.09 99.87,91.15 100.3,91.15 100.93,91.78 100.93,93.02 U8.A9
DGPU_EDIDDATA: length 8.5
  BOTTOM w0.102: R366.1 96.05,89.82 96.63,89.82 97.13,90.32 98.71,90.32 99.77,91.38 100.2,91.38 100.7,91.87 100.7,92.72 100.54,92.88 100.54,93.23 100.91,93.6 U8.B9
DGPU_HOLD_RST#: length 121.3
  TOP w0.079: v2(80.66,40.22) 80.66,39.97 80.28,39.58 80.28,38.95 80.07,38.75 80.07,38.06 80.38,37.76 80.38,36.89 79.16,35.67
  TOP w0.102: R25428.2 77.1,25.06 77.1,25.98 77.48,26.36 77.48,27.41 77.29,27.6 77.29,29.07 77.16,29.21 77.16,32.08 78.78,33.7 78.78,35.29 79.16,35.67 ; v1(85.37,91.65) 83.86,93.16 83.86,95.72 84.26,96.13 86.73,96.13 87.19,96.59 88.59,96.59 88.99,96.99 90.71,96.99 93.69,99.96 v2(93.76,99.96)
  IN1 w0.089: v1(85.37,91.65) 85.37,90.68 84.69,90 84.69,87.39 v1(84.54,87.24)
  IN3 w0.089: v1(92.9,115.3) 92.82,115.22 92.82,112.04 91.91,111.14 91.91,106.23 93.15,104.99 93.15,100.44 93.61,99.99 93.74,99.99 v2(93.76,99.96) ; v1(84.54,87.24) 84.54,87.06 85.02,86.57 85.02,86.12 85.99,85.15 85.99,68.26 81.52,63.79 81.52,52.82 80.29,51.59 80.29,50.55 80.15,50.41 80.15,48.96 80.32,48.79 80.32,47.96 79.1,46.74 79.1,46.39 78.91,46.19 78.54,46.19 78.45,46.29 77.56,46.29 77.13,45.86 77.13,45.25 77.26,45.12 78.15,45.12 78.3,44.96 78.3,42.5 78.45,42.35 78.45,40.96 78.8,40.6 80.28,40.6 v2(80.66,40.22)
  BOTTOM w0.079: U1.CE28 80.34,40.54 v2(80.66,40.22)
  BOTTOM w0.102: v1(92.9,115.3) 92.9,116.32 91.88,117.33 91.88,118.45 95.44,122.01 v1(95.44,122.41) 95.44,122.8 95.68,123.03 U9.1
DGPU_OPP#: length 12.3
  TOP w0.102: U37.71 199.8,18.18 v2(200.02,18.4) ; R378.1 201.98,12.39 202.37,12 v2(202.37,11.82) 202.38,11.82 Q6512.3 202.38,10.78 v1(202.86,10.3)
  IN1 w0.089: v2(200.02,18.4) 199.38,17.75 199.38,14.95 202.37,11.95 v2(202.37,11.82)
DGPU_OVT#_EC: length 213.2
  TOP w0.102: R340.1 201.64,16.06 201.51,16.19 v2(201.51,16.47) 201,16.98 U37.68 ; v1(96.33,122.41) 96.33,122.54 96.58,122.8 96.58,123.43 97.09,123.94 Q15.3 99.33,123.94 100.21,123.05 R385.1
  IN3 w0.089: v1(96.33,122.41) 95.82,122.41 95.45,122.04 95.45,119.11 96.38,118.17 96.38,102.39 97.34,101.43 97.34,99 98.68,97.66 98.68,96.35 98.87,96.16 98.87,95.2 99.55,94.52 100.08,94.52 100.88,93.71 102.93,93.71 103.69,92.95 104.38,92.95 104.79,92.54 104.79,91.38 105.94,90.22 108.86,90.22 111.08,88 121.87,88 124.88,84.99 124.88,83.13 126.03,81.98 128.85,81.98 129.6,81.24 138.58,81.24 142.91,76.91 142.91,65.9 143.19,65.62 143.19,64.86 143.57,64.48 143.57,63.99 142.48,62.9 142.2,62.9 142.07,62.77 142.07,62.29 142.3,62.06 142.96,62.06 143.95,61.07 143.95,59.79 144.44,59.3 144.44,57.77 144.91,57.31 144.91,56.81 145.41,56.31 145.41,55.24 146.86,53.79 146.86,48.36 144.89,46.39 144.89,45.38 144.52,45.01 144.52,43.58 143.51,42.57 143.51,40.69 144.8,39.4 144.8,35.7 144.6,35.5 144.6,33.42 144.91,33.11 146.69,33.11 147.18,33.59 147.9,33.59 149.08,34.78 149.39,34.78 149.49,34.87 152.78,34.87 153.15,34.5 156.12,34.5 156.41,34.8 162.04,34.8 164.62,32.22 168.96,32.22 169.59,31.6 171.66,31.6 172.07,32.01 173.89,32.01 174.28,31.62 175.46,31.62 175.67,31.41 182.88,31.41 183.79,32.33 185.77,32.33 186.74,31.36 186.74,31.11 187.95,29.9 191.37,29.9 193.15,28.12 193.15,27.31 193.5,26.95 194.78,26.95 195.39,26.35 195.39,26.01 195.7,25.7 196.53,25.7 196.75,25.92 196.75,26.28 196.82,26.34 197.27,26.34 197.52,26.09 198.6,26.09 198.95,25.74 198.95,24.99 199.27,24.67 199.27,23.98 200.41,22.84 200.41,21.8 199.9,21.29 199.9,20.43 200.5,19.83 200.5,17.82 201.51,16.81 v2(201.51,16.47)
DGPU_PROCHOT_EC#: length 202.4
  TOP w0.102: Q6512.1 200.62,10.71 199.91,11.42 v1(199.91,12.05) 199.91,12.77 R25322.1 200.69,13.55 203.01,13.55 203.24,13.78 203.24,17.39 202.48,18.14 v2(202.13,18.14)
  IN1 w0.089: v2(144.59,41.79) 144.59,46.72 146.62,48.75 146.62,50.79 146.24,51.17 146.24,54.34 145.2,55.38 145.2,57.44 145.12,57.51 145.12,57.59 144.59,58.13 144.59,59.55 144.18,59.96 144.18,61.23 143.57,61.84 143.57,65.16 142.91,65.82 142.91,77.25 140.07,80.09 129.3,80.09 128.48,80.91 118.04,80.91 116.19,82.76 116.19,86.89 115.89,87.19 111.64,87.19 107.29,82.83 98.95,82.83 97.72,84.06 97.72,86.85 97.09,87.49 97.09,90.28 98.61,91.81 98.61,95.11 99.36,95.85 v2(99.68,95.85)
  IN3 w0.089: v2(202.13,18.14) 202.13,18.16 202.7,18.73 202.7,20.56 201.45,21.81 201.45,23.22 201.59,23.35 201.59,23.58 202.86,24.85 202.86,25.9 200.82,27.93 198.47,27.93 198,28.4 198,28.58 196.85,29.74 196.85,33.36 196.37,33.83 195.15,33.83 194.78,33.46 194.58,33.46 193.47,34.57 189.28,34.57 189.09,34.38 188.11,34.38 187.75,34.02 186.11,34.02 185.99,33.9 185.27,33.9 184.94,33.57 181.68,33.57 180.57,32.47 174.97,32.47 174.49,32.95 164.7,32.95 162.26,35.39 156.2,35.39 155.88,35.07 153.39,35.07 153.01,35.44 149.25,35.44 149.15,35.35 147.39,35.35 145.53,33.49 145.07,33.49 144.98,33.57 144.98,34.89 145.44,35.35 145.44,39.87 144.59,40.73 v2(144.59,41.79)
  BOTTOM w0.102: U8.D7 99.26,95.43 v2(99.68,95.85)
DGPU_PSI: length 45.1
  TOP w0.254: v1(70.67,115.51) 70.64,115.47 PR9016.1
  IN1 w0.089: v1(88.97,90.37) 87.97,91.37 87.97,95.99 87.61,96.35 87.61,98.93 83.22,103.32 76.74,103.32 76.39,103.67 75.29,103.67 74.68,104.28 74.68,105.3 73.03,106.95 72.55,106.95 71.76,107.74 70.21,107.74 69.68,108.27 69.68,112.96 70.32,113.6 71.87,113.6 72.58,114.31 72.58,115.23 72.3,115.51 v1(70.67,115.51)
  BOTTOM w0.102: R376.1 89.52,90.92 v1(88.97,90.37) 88.75,90.37 88.56,90.56 R391.1
DGPU_PW_CTRL#: length 16.8
  TOP w0.102: R25375.2 66.36,33.71 R25377.2 67.83,33.72 68.06,33.95 69.16,33.95 70.04,34.83 v2(70.04,35.85)
  IN1 w0.089: v2(70.04,35.85) 70.05,35.86 70.05,37.34 70.73,38.01 70.73,38.98 72.58,40.83 72.91,40.83 74,41.92 v2(74,42.18)
  BOTTOM w0.089: U1.CB34 76.09,42.18 v2(74,42.18)
DGPU_PWR_EN: length 194.4
  TOP w0.079: 80.58,35.67 80.58,35.77 80.5,35.85 80.5,36.53 80.72,36.75 80.72,37.59 81.19,38.06 81.19,40.5 v2(80.68,41.01)
  TOP w0.102: 80.58,35.67 80.58,33.13 80.68,33.03 80.68,31.17 81.09,30.76 81.09,29 80.78,28.69 79.84,28.69 79.31,28.15 R25403.1 79.31,26.66 78.67,26.02 78.67,25.06 79.1,24.63 R25429.2 ; v1(85.79,92.82) 85.48,92.82 85.36,92.95 84.39,92.95 84.09,93.25 84.09,95.62 84.36,95.9 86.83,95.9 87.29,96.36 88.69,96.36 89.09,96.76 91.07,96.76 92.34,98.03 92.44,98.03 v2(93.79,99.38) ; PR9070.2 24.95,86.73 v1(25.33,86.73)
  IN1 w0.089: v1(25.33,86.73) 25.46,86.6 26.73,86.6 28.14,88 28.14,92.08 30.22,94.16 30.22,95.17 31.82,96.77 49.8,96.77 50.96,97.92 52.29,97.92 53.54,99.17 55.23,99.17 57.03,97.36 62.49,97.36 62.83,97.03 79.15,97.03 82.32,93.86 85.39,93.86 85.63,93.61 85.63,92.98 v1(85.79,92.82) 85.79,92.52 85.81,92.49 85.81,87.77 85.28,87.24 85.28,86.85 v1(85.79,86.35)
  IN3 w0.089: v2(93.79,99.38) 93.79,99.38 93.82,99.38 94.14,99.71 94.14,100.21 93.34,101.01 93.34,105.07 92.1,106.31 92.1,111.06 93.01,111.97 93.01,113.89 v1(93.41,114.29) ; v2(80.68,41.01) 80.35,41.33 80.35,42.53 80.41,42.58 80.41,43.93 81,44.52 81,44.93 80.81,45.12 80.58,45.12 80.32,45.39 80.32,45.81 80.12,46.01 79.69,46.01 79.56,46.14 79.56,46.62 80.71,47.76 81.06,47.76 81.39,48.09 81.39,48.7 81.82,49.14 81.82,50.07 81.88,50.13 81.88,63.41 86.37,67.91 86.37,85.31 85.79,85.89 v1(85.79,86.35)
  BOTTOM w0.079: U1.CE27 80.99,40.7 v2(80.68,41.01)
  BOTTOM w0.102: R323.1 99.78,118.22 98.1,119.9 94.25,119.9 93.79,119.44 93.79,114.79 93.41,114.41 v1(93.41,114.29)
DGPU_PWROK: length 166.4
  TOP w0.079: v2(78.07,41.97) 77.76,42.28 77.18,42.28 76.67,41.77 75.25,41.77
  TOP w0.102: R25468.1 64.03,39.58 R25376.1 64.7,39.84 64.83,39.96 66.58,39.96 68.95,42.33 72.16,42.33 72.72,41.77 75.25,41.77
  IN2 w0.089: v2(88.43,87.36) 92.32,87.36 93.79,85.89 93.79,84.41 96.49,81.72 99.89,81.72 100.06,81.55 100.06,79.74 99.54,79.22 99.54,77.56 98.93,76.95 97.72,76.95 97.47,76.69 97.47,76.2 97.03,75.76 97.03,70.85 97.63,70.26 99.82,70.26 100.46,69.62 100.46,68.7 102.23,66.93 102.23,66.5 102.78,65.95 109.58,65.95 109.99,65.54 111.61,65.54 113.85,63.3 113.85,55.36 113.54,55.05 113.54,50.61 114.44,49.7 114.44,48.44 112.42,46.42 112.42,45.16 111.57,44.32 111.57,43.53 111.85,43.25 113.27,43.25 114.69,41.83 115.98,41.83 117.08,40.74 117.41,40.74 117.62,40.52 117.62,40.34 117.85,40.12 118.37,40.12 119.78,38.7 119.78,38.18 120.39,37.57 120.39,37 117.73,34.33 116.95,34.33 116.37,34.91 106.63,34.91 106.04,35.5 106.04,36.36 105.71,36.69 104.63,36.69 104.33,36.38 104.33,35.55 104.02,35.24 100.03,35.24 99.55,34.75 97.2,34.75 96.51,35.44 93.55,35.44 93,35.99 90.65,35.99 90.31,36.33 88.38,36.33 88.2,36.51 88.2,39.71 87.87,40.04 86.37,40.04 85.98,40.44 85.28,40.44 84.8,40.92 84.8,41.62 83.75,42.66 83.75,47.23 83.53,47.46 83.02,47.46 82.61,47.87 81.09,47.87 80.83,47.61 80.07,47.61 79.56,47.1 79.56,46.21 79.69,46.09 80.07,46.09 80.33,45.83 80.33,45.41 80.11,45.2 78.55,45.2 78.32,44.97 78.32,44.18 78.3,44.16 78.3,43.42 78.29,43.42 78.29,42.2 v2(78.07,41.97)
  BOTTOM w0.079: U1.CA31 78.39,42.4 78.07,42.07 v2(78.07,41.97)
  BOTTOM w0.102: v2(88.43,87.36) 88.07,87.36 86.68,88.76 86.68,89.72 86.12,90.28 86.04,90.28 85.85,90.48 Q9.2
DISP_ON: length 5.5
  BOTTOM w0.102: R445.1 R446.2 81.09,96.16 81.09,98.67 80.65,99.11 U19.3
DMIC-DATA34: length 0.9
  TOP w0.102: TP9024.1 209.24,30.48 209.1,30.63 R453.1
DMIC_CLK: length 2
  BOTTOM w0.102: U20.3 206.06,28.99 206.74,28.31 R461.2
DMIC_CLK_2: length 156.8
  IN1 w0.089: v1(35.75,115.18) 39.18,115.18 39.81,115.81 40.32,115.81 41.57,114.57 41.57,109.04 42.71,107.89 42.71,106.97 41.59,105.85 41.59,104.17 40.93,103.51 40.93,102.05 41.3,101.68 41.3,101.14 v1(41.11,100.95) ; v1(29.02,66.13) 28.62,65.73 28.62,57 27.79,56.17 27.79,40.21 28,40 28,39.04 31.5,35.54 35.75,35.54 36.52,34.77 43.13,34.77 v2(45.02,32.88)
  IN3 w0.089: v1(41.11,100.95) 41.11,100.47 40.63,99.99 36.71,99.99 36.24,100.46 31.74,100.46 30.06,98.78 28.62,98.78 27.75,97.9 27.75,96.33 26.78,95.35 26.78,93.52 26.94,93.36 26.94,89.47 26.27,88.81 25.54,88.81 24.08,87.35 24.08,85.73 23.39,85.04 23.39,81.52 24.06,80.84 24.06,76.77 24.68,76.15 24.68,74.93 26.69,72.93 27.43,72.93 27.83,72.53 27.83,67.32 v1(29.02,66.13)
  BOTTOM w0.102: CN38.3 35.5,115.42 v1(35.75,115.18) ; R25498.1 65.97,24.8 65.97,23.99 66.13,23.84 66.37,23.84 66.69,23.52 66.69,23.13 66.46,22.9 66.08,22.9 65.44,22.26 65.44,21.73 64.86,21.14 61.75,21.14 61.62,21.27 61.62,21.92 60.13,23.4 59.97,23.4 58.85,24.52 55.34,24.52 54.13,23.3 53.03,23.3 52.62,22.9 51.37,22.9 48.35,25.91 48.35,29 47.66,29.68 47.66,30.62 45.4,32.88 v2(45.02,32.88)
DMIC_CLK_2_R: length 28
  IN3 w0.089: v2(68.16,24.62) 69.16,24.62 69.89,23.9 70.15,23.9 70.43,23.61 73.45,23.61 73.84,24 73.98,24 76,26.03 76,29.75 77.03,30.77 80.87,30.77 81.75,31.65 82.86,31.65 83.5,32.3 v2(83.7,32.3)
  BOTTOM w0.079: U1.CP24 83.09,34.95 83.15,34.81 83.15,34.44 83.04,34.34 83.04,32.96 v2(83.7,32.3)
  BOTTOM w0.102: C6617.2 67.18,25.95 67.01,25.79 R25498.2 67.73,25.39 68.16,24.95 v2(68.16,24.62)
DMIC_CLK_L: length 306.5
  IN1 w0.089: v2(87.13,119.37) 87.13,120.03 85.71,121.45 85.71,122.77 85.1,123.38 78.7,123.38 76.07,126.01 59.64,126.01 58.94,125.31 51.78,125.31 51.27,124.8 51.27,122.97 49.13,120.84 46.26,120.84 44.94,122.16 43.29,122.16 41.41,120.28 41.41,119.92 44,117.33 44,116.32 44.26,116.06 47.05,116.06 47.61,115.51 47.61,113.73 49.21,112.13 49.21,108.85 48.3,107.94 48.3,107.66 47.71,107.07 44.61,107.07 43.11,105.57 43.11,103.52 42.71,103.11 42.71,101.54 v2(42.35,101.18)
  IN3 w0.089: v2(207.35,27.27) 205.75,27.27 205.53,27.04 205.53,24.44 205.78,24.19 205.78,22.73 204.21,21.16 204.21,19.42 203.62,18.83 203.62,16.85 202.4,15.63 200.57,15.63 199.04,17.16 199.04,22.99 198.4,23.62 198.4,23.92 197.82,24.5 197.01,24.5 196.94,24.57 196.47,24.57 196.44,24.54 195.64,24.54 194.49,25.68 191.5,25.68 190.66,26.52 190.66,27.95 189.57,29.04 186.88,29.04 185.57,30.35 175.25,30.35 175.03,30.57 173.84,30.57 173.65,30.76 172.32,30.76 172.1,30.54 168.89,30.54 168.3,31.13 157.68,31.13 155.37,33.44 152.71,33.44 152.34,33.82 149.92,33.82 149.54,33.44 149.24,33.44 148.33,32.54 147.65,32.54 147.17,32.05 144.12,32.05 142.87,33.3 142.87,33.31 142.3,33.88 142.3,35.95 142.66,36.31 142.66,39 141.78,39.88 141.78,42.62 143.27,44.1 143.27,45.55 143.61,45.9 143.61,46.89 145.2,48.48 145.2,51.92 144.73,52.39 144.73,53.59 144.52,53.8 144.52,54.35 144.11,54.76 144.11,55.66 142.85,56.92 142.62,56.92 141.79,57.75 141.79,61.25 141.21,61.84 141.21,64.81 141.46,65.07 141.46,68.05 141.29,68.22 141.29,68.95 140.75,69.48 140.75,71.97 141.44,72.66 141.44,76.28 138.04,79.68 129.4,79.68 128.45,80.62 121.31,80.62 121.23,80.54 118,80.54 115.48,83.07 115.48,84.7 115.19,84.99 112.33,84.99 108.34,88.98 105.42,88.98 103.55,90.85 103.25,90.85 102.9,91.2 101.63,91.2 99.56,93.27 99.04,93.27 98.15,94.16 97.76,94.16 96.29,95.63 96.29,100.99 95.32,101.95 95.32,115.28 93.27,117.33 88.68,117.33 87.34,118.68 87.34,119.16 v2(87.13,119.37)
  BOTTOM w0.102: v2(42.35,101.18) 41.67,101.87 41.67,102.5 41.34,102.83 L12.2 ; R461.1 207.27,27.35 v2(207.35,27.27) 207.83,26.78 C583.2
DMIC_CLK_L_C: length 5.1
  BOTTOM w0.102: CN29.1 43.85,106.74 43.75,106.64 43.6,106.64 43.6,106.64 42.2,106.64 41.79,106.23 41.79,105.46 C548.1 L12.1
DMIC_DAT: length 2.4
  BOTTOM w0.102: U20.2 206.46,29.05 206.67,28.84 207.05,28.84 207.19,28.98 207.55,28.98 R459.1
DMIC_DAT_2: length 158.5
  IN1 w0.089: v1(34.99,115.18) 35.39,115.58 39.03,115.58 39.66,116.22 40.55,116.22 41.97,114.79 41.97,109.21 43.1,108.08 43.1,106.81 41.98,105.69 41.98,104 41.34,103.36 41.34,102.2 41.69,101.84 41.69,101.08 v1(41.74,101.03) ; v2(29.02,66.76) 28.22,65.97 28.22,57.16 27.4,56.34 27.4,40.05 27.6,39.85 27.6,38.89 31.34,35.15 35.58,35.15 36.35,34.38 42.89,34.38 v1(44.38,32.88)
  IN3 w0.089: v2(29.02,66.76) 28.22,67.56 28.22,72.71 27.62,73.32 26.85,73.32 25.07,75.1 25.07,76.32 24.46,76.93 24.46,81.01 23.78,81.69 23.78,84.88 24.47,85.57 24.47,87.18 25.71,88.42 26.43,88.42 27.33,89.31 27.33,93.52 27.19,93.66 27.19,95.21 28.14,96.16 28.14,97.74 28.79,98.39 30.23,98.39 31.9,100.06 35.93,100.06 36.41,99.58 40.78,99.58 41.74,100.54 v1(41.74,101.03)
  BOTTOM w0.102: R25497.1 66.56,24.21 67.09,23.68 67.09,22.96 66.63,22.49 66.24,22.49 65.85,22.09 65.85,21.56 65,20.71 61.59,20.71 61.21,21.09 61.21,21.75 59.96,23 59.76,23 58.65,24.12 55.51,24.12 54.29,22.9 53.2,22.9 52.79,22.49 51.2,22.49 47.94,25.75 47.94,28.83 47.26,29.51 47.26,30.45 45.36,32.35 44.92,32.35 44.82,32.45 44.82,32.45 v1(44.38,32.88) ; v1(34.99,115.18) 34.7,115.46 CN38.2
DMIC_DAT_2_R: length 26.7
  IN3 w0.089: v2(83.7,32.88) 83.53,32.88 82.69,32.05 81.59,32.05 80.7,31.16 76.86,31.16 75.61,29.91 75.61,26.19 73.82,24.4 73.68,24.4 73.29,24.01 70.6,24.01 70.31,24.29 70.05,24.29 69.21,25.13 67.85,25.13 v2(67.6,24.88)
  BOTTOM w0.079: U1.CN24 82.97,35.67 83.11,35.53 83.16,35.43 83.16,35.18 83.24,35.02 83.31,34.84 83.31,34.37 83.22,34.28 83.22,33.37 v2(83.7,32.88)
  BOTTOM w0.102: R25497.2 67.42,24.88 v2(67.6,24.88)
DMIC_DAT_L: length 305.6
  IN1 w0.089: v2(42.3,101.81) 42.3,103.44 42.61,103.75 42.61,105.62 44.49,107.5 47.51,107.5 47.89,107.89 47.89,108.11 48.73,108.95 48.73,111.93 47.13,113.53 47.13,115.31 46.85,115.58 44.06,115.58 43.52,116.12 43.52,117.13 40.93,119.72 40.93,120.38 43.19,122.64 45.01,122.64 46.42,121.23 48.97,121.23 50.87,123.14 50.87,125.02 51.67,125.82 58.34,125.82 58.93,126.41 76.23,126.41 78.86,123.77 85.26,123.77 86.1,122.93 86.1,121.61 87.74,119.98 v2(87.74,119.37)
  IN3 w0.089: v2(207.2,28.46) 206.4,27.66 205.59,27.66 205.14,27.21 205.14,24.22 205.39,23.97 205.39,22.89 203.82,21.33 203.82,19.59 203.21,18.98 203.21,17.01 202.23,16.03 200.73,16.03 199.43,17.33 199.43,23.15 198.8,23.79 198.8,24.08 197.97,24.9 197.14,24.9 197.09,24.96 196.31,24.96 196.3,24.95 195.78,24.95 194.65,26.08 191.66,26.08 191.05,26.69 191.05,28.11 189.73,29.43 187.04,29.43 185.72,30.75 175.4,30.75 175.19,30.96 174.01,30.96 173.81,31.16 172.16,31.16 171.93,30.94 169.06,30.94 168.47,31.53 157.85,31.53 155.53,33.84 152.88,33.84 152.5,34.21 149.75,34.21 149.38,33.84 149.07,33.84 148.17,32.93 147.49,32.93 147,32.45 144.29,32.45 142.7,34.04 142.7,35.79 143.06,36.15 143.06,39.16 142.17,40.04 142.17,42.45 143.66,43.94 143.66,45.39 144,45.73 144,46.73 145.59,48.32 145.59,52.08 145.12,52.55 145.12,53.76 144.92,53.96 144.92,54.52 144.51,54.93 144.51,55.82 143.02,57.31 142.78,57.31 142.19,57.91 142.19,61.47 141.6,62.05 141.6,64.65 141.86,64.9 141.86,68.21 141.79,68.27 141.79,69.07 141.16,69.71 141.16,71.74 141.84,72.43 141.84,76.43 138.21,80.07 129.56,80.07 128.61,81.02 121.15,81.02 121.07,80.93 118.16,80.93 115.87,83.23 115.87,84.86 115.35,85.38 112.5,85.38 108.5,89.37 105.59,89.37 103.71,91.25 103.41,91.25 103.07,91.6 101.79,91.6 99.72,93.67 99.2,93.67 98.31,94.56 97.92,94.56 96.68,95.79 96.68,101.15 95.72,102.12 95.72,115.44 93.43,117.73 88.85,117.73 87.74,118.83 v2(87.74,119.37)
  BOTTOM w0.102: v2(42.3,101.81) 42.07,102.04 42.07,102.35 42.48,102.75 L13.2 ; R459.2 207.72,27.74 207.2,28.26 v2(207.2,28.46)
DMIC_DAT_L_C: length 5.4
  BOTTOM w0.102: L13.1 C547.1 42.05,105.44 42.05,106.13 42.31,106.39 44.22,106.39 44.35,106.51 CN29.2
DNBSWON#: length 136.8
  TOP w0.102: v2(185.84,28.46) 186.19,28.46 186.68,28.94 186.7,28.94 186.85,29.09 U37.123
  IN1 w0.089: v2(185.84,28.46) 184.17,28.46 183.65,27.94 180.34,27.94 180.27,28 177.58,28 177.21,28.37 170.89,28.37 170.83,28.31 168.83,28.31 168.06,29.09 163.63,29.09 163.43,29.29 162.11,29.29 161.78,29.62 160.8,29.62 158.73,31.69 156.23,31.69 156.07,31.85 147.18,31.85 146.48,32.54 145.7,32.54 145.55,32.69 144.54,32.69 141.44,35.79 134.4,35.79 134.22,35.62 133.87,35.62 133.49,36 127.38,36 126.01,34.63 123.78,34.63 123.68,34.52 122.78,34.52 122.51,34.79 121.71,34.79 121.25,34.33 119.3,34.33 116.98,32.01 111.42,32.01 109.51,33.92 107,33.92 106.51,34.41 105.43,34.41 105.31,34.54 104.68,34.54 104.43,34.78 104.43,35.39 103.59,36.23 102.53,36.23 100.88,37.88 99.42,37.88 99.21,38.09 99.21,38.33 98.23,39.31 95.68,39.31 94.87,38.49 91.96,38.49 91.58,38.11 91.58,36.66 91.36,36.44 88.63,36.44 88.26,36.82 88.26,38.09 88.13,38.21 87.56,38.21 87.18,38.59 87.18,39.1 86.98,39.31 86.52,39.31 86.4,39.18 85.58,39.18 85.28,39.48 85.28,39.87 84.39,40.76 84.39,41.77 83.65,42.51 83.65,47.15 83.54,47.26 82.9,47.26 82.74,47.1 82.74,45.96 82.54,45.76 81.86,45.76 81.57,46.05 81.18,46.05 81.13,46 78.38,46 78.27,46.11 77.4,46.11 77.1,45.81 77.1,45.47 77.44,45.12 78.11,45.12 78.19,45.05 79.53,45.05 79.84,44.74 v2(80.04,44.74)
  BOTTOM w0.079: U1.BU28 80.01,44.83 80.01,44.77 v2(80.04,44.74)
DRAM_RESET#: length 34.6
  TOP w0.102: R27.2 50.09,33.27 50.11,33.25 R26.1 50.98,33.01 53.68,33.01 53.96,33.29 v1(54.19,33.29)
  IN3 w0.089: v2(77.92,44.71) 77.47,44.26 77.2,44.26 76.92,43.98 76.92,43.04 76.59,42.71 76.59,42.29 74.42,40.12 73.85,40.12 72.22,38.49 70.83,38.49 69.52,37.18 68.4,37.18 68.19,36.97 65.83,36.97 64.54,35.67 60.29,35.67 58.94,34.32 58.32,33.7 54.6,33.7 v1(54.19,33.29)
  BOTTOM w0.079: v2(77.92,44.71) 78.37,45.15 U1.BU31
DRVEN_SET: length 4
  BOTTOM w0.203: PU7000.18 134.98,54.27 134.81,54.44 134.27,54.44 134.03,54.21 134.03,53.84 133.55,53.36 PR7104.2 PR7103.1
DSWROK_EC: length 15.6
  TOP w0.102: R51.2 64.32,44.11 63.49,43.27 63.08,43.27 62.9,43.09 62.9,41.87 62.44,41.41 62.44,31.02 TP9026.1 62.47,30.95 R41.2
DSWROK_EC_R: length 21.6
  TOP w0.079: v2(79.39,45.6) 79.39,45.38 79.67,45.1 79.67,44.31 79.54,44.18 79.24,44.18 79.07,44.01 79.07,43.56 78.9,43.39 77.15,43.39 76.65,43.9 75.98,43.9 75.63,43.55 75.25,43.55
  TOP w0.102: 75.25,43.55 74.92,43.55 74.81,43.65 67.79,43.65 C8.1 R46.1 R51.1 63.69,44.44 63.69,44.17 R47.1
  BOTTOM w0.089: v2(79.39,45.6) 79.39,46.63 U1.BP30
EC_FPBACK#: length 227.7
  TOP w0.102: v2(56.15,108.32) 56.15,108.67 Q6522.2 ; v2(201.94,25.54) 201.94,24.78 201.59,24.42 199.86,24.42 199.62,24.18 U37.86
  IN2 w0.089: v2(201.94,25.54) 202.16,25.76 202.16,26.48 201.49,27.16 199.55,27.16 194.47,32.24 191.64,32.24 190.61,33.26 188.17,33.26 187.42,32.51 185.51,32.51 185.08,32.94 182.93,32.94 182.54,32.55 180.96,32.55 180.78,32.36 179.65,32.36 179.34,32.68 179.34,33.18 179,33.52 173.94,33.52 173.85,33.43 167.09,33.43 166.95,33.29 165.25,33.29 164.85,33.7 164.03,33.7 163.41,34.31 162.56,35.17 159.75,35.17 159.13,35.79 156.74,35.79 155.87,34.92 148.82,34.92 148.23,35.51 147.63,35.51 147.54,35.6 147.25,35.6 146.73,36.12 146.73,36.69 143.63,39.79 139.78,39.79 139.01,39.01 136.38,39.01 135.6,38.24 128.08,38.24 125.84,36 124.78,36 123.75,37.03 122.02,37.03 120.57,38.47 120.57,38.99 119.02,40.54 119.02,41.17 118.03,42.16 117.78,42.16 117.28,42.66 117.28,43.12 117.03,43.37 114.32,43.37 113.66,44.02 113.66,46.58 115.2,48.12 115.2,50.03 114.95,50.28 114.95,51.81 114.3,52.46 114.3,54.73 114.61,55.04 114.61,64.8 114.61,64.8 113.43,64.8 111.93,66.3 110.31,66.3 109.84,66.76 105,66.76 103.22,68.54 102.62,68.54 100.03,71.13 100.03,71.37 99.92,71.49 99.92,74.2 99.53,74.59 99.53,76.47 100.3,77.24 100.3,78.91 100.82,79.42 100.82,81.98 100.32,82.48 96.81,82.48 94.56,84.73 94.56,86.2 92.13,88.63 86.93,88.63 86.37,88.07 86.37,86.14 86.17,85.94 85.56,85.94 85.38,86.12 85.38,88.94 84.8,89.51 84.8,92.61 83.12,94.29 83.12,96.43 78.16,101.39 75.15,101.39 74.37,102.17 70.5,102.17 66.03,106.64 66.03,107.73 63.1,110.66 57.73,110.66 57.31,110.24 57.31,108.22 56.91,107.81 56.65,107.81 v2(56.15,108.32)
EC_ODD_EJ#: length 91.2
  TOP w0.102: R638.1 127.44,16.37 v2(127.87,16.8) ; v2(204.43,23) 204.43,23.3 204.79,23.66 v1(204.79,23.94) 204.79,24.7 204.38,25.11 203.41,25.11 203.31,25.01 R25328.1
  IN2 w0.089: v2(127.87,16.8) 128.05,16.8 128.13,16.72 128.31,16.72 128.43,16.6 138.7,16.6 139.33,17.23 142.59,17.23 143.27,16.55 156.63,16.55 156.83,16.75 156.83,17.16 156.96,17.29 158.3,17.29 158.51,17.09 172.2,17.09 173.25,18.13 184.1,18.13 184.37,17.86 187.74,17.86 188.28,18.4 188.66,18.4 188.99,18.07 188.99,16.9 189.52,16.37 190.77,16.37 191.57,17.18 192.14,17.18 192.16,17.16 196.24,17.16 196.61,17.52 197.15,17.52 197.23,17.44 200.22,17.44 200.54,17.77 200.54,18.6 200.87,18.93 202.39,18.93 202.8,19.35 202.8,20.05 203.54,20.79 203.54,21.63 204.43,22.52 v2(204.43,23)
  BOTTOM w0.102: CN15.16 129.35,17.06 129.02,16.72 128.13,16.72 128.05,16.8 v2(127.87,16.8)
EC_ODD_EJ_R#: length 5.8
  TOP w0.102: U37.94 199.67,27.38 200.27,27.98 C2607.1 201.2,27.37 201.25,27.37 v1(201.53,27.08) 202.2,26.42 202.2,25.86 202.58,25.47 R25328.2
EC_PECI: length 106.6
  TOP w0.102: R380.2 179.08,30.77 178.01,31.84 177,31.84 176.34,32.5 175.83,32.5 175.7,32.63 175.7,33.13 175.47,33.36 167.63,33.36 166.94,34.05 v2(166.61,34.05)
  IN1 w0.089: v2(166.61,34.05) 166.41,34.05 166.25,33.9 165.72,33.9 165.7,33.91 164.97,33.91 164.07,34.81 162.57,34.81 161.61,35.76 160.34,35.76 158.93,37.17 156.14,37.17 155.88,36.91 155.09,36.91 154.97,36.79 154.87,36.79 154.48,36.4 154,36.4 153.84,36.24 153.51,36.24 153.26,35.99 149.37,35.99 148.94,36.42 148.74,36.42 148.58,36.59 148.2,36.59 147.76,37.02 147.52,37.02 144.13,40.42 144.13,40.91 143.25,41.78 143.25,45.77 142.56,46.47 135.23,46.47 133.68,44.91 131.4,44.91 130.38,43.9 127.8,43.9 127.09,44.61 120.76,44.61 119.44,43.29 119.44,42.62 119.2,42.38 115.02,42.38 114.57,42.83 114.57,43.44 111.23,46.78 111.23,47.44 111.06,47.61 111.06,48.14 110.2,49.01 108.77,49.01 108.24,49.54 108.24,50.58 106.21,52.61 v1(105.9,52.61)
  BOTTOM w0.079: U1.AR1 97.47,58.69 98.28,58.69 98.61,59.02 99.1,59.02 99.72,59.64 100.6,59.64
  BOTTOM w0.102: 100.6,59.64 102.08,59.64 102.42,59.3 102.68,59.3 103.47,58.51 v1(103.47,56.2) 104.84,54.82 105.29,54.82 105.9,54.22 v1(105.9,52.61)
EC_PECR_R: length 12.7
  TOP w0.102: v2(188.33,28.08) 188.89,28.64 188.89,28.69 189.25,29.05 U37.117 ; v2(180.78,29.2) 179.84,29.2 179.24,29.8 R380.1
  IN2 w0.089: v2(180.78,29.2) 181.24,28.74 183.04,28.74 183.75,29.44 184.9,29.44 185.26,29.09 185.74,29.09 186.72,28.1 188.3,28.1 v2(188.33,28.08)
EC_PWROK: length 112.5
  TOP w0.102: v2(185.53,16.55) 185.53,15.96 185.63,15.86 185.63,15.3 185.38,15.05 185,15.05 184.85,14.9 U37.33
  IN1 w0.089: v2(185.53,16.55) 185.53,16.55 183.4,16.55 181.82,18.13 174.7,18.13 173.38,16.81 159.13,16.81 157.84,18.1 155.77,18.1 155.34,18.53 154.79,18.53 154.14,19.18 144.85,19.18 144.48,19.55 136.93,19.55 136.54,19.94 136.15,19.94 135.53,19.32 133.1,19.32 132.47,18.69 130.35,18.69 129.62,19.41 123.49,19.41 122.01,20.89 122.01,21.35 121.79,21.57 120.93,21.57 120.11,20.75 114.17,20.75 113.51,20.09 110.8,20.09 110.52,20.37 103.5,20.37 103.27,20.6 96.05,20.6 95.41,21.25 94.52,21.25 93.38,22.39 v2(93.23,22.39)
  BOTTOM w0.102: v2(93.23,22.39) 93.23,22.8 92.77,23.25 R25362.2 92.56,23.7 92.14,23.28 92.04,23.28 91.73,22.97 90.99,22.97 90.48,23.49 89.31,23.49 88.21,22.39 v1(87.46,22.39) 87.01,22.39 86.29,23.1 R25358.2 86.65,23.38 87,23.03 U6504.1
EC_TYPEC_CHG: length 1.6
  BOTTOM w0.102: U6503.7 25.45,13.46 25.97,12.94 R6515.2
EC_TYPEC_CHG_HI: length 180.5
  TOP w0.102: v2(163.97,17.87) 163.97,17.89 164.12,18.04 164.12,20.48 164.43,20.78 164.43,22.48 163.84,23.07 163.84,24.64 164.21,25.01 v2(164.32,25.01) ; v2(181.47,26.53) 181.49,26.55 181.49,26.71 182.17,27.38 U37.3
  IN2 w0.089: v1(25.21,12.94) 25.33,12.81 26.1,12.81 27.11,11.8 27.95,11.8 29.42,10.32 44.94,10.32 48.8,14.18 72.89,14.18 73.97,15.26 80.38,15.26 81.28,16.17 81.28,17.27 84.35,20.34 88.21,20.34 93.79,14.76 95.44,14.76 96.16,14.04 98.66,14.04 98.73,14.11 107.76,14.11 109.05,15.4 113.18,15.4 114.51,16.73 118.9,16.73 119.39,17.23 119.77,17.23 120.3,16.7 122.46,16.7 122.82,17.05 122.82,17.6 123.05,17.83 123.71,17.83 124.09,17.45 128.38,17.45 128.97,16.86 138.69,16.86 139.25,17.42 142.89,17.42 143.45,16.86 149.49,16.86 150.11,17.48 163.58,17.48 v2(163.97,17.87)
  IN3 w0.089: v2(164.32,25.01) 164.58,25.01 164.83,24.76 168.08,24.76 168.75,25.42 171.14,25.42 171.85,26.14 181.08,26.14 v2(181.47,26.53)
  BOTTOM w0.102: R6516.2 24.95,12.69 v1(25.21,12.94) 24.95,13.2 U6503.8
EC_TYPEC_EN: length 2
  TOP w0.102: R2356.1 200.55,21.89 200.2,21.55 199.85,21.55 199.62,21.78 U37.80
EC_TYPEC_EN_R: length 197
  TOP w0.102: v2(200.04,21.96) 200.04,22.06 200.3,22.33 200.9,22.33 201,22.22 R2356.2
  TOP w0.254: R25504.1 26.27,13.42 26.99,14.13 v1(26.99,14.21)
  IN2 w0.089: v2(200.04,21.96) 200.04,20.86 199.07,19.9 199.07,18.49 198.6,18.02 197.3,18.02 197.14,17.86 196.68,17.86 196.22,17.4 191.54,17.4 189.59,19.35 187.52,19.35 186.88,18.71 184.05,18.71 183.97,18.63 180.68,18.63 180.37,18.94 180.37,19.27 180.16,19.48 179.78,19.48 178.72,18.42 173.23,18.42 172.88,18.06 170.47,18.06 170.22,17.82 164.55,17.82 164.13,18.24 163.82,18.24 163.24,17.67 150.03,17.67 149.41,17.05 143.53,17.05 142.97,17.61 139.17,17.61 138.61,17.05 129.05,17.05 128.46,17.64 124.17,17.64 123.69,18.12 122.41,18.12 121.96,17.66 121.96,17.44 121.63,17.11 120.17,17.11 119.85,17.42 119.31,17.42 118.82,16.92 114.43,16.92 113.11,15.61 108.95,15.61 107.66,14.31 98.61,14.31 98.54,14.24 96.26,14.24 95.52,14.98 93.84,14.98 88.26,20.56 84.29,20.56 79.54,15.81 73.7,15.81 72.76,14.87 51.05,14.87 49.53,16.39 48.09,16.39 47.36,15.66 47.36,13.04 44.83,10.51 33.22,10.51 30.8,12.94 28.26,12.94 v1(26.99,14.21)
  BOTTOM w0.203: U6503.6 26.84,14.36 v1(26.99,14.21)
ECAGND: length 1.8
  TOP w0.203: U37.75 199.69,19.78 199.86,19.95 200.63,19.95 C6566.2
  vias: v1(202.78,15.73) v2(200.47,20.66) v2(200.77,21.17) v2(201.81,15.23) v2(202.4,15.25)
EDP_RCOMP: length 9.1
  BOTTOM w0.079: 100.42,62.62 100.34,62.55 v1(100.34,62.04) 99.45,62.04 99.25,61.84 99.25,61.21 99.12,61.08 99.12,60.9 98.79,60.57 97.98,60.57 97.85,60.69 96.96,60.69 96.71,60.94 95.32,60.94 94.79,60.41 94.31,60.41 U1.AM6
  BOTTOM w0.127: 100.42,62.62 100.65,62.85 R2.2
EDRAM_OPIO_RCOMP: length 9.2
  BOTTOM w0.079: U1.L5 94.93,73.89 94.93,74.39 94.97,74.43 94.97,75.19 95.13,75.35 95.13,76.01 95.45,76.32 95.45,76.56 95.64,76.74 96.14,76.74 96.23,76.83 97.21,76.83 97.26,76.78 97.52,76.78 97.66,76.92 98.26,76.92 98.49,76.69
  BOTTOM w0.102: R20.1 100.67,76.29 100.26,76.69 98.49,76.69
EMMC_RCOMP: length 3.2
  TOP w0.102: R147.1 90.12,35.75 v1(89.53,36.34) 89.23,36.64 89.23,37.21 v2(88.81,37.63)
  BOTTOM w0.079: v2(88.81,37.63) 88.76,37.63 88.42,37.29 U1.CK15
EN: length 5.4
  TOP w0.102: R1238.1 205.73,17.64 206.11,17.26 206.89,17.26 207.04,17.41 R1236.2 v1(207.74,17.77) 207.91,17.77 208.27,17.41 208.27,17.03 208.43,16.87 U42.7
EN1_CORE: length 1.3
  BOTTOM w0.254: PU7002.1 117.8,70.25 117.2,69.65 PR7107.2
EN2_CORE: length 2.1
  BOTTOM w0.254: PU7001.1 133.86,46.2 v1(134.25,45.81) 134.25,45.81 134.86,45.81 PR7079.2
EN_GT: length 1
  BOTTOM w0.254: PR7111.2 129.55,76.41 PU7003.1
EN_SA: length 2.5
  BOTTOM w0.102: PR7115.2 143.78,41.05 144.13,40.7 v1(144.13,40.17)
  BOTTOM w0.254: PR7115.2 142.82,41.05 142.7,41.18 PU7004.1
EOPIO_RCOMP: length 9.4
  BOTTOM w0.079: 98.11,76.14 97.65,76.14 97.62,76.17 95.91,76.17 95.72,75.98 95.72,75.7 95.14,75.13 arc(95.14,75.13) 95.14,75.13 95.14,74.31 arc(95.14,74.29) 95.13,74.28 95.1,74.25 arc(95.1,74.25) 95.1,74.25 95.1,73.59 arc(95.1,73.57) 95.09,73.55 94.77,73.23 arc(94.7,73.13) 94.68,73.01 U1.N5
  BOTTOM w0.102: R21.2 100.8,75.53 100.01,76.31 98.28,76.31 98.11,76.14
EQ1: length 17.2
  TOP w0.102: R497.2 207.04,13.48 206.82,13.7 206.41,13.7 206.23,13.52 206.23,13.24 206.11,13.12 v2(205.65,13.12) 205.65,13.12 205.65,13.32 205.93,13.6 205.93,14.13 205.6,14.46 205.07,14.46 204.76,14.16 R498.1 ; U42.17 213.41,15.87 213.55,15.73 213.55,15.2 v1(212.53,14.18)
  IN2 w0.089: v2(205.65,13.12) 206.61,13.12 208.6,15.1 212,15.1 212.18,15.28 212.74,15.28 212.99,15.02 212.99,14.64 v1(212.53,14.18)
EQ2: length 12.6
  TOP w0.102: R495.1 206.03,14.74 206.39,15.1 206.89,15.1 207.04,14.95 R1234.2 207.33,14.72 207.88,15.27 v2(207.88,16.06) ; v1(213.73,17) 213.68,17 213.54,16.87 U42.19
  IN2 w0.089: v2(207.88,16.06) 208.61,16.79 208.61,17.14 209.1,17.64 212.91,17.64 213.54,17 v1(213.73,17)
EXT_PWR_GATE#: length 12.7
  BOTTOM w0.079: 71.14,38.07 71.21,38.14 71.21,38.64 72.46,39.9 72.46,40.37 73.48,41.39 74.6,41.39 U1.CC37
  BOTTOM w0.102: R40.1 65.35,35.94 65.85,36.44 v1(65.85,36.66) 65.85,36.82 65.97,36.94 70.01,36.94 71.14,38.07
FAN1_RPM: length 37.6
  TOP w0.102: U37.47 190.45,14.93 190.7,15.19 190.7,18.98 191.87,20.15 192.16,20.15 193.15,21.15 193.15,22.4 192.43,23.13 189.57,23.13 v2(189.11,23.58) ; v2(179,29.17) 179,29.02 178.59,28.6 R25372.2
  IN2 w0.089: v2(189.11,23.58) 189.37,23.58 189.5,23.46 189.8,23.46 190.08,23.74 190.08,24.63 190.49,25.04 190.49,26.98 189.75,27.72 189.01,27.72 188.32,27.02 187.93,27.02 187.3,26.39 185.89,26.39 185.14,27.14 183.93,27.14 183.22,27.85 180.67,27.85 179.35,29.17 v2(179,29.17)
  BOTTOM w0.102: FAN3.2 177.73,28.87 178.19,28.41 178.67,28.41 179,28.74 v2(179,29.17) 179,30.21 v1(178.83,30.39)
FAN_PWM: length 41.7
  TOP w0.102: Q6523.1 175.92,29.67 175.83,29.58 175.7,29.58 175.19,29.07 174.74,29.07 v2(173.44,27.77) ; U37.32 183.93,15.78 184.14,15.99 184.14,16 185.17,17.03 185.58,17.03 185.84,17.29 185.84,18.22 186.12,18.5 186.83,18.5 189.27,20.94 arc(189.27,20.94) 189.27,20.94 192.59,20.94 192.92,21.27 192.92,22.3 192.33,22.9 187.67,22.9 187.14,23.42 187.14,26.73 187.1,26.77 v2(187.09,26.77)
  IN3 w0.089: v2(187.09,26.77) 186.92,26.77 186.31,27.38 185.89,27.38 184.52,28.75 174.41,28.75 v2(173.44,27.77)
FAN_PWM_C: length 6.4
  TOP w0.102: Q6523.3 177.92,29.73 R25373.2 177.96,28.76 v2(178.37,29.17)
  BOTTOM w0.102: v2(178.37,29.17) 177.42,30.13 FAN3.3
FB_CAL_PD_VDDQ: length 9.4
  TOP w0.381: R318.2 119.43,93.46 116.55,93.46 116.37,93.64 115.06,93.64 114.72,93.97 114.28,93.97 113.98,93.67 113.5,93.67 112.14,95.03 v2(112.03,95.03)
  BOTTOM w0.381: U8.D22 111.63,95.43 v2(112.03,95.03)
FB_CAL_PU_GND: length 6.9
  TOP w0.102: v2(113.73,94.22) 113.97,94.46 114.93,94.46 115.17,94.22 116.53,94.22 116.66,94.09 R319.2
  BOTTOM w0.102: U8.C24 113.73,94.23 v2(113.73,94.22)
FB_CAL_TERM_GND: length 5.8
  BOTTOM w0.203: U8.B25 114.54,94.24 116,94.24 116.65,93.59 116.77,93.59
  BOTTOM w0.508: 116.77,93.59 118.8,93.59 119.31,94.09
  vias: v1(119.59,94.09)
FB_CORE: length 9.7
  BOTTOM w0.102: v1(144.94,46.24) 144.79,46.24 144.61,46.42 PC7010.2
  BOTTOM w0.203: PR7047.1 143.45,47.24 143.55,47.33 143.99,47.33 ; 143.99,47.33 PR7049.2 143.99,46.93 144.23,46.7 PC7010.2 ; 143.99,47.33 143.48,47.85 PC7011.2 143.48,48.3 143.32,48.46 143.32,49.15 PR7048.1 142.95,49.74 142.12,49.74 141.55,50.31 140.55,50.31 140.45,50.41 140.45,50.46 140.15,50.76 PU7000.3
FB_GT: length 6.7
  BOTTOM w0.203: PC7017.2 133.64,57.19 PR7054.1 PC7016.1 133.53,55.64 133.54,55.63 PR7056.2 ; PC7017.2 133.76,57.92 134.81,57.92 v1(134.95,57.78) 135.04,57.69 135.04,57.62 135.65,57.01 PU7000.24 ; PC7017.2 PR7055.1
FB_SA: length 13.2
  TOP w0.102: v2(145.35,54.22) PR7063.1 144.72,53.97 144.46,53.71 143.37,53.71 v1(143.04,53.38)
  BOTTOM w0.102: PC7020.1 147.06,50.73 146.37,51.41 PR7059.1 146.37,53.44 145.6,54.22 v2(145.35,54.22) 145,54.22 PC7021.2 144.98,54.5 145.43,54.95 v1(145.6,54.95) 145.6,56.4 145.43,56.58 144.74,56.58 144.52,56.36 PR7060.1 ; v1(143.04,53.38) 143.01,53.38 142.92,53.47 PU7000.45
FBA_CMD0: length 27.5
  TOP w0.127: v2(135.41,92.61) 135.01,93.01 135.01,94.66 131.71,97.96 131.71,98.76 131.17,99.3 v1(128.59,99.3) 125.45,99.3 123.97,97.81 119.86,97.81 v2(119.44,97.4)
  BOTTOM w0.127: v2(135.41,92.61) 135.01,92.21 VRAM1.G12 ; v2(119.44,97.4) 119.44,95.87 117.98,94.41 116.33,94.41 116.11,94.63 U8.C27
FBA_CMD1: length 32.4
  TOP w0.127: v2(134.61,90.21) 135.01,90.61 135.01,91.25 135.16,91.4 135.67,91.4 135.81,91.54 135.81,94.47 132.14,98.14 132.14,98.93 131.33,99.74 125.22,99.74 v1(124.65,99.17) 123.72,98.25 119.53,98.25 118.81,97.52 v2(118.81,97.4)
  BOTTOM w0.127: v2(118.81,97.4) 118.81,95.87 117.79,94.86 116.32,94.86 116.17,95.01 115.31,95.01 U8.C26 ; v2(134.61,90.21) 134.22,90.6 VRAM1.H10
FBA_CMD2: length 29.8
  TOP w0.127: v2(134.61,91.01) 134.09,91.53 v1(134.09,93.08) 134.09,94.98 131.28,97.78 131.28,98.58 131,98.86 125.62,98.86 124.15,97.38 121.29,97.38 120.85,96.94 116.19,96.94 115.5,96.25 113.9,96.25 113.89,96.26 113.36,96.26 v2(112.96,95.87)
  BOTTOM w0.127: U8.E24 113.33,96.24 v2(112.96,95.87) ; VRAM1.H11 134.22,91.4 v2(134.61,91.01)
FBA_CMD3: length 28.3
  IN3 w0.102: v2(133.01,91.01) 133.59,91.58 133.59,94.07 128.03,99.63 118.76,99.63 118.55,99.43 117.28,99.43 116.72,98.87 115.58,98.87 114.69,97.98 113.36,97.98 v2(112.93,97.55)
  BOTTOM w0.127: v2(133.01,91.01) 132.62,91.4 VRAM1.K11 ; U8.F24 113.33,97.15 v2(112.93,97.55)
FBA_CMD4: length 23.3
  TOP w0.127: v2(117.33,95.49) 117.68,95.15 119.9,95.15 120.23,95.48 125.17,95.48 125.64,95.95 131.07,95.95 132.65,94.37 132.65,93.13 132.61,93.09 132.61,90.61 v2(133.01,90.21)
  BOTTOM w0.127: v2(133.01,90.21) 132.62,90.6 VRAM1.K10 ; v2(117.33,95.49) 116.93,95.08 116.42,95.08 116.07,95.43 U8.D27
FBA_CMD5: length 24.1
  TOP w0.127: v2(116.65,95.49) 116.65,94.99 116.92,94.72 120.08,94.72 120.41,95.05 124.12,95.05 124.33,94.84 124.33,94.24 124.46,94.11 124.64,94.11 124.9,94.38 124.9,94.86 125.09,95.05 125.57,95.05 126.05,95.52 130.71,95.52 v1(130.87,95.36) 130.87,94.99 131.07,94.79 131.44,94.79 131.81,94.42 131.81,93.01 v2(132.21,92.61)
  BOTTOM w0.127: v2(116.65,95.49) 117,95.84 117,96.02 116.87,96.15 115.3,96.15 114.93,95.78 U8.D26 ; VRAM1.L12 131.81,92.2 v2(132.21,92.61)
FBA_CMD6: length 27.9
  IN3 w0.102: v2(117.54,97.37) 117.54,97.36 118.36,96.53 118.98,96.53 119.47,96.04 127.07,96.04 127.81,95.3 127.81,90.41 127.83,90.38 127.83,89.87 128.74,88.96 129.36,88.96 130.37,87.95 131.23,87.95 131.82,87.36 131.82,86.6 v2(132.21,86.21)
  BOTTOM w0.102: U8.F25 114.53,97.53 115.1,97.53 115.34,97.29
  BOTTOM w0.127: 115.34,97.29 115.34,96.96 115.6,96.7 116.86,96.7 v2(117.54,97.37) ; VRAM1.K4 132.61,85.81 v2(132.21,86.21)
FBA_CMD7: length 26.3
  IN3 w0.102: v2(118.17,97.37) 118.54,97 119.25,97 119.7,96.56 127.2,96.56 128.62,95.14 128.62,92.19 128.61,92.18 128.61,90.03 129.22,89.42 129.57,89.42 130.59,88.4 131.04,88.4 132.21,87.23 v2(132.21,87.01)
  BOTTOM w0.127: U8.F26 114.93,96.83 115.38,96.38 117.41,96.38 118.17,97.14 v2(118.17,97.37) ; v2(132.21,87.01) 132.61,86.61 VRAM1.K5
FBA_CMD8: length 32.2
  IN3 w0.102: v2(133.01,86.21) 133.18,86.21 133.41,86.43 133.41,87.97 131.61,89.78 131.23,89.78 131.01,90 131.01,94.69 127.46,98.23 117.36,98.23 117.16,98.03 115.89,98.03 115.3,97.45 115.3,96.7 114.86,96.25 113.35,96.25 112.94,96.66 v2(112.94,96.73)
  BOTTOM w0.127: v2(133.01,86.21) 133.41,85.81 VRAM1.J4 ; U8.F23 112.54,97.13 v2(112.94,96.73)
FBA_CMD9: length 33.7
  IN3 w0.102: v2(111.32,97.55) 111.72,97.15 111.72,96.35 111.82,96.25 112.46,96.25 112.58,96.13 112.58,95.62 112.74,95.46 114.72,95.46 115.76,96.51 115.76,97.5 116.04,97.78 120.43,97.78 120.63,97.58 127.47,97.58 130.23,94.82 130.23,90.41 130.2,90.38 130.2,90.08 130.97,89.32 131.42,89.32 133.01,87.73 v2(133.01,87.01)
  BOTTOM w0.127: VRAM1.J5 133.41,86.61 v2(133.01,87.01) ; v2(111.32,97.55) 111.69,97.92 U8.G22
FBA_CMD10: length 32.9
  IN3 w0.102: v2(133.81,86.21) 134.2,86.59 134.2,87.83 132.14,89.9 132.14,91.25 131.83,91.55 131.83,91.91 131.81,91.93 131.81,94.54 127.65,98.69 117.44,98.69 116.98,98.23 115.71,98.23 114.62,97.14 112.58,97.14 112.17,97.55 v2(112.11,97.55)
  BOTTOM w0.127: v2(133.81,86.21) 134.21,85.81 VRAM1.H4 ; U8.G23 112.49,97.93 v2(112.11,97.55)
FBA_CMD11: length 30.9
  IN3 w0.102: v2(134.61,87.01) 134.61,88.07 132.62,90.06 132.62,94.4 127.87,99.15 117.38,99.15 116.67,98.44 115.53,98.44 114.64,97.55 v2(113.73,97.55)
  BOTTOM w0.102: v2(113.73,97.55) 113.35,97.93 U8.G24
  BOTTOM w0.127: v2(134.61,87.01) 134.21,86.61 VRAM1.H5
FBA_CMD12: length 30.2
  IN3 w0.102: v2(116.9,97.37) 116.9,97.35 118.2,96.05 118.77,96.05 119.24,95.59 126.46,95.59 126.99,95.05 126.99,89.46 128.08,88.38 129.32,88.38 130.08,87.62 130.62,87.62 130.74,87.49 130.74,86.09 131.02,85.81 132.37,85.81 132.6,85.58 132.6,85.15 132.73,85.03 135.03,85.03 v2(135.41,85.41)
  BOTTOM w0.127: VRAM1.G3 135.01,85.01 v2(135.41,85.41) ; v2(116.9,97.37) 116.46,96.92 115.94,96.92 U8.F27
FBA_CMD13: length 35.2
  IN3 w0.102: v2(133.81,85.41) 134.22,85.81 134.78,85.81 135.01,86.04 135.01,88.94 134.23,89.72 134.23,91.24 134.05,91.43 134.05,94.26 128.2,100.11 123.2,100.11 122.77,100.54 120.42,100.54 v1(119.95,100.07)
  BOTTOM w0.127: v1(119.95,100.07) 119.95,99.81 R315.2 116.9,99.05 116.27,98.41 114.62,98.41 114.14,97.93 U8.G25 ; VRAM1.J2 133.81,84.6 v2(133.81,85.41)
