# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IN_D0#_R: length 14
  TOP w0.102: R1284.2 v1(26.94,74.92)
  BOTTOM w0.102: v1(26.94,74.92) 26.94,75.28 26.83,75.38 26.6,75.38 25.35,76.63 22.78,76.63 22.5,76.35 19.66,76.35 18.63,75.32 18.04,75.32 D13081.2 17.44,75.32 17.28,75.32 16.71,74.74 15.89,74.74 15.78,74.64 C1685.1
IN_D0_R: length 14
  TOP w0.102: R1285.2 v1(26.94,76.06)
  BOTTOM w0.102: C1684.1 15.78,75.08 15.9,74.96 16.62,74.96 17.19,75.54 17.44,75.54 D13082.2 18.04,75.54 18.54,75.54 19.57,76.57 22.41,76.57 22.69,76.85 25.44,76.85 26.69,75.6 26.83,75.6 26.94,75.7 v1(26.94,76.06)
IN_D1: length 114.6
  TOP w0.102: C851.1 26,77.6 26.1,77.5 27.55,77.5 27.62,77.57 v1(27.62,77.71)
  IN3 w0.089: v2(94.25,62.98) 94.33,62.98 94.52,63.17 94.52,63.26 94.42,63.36 93.44,63.36 93.42,63.33 92.51,63.33 92.24,63.6 92.24,66.81 92.01,67.04 89.34,67.04 88.2,68.19 88.2,80.47 88,80.67 88,84.9 87.54,85.36 87.54,85.75 86.98,86.31 86.98,87.3 85.8,88.48 83.53,88.48 83.2,88.81 81.09,88.81 79.51,90.38 76.29,90.38 75.8,90.87 75.8,91.35 73.74,93.41 67.88,93.41 67.42,92.95 59.27,92.95 57.34,94.88 50.17,94.88 49.15,95.9 33.36,95.9 32.07,94.6 32.07,93.76 30.36,92.05 30.36,86.68 29.55,85.86 29.55,82.78 28.95,82.18 28.28,82.18 27.24,81.14 26.66,81.14 26.53,81.01 26.53,77.79 26.89,77.43 27.44,77.43 27.62,77.61 v1(27.62,77.71)
  BOTTOM w0.102: v2(94.25,62.98) 94.15,63.08 93.96,63.08 93.76,62.88 93.76,62.7 93.92,62.54 U1.AJ6
IN_D1#: length 114.6
  TOP w0.102: v1(27.62,77.08) 27.41,77.28 26.23,77.28 26,77.05 R1286.1
  IN3 w0.089: v2(94.88,63) 94.73,63.16 94.73,63.34 94.51,63.56 93.36,63.56 93.33,63.54 92.59,63.54 92.44,63.69 92.44,66.9 92.09,67.25 89.43,67.25 88.4,68.27 88.4,80.55 88.2,80.76 88.2,84.98 87.74,85.44 87.74,85.84 87.18,86.4 87.18,87.38 85.88,88.68 83.61,88.68 83.28,89.01 81.17,89.01 79.6,90.59 76.37,90.59 76,90.96 76,91.43 73.82,93.61 67.8,93.61 67.34,93.15 59.35,93.15 57.42,95.08 50.25,95.08 49.24,96.1 33.28,96.1 31.86,94.69 31.86,93.84 30.16,92.14 30.16,86.76 29.35,85.95 29.35,82.87 28.87,82.38 28.2,82.38 27.16,81.34 26.57,81.34 26.33,81.1 26.33,77.71 26.81,77.23 27.47,77.23 v1(27.62,77.08)
  BOTTOM w0.102: v2(94.88,63) 94.68,62.8 U1.AJ5
IN_D1#_R: length 13
  TOP w0.102: R1286.2 v1(26.94,76.82)
  BOTTOM w0.102: C1680.1 15.78,76.54 15.89,76.65 16.27,76.65 D13083.2 16.87,76.65 18.1,76.65 18.57,77.11 22.12,77.11 22.29,77.28 26.83,77.28 26.94,77.18 v1(26.94,76.82)
IN_D1_R: length 13
  TOP w0.102: R1287.2 v1(26.94,77.96)
  BOTTOM w0.102: C1683.1 15.78,76.97 15.88,76.87 16.27,76.87 D13084.2 16.87,76.87 18.01,76.87 18.48,77.33 22.03,77.33 22.2,77.5 26.83,77.5 26.94,77.6 v1(26.94,77.96)
IN_D2: length 110.1
  TOP w0.102: v1(27.62,79.62) 27.62,79.49 27.54,79.41 26.1,79.41 26,79.51 C854.1
  IN3 w0.089: v2(94.32,62.04) 94.12,61.84 93.37,61.84 93.25,61.71 92.6,61.71 92.39,61.92 92.39,62.22 91.4,63.21 90.77,63.21 87.31,66.66 87.31,72 87.72,72.4 87.72,80.22 87.13,80.81 87.13,85.54 86.55,86.13 86.55,87.17 85.65,88.07 83.36,88.07 83.03,88.4 80.92,88.4 79.34,89.98 75.8,89.98 75.12,90.66 75.12,91.1 73.22,93 68.18,93 67.69,92.52 58.28,92.52 57.26,93.53 54.6,93.53 54.17,93.97 50.48,93.97 49.21,95.24 48.14,95.24 47.86,94.96 45.05,94.96 44.51,95.5 33.57,95.5 32.56,94.49 32.56,92.04 31.05,90.53 31.05,86.47 30.29,85.71 30.29,81.17 28.3,79.18 27.98,79.18 27.62,79.55 v1(27.62,79.62)
  BOTTOM w0.102: v2(94.32,62.04) 94.1,62.04 93.97,61.91 93.97,61.67 U1.AL6
IN_D2#: length 110.2
  TOP w0.102: C850.1 26,78.91 26.28,79.19 27.41,79.19 v1(27.62,78.98)
  IN3 w0.089: v2(94.91,62.05) 94.49,61.63 93.46,61.63 93.34,61.51 92.52,61.51 92.19,61.84 92.19,62.13 91.32,63 90.68,63 87.11,66.58 87.11,72.08 87.51,72.49 87.51,80.14 86.93,80.72 86.93,85.46 86.35,86.04 86.35,87.09 85.56,87.87 83.27,87.87 82.94,88.2 80.83,88.2 79.26,89.78 75.72,89.78 74.92,90.58 74.92,91.02 73.14,92.8 68.26,92.8 67.78,92.32 58.19,92.32 57.18,93.33 54.52,93.33 54.09,93.76 50.4,93.76 49.13,95.03 48.23,95.03 47.95,94.75 44.97,94.75 44.42,95.3 33.65,95.3 32.76,94.41 32.76,91.96 31.25,90.45 31.25,86.39 30.49,85.63 30.49,81.09 28.38,78.98 v1(27.62,78.98)
  BOTTOM w0.102: U1.AL5 94.91,61.85 v2(94.91,62.05)
IN_D2#_R: length 13.5
  TOP w0.102: R1288.2 v1(26.94,78.73)
  BOTTOM w0.102: v1(26.94,78.73) 26.94,79.09 26.83,79.19 23.3,79.19 22.66,79.82 20.21,79.82 18.94,78.55 18.04,78.55 D13085.2 17.44,78.55 15.88,78.55 15.78,78.45 C1682.1
IN_D2_R: length 13.5
  TOP w0.102: R1289.2 v1(26.94,79.87)
  BOTTOM w0.102: v1(26.94,79.87) 26.94,79.51 26.83,79.41 23.39,79.41 22.75,80.04 20.12,80.04 18.85,78.77 18.04,78.77 D13086.2 17.44,78.77 15.88,78.77 15.78,78.87 C1686.1
INT_AMIC-VREFO: length 3.4
  BOTTOM w0.102: U20.27 203.26,37 v1(203.08,37.17) 203.08,37.55 203.16,37.63 R447.2 C564.1
INT_EDP_AUXN: length 77.9
  TOP w0.102: C556.2 63.09,108.85 63.16,108.77 63.49,108.77 63.74,108.52 63.74,107.68 63.49,107.43 63.49,106.95 63.84,106.59 63.84,103.77 64.4,103.21 64.4,103.03 v2(64.6,102.83)
  IN3 w0.089: v2(98.97,64.12) 99.16,64.31 99.16,64.52 99.47,64.83 100.43,64.83 101.61,66.01 101.61,66.65 101.08,67.19 101.08,70.05 101.79,70.76 101.79,73.29 101.31,73.77 101.31,74.47 100.93,74.85 100.93,75.38 97.85,78.45 97.85,79.24 96.43,80.66 96.43,80.91 96.01,81.33 96.01,82.27 94.96,83.32 94.96,86.53 94.65,86.83 94.65,88.26 90.32,92.59 90.32,93.31 89.64,94 89.64,94.19 89.39,94.45 88.19,94.45 84.86,97.78 84.52,97.78 84.14,98.16 81.72,98.16 80.71,99.17 77.61,99.17 76.92,99.86 69.17,99.86 66.02,103.01 64.78,103.01 v2(64.6,102.83)
  BOTTOM w0.079: v2(98.97,64.12) 99.09,64 99.09,63.55 98.9,63.36 97.87,63.36 97.72,63.21 96.82,63.21 96.65,63.38 96.23,63.38 95.94,63.1 U1.AH4
INT_EDP_AUXN_C: length 10.4
  TOP w0.102: C556.1 62.03,109.33 v1(61.71,109.01) 61.39,109.33 R25271.1
  BOTTOM w0.102: v1(61.71,109.01) 61.69,109 61.69,108.99 61.53,108.83 60.26,108.83 60.04,109.04 55.22,109.04 54.46,108.28 54.46,107.85 54.35,107.74 CN29.22
INT_EDP_AUXP: length 77.9
  TOP w0.102: C557.2 63.09,108.39 63.26,108.56 63.4,108.56 63.52,108.43 63.52,107.77 63.27,107.52 63.27,106.86 63.63,106.5 63.63,103.68 64.19,103.12 64.19,102.97 v2(64.02,102.81)
  IN3 w0.089: v2(99.55,64.12) 99.36,64.31 99.36,64.44 99.56,64.63 100.52,64.63 101.81,65.92 101.81,66.74 101.28,67.27 101.28,69.96 101.99,70.67 101.99,73.37 101.51,73.86 101.51,74.55 101.13,74.93 101.13,75.46 98.05,78.54 98.05,79.32 96.63,80.74 96.63,80.99 96.21,81.41 96.21,82.35 95.16,83.41 95.16,86.61 94.85,86.92 94.85,88.35 90.53,92.68 90.53,93.4 89.84,94.08 89.84,94.28 89.47,94.65 88.28,94.65 84.95,97.98 84.6,97.98 84.22,98.36 81.81,98.36 80.79,99.38 77.69,99.38 77.01,100.06 69.25,100.06 66.1,103.21 64.43,103.21 v2(64.02,102.81)
  BOTTOM w0.079: U1.AH3 96.71,63.1 96.76,63.05 97.79,63.05 97.94,63.2 98.96,63.2 99.25,63.49 99.25,63.82 v2(99.55,64.12)
INT_EDP_AUXP_C: length 10.3
  TOP w0.102: C557.1 62.31,108.28 62.07,108.51 61.85,108.51 v1(61.71,108.37) 61.4,108.06 R25270.1
  BOTTOM w0.102: CN29.23 54.85,107.76 54.67,107.94 54.67,108.19 55.31,108.83 59.95,108.83 60.17,108.61 61.46,108.61 61.69,108.37 v1(61.71,108.37)
INT_EDP_TXN0: length 80.6
  IN3 w0.089: v2(98.74,66.54) 98.92,66.71 98.92,68.4 99.05,68.52 99.05,69.37 98.92,69.5 98.92,70.43 99.29,70.8 99.69,70.8 99.93,71.04 99.93,74.16 99.11,74.97 99.11,75.48 98.68,75.91 97.42,75.91 96.57,76.76 96.57,77.95 95.21,79.31 95.21,80.44 94.6,81.05 94.6,81.97 93.76,82.81 93.76,85.96 93.33,86.39 93.33,87.79 89.67,91.46 89.07,91.46 85.29,95.24 82.83,95.24 81.16,96.91 77.98,96.91 77.02,97.88 66.98,97.88 65.02,99.84 65.02,101.19 64.5,101.71 v1(64.45,101.71)
  BOTTOM w0.079: U1.AG4 95.79,63.95 96.27,63.94 96.5,64.05 96.64,64.09 96.87,64.09 97.03,64.01 97.06,64.01 97.27,64.1 97.45,64.1 97.93,64.58 97.93,65.29 98.45,65.8 98.55,65.8 98.96,66.22 98.96,66.31 v2(98.74,66.54)
  BOTTOM w0.102: v1(64.45,101.71) 64.45,102.04 64.34,102.16 63.62,102.16 63.08,102.7 61.87,102.7 61.7,102.53 61.7,100.99 61.33,100.62 58,100.62 55.47,103.15 54.81,103.15 54.41,103.55 54.41,103.77 C553.2
INT_EDP_TXN0_C: length 3.6
  BOTTOM w0.102: CN29.19 52.85,106.71 53,106.56 53,106.38 54.11,105.27 54.49,105.27 54.56,105.2 54.56,104.93 54.4,104.77 C553.1
INT_EDP_TXN1: length 84.3
  IN3 w0.089: v2(99.58,65.26) 99.58,65.63 99.72,65.77 100.04,65.77 100.52,66.25 100.52,70.31 100.91,70.7 100.91,74.31 100.52,74.7 100.52,75.23 98.61,77.13 97.75,77.13 97.39,77.49 97.39,78.5 96.02,79.87 96.02,80.76 95.62,81.16 95.62,82.09 94.56,83.14 94.56,86.37 94.25,86.68 94.25,88.04 89.93,92.35 89.93,93.15 89.5,93.59 88.45,93.59 84.69,97.34 84.35,97.34 83.97,97.73 81.52,97.73 80.48,98.77 76.8,98.77 76.19,99.38 70.72,99.38 70.34,99 67.39,99 67,99.38 67,100.72 65.4,102.32 63.48,102.32 63.02,101.87 63.02,101.28 v1(63.31,100.99)
  BOTTOM w0.079: U1.AG2 96.99,63.4 97.59,63.4 98.7,64.51 99.13,64.51
  BOTTOM w0.102: C555.2 52.43,103.77 52.43,103.36 53.27,102.53 55.14,102.53 57.69,99.97 62.79,99.97 63.09,100.28 63.09,100.76 63.31,100.99 v1(63.31,100.99) ; v2(99.58,65.26) 99.47,65.16 99.47,64.84 99.15,64.51 99.13,64.51
INT_EDP_TXN1_C: length 3.6
  BOTTOM w0.102: CN29.16 51.35,106.69 51.53,106.5 51.53,106.21 51.75,105.99 52.5,105.99 52.81,105.69 52.81,105.37 C555.1
INT_EDP_TXN2: length 99.7
  IN3 w0.089: v2(98.28,61.56) 98.28,61.58 98.47,61.77 98.47,61.98 98.88,62.39 100.04,62.39 102.91,65.26 102.91,65.52 103.8,66.41 103.8,68.74 103.47,69.07 103.47,69.82 104.02,70.38 104.02,70.97 103.74,71.25 103.74,72.43 104.2,72.88 104.2,73.87 102.98,75.09 102.98,75.2 102.32,75.86 102.32,76.87 102.06,77.13 100.87,77.13 100.04,77.96 100.04,82.36 99.54,82.86 98.17,82.86 96.15,84.87 96.15,87.02 95.87,87.3 95.87,88.78 91.52,93.13 91.52,93.81 90.84,94.49 90.84,94.84 89.95,95.72 89.95,96.25 89.49,96.71 89.19,96.71 86.49,99.41 85.26,99.41 84.9,99.78 82.13,99.78 81.47,100.44 78.45,100.44 77.79,101.1 75.2,101.1 74.31,101.99 69.9,101.99 67.82,104.08 66.75,104.08 66.02,104.81 65.67,104.81 65.55,104.69 65.55,104.51 v1(65.73,104.33)
  BOTTOM w0.079: U1.AJ4 95.95,62.28 96.48,62.17 96.58,62.11 96.9,62.11 96.93,62.14 97.17,62.14 97.2,62.11 97.81,62.11 97.99,61.93 98.37,61.93 98.41,61.89 98.44,61.85 98.44,61.72 v2(98.28,61.56)
  BOTTOM w0.102: C1675.2 50.68,103.54 50.68,102.66 51.98,101.36 55.42,101.36 57.44,99.34 63.73,99.34 65.73,101.34 65.73,102 65.54,102.2 65.54,102.87 65.73,103.06 v1(65.73,104.33)
INT_EDP_TXN2_C: length 3.1
  BOTTOM w0.102: CN29.13 49.85,106.67 49.98,106.54 49.98,105.52 50.25,105.25 50.43,105.25 50.61,105.07 50.61,104.91 50.47,104.77 C1675.1
INT_EDP_TXN3: length 89.9
  IN3 w0.089: v2(98.99,62.8) 99.19,62.99 99.19,63.2 99.55,63.56 100.16,63.56 102.22,65.63 102.22,66.91 101.79,67.34 101.79,69.82 102.39,70.42 102.39,74.24 101.53,75.09 101.53,75.61 98.51,78.63 98.51,79.43 97.04,80.9 97.04,81.16 96.84,81.37 96.84,82.38 95.55,83.66 95.55,86.78 95.26,87.07 95.26,88.52 90.92,92.86 90.92,93.56 90.24,94.24 90.24,94.59 89.36,95.46 88.38,95.46 87.49,96.36 87.49,97.55 86.22,98.82 85.02,98.82 84.66,99.17 81.72,99.17 81.09,99.81 77.84,99.81 77.18,100.47 69.42,100.47 66.25,103.64 63.35,103.64 63.02,103.97 50.47,103.97 49.78,103.29 49.07,103.29 48.87,103.49 48.87,103.78 v1(48.68,103.95)
  BOTTOM w0.079: 99.08,62.46 99.04,62.42 98.28,62.42 97.9,62.8 96.99,62.8 U1.AJ2
  BOTTOM w0.102: v2(98.99,62.8) 99.12,62.67 99.12,62.5 99.08,62.46 ; v1(48.68,103.95) 48.68,104.27 C1678.2
INT_EDP_TXN3_C: length 1.9
  BOTTOM w0.102: C1678.1 48.62,105.96 48.62,106.14 48.49,106.27 48.49,106.55 48.35,106.7 CN29.10
INT_EDP_TXP0: length 80.5
  IN3 w0.089: v2(99.33,66.54) 99.29,66.54 99.12,66.7 99.12,68.31 99.25,68.44 99.25,69.46 99.12,69.58 99.12,70.34 99.38,70.6 99.78,70.6 100.13,70.95 100.13,74.24 99.32,75.06 99.32,75.56 98.77,76.11 97.5,76.11 96.77,76.84 96.77,78.04 95.41,79.39 95.41,80.52 94.8,81.13 94.8,82.05 93.97,82.89 93.97,86.04 93.53,86.47 93.53,87.88 89.75,91.66 89.15,91.66 85.38,95.44 82.92,95.44 81.24,97.12 78.07,97.12 77.1,98.08 67.07,98.08 65.23,99.92 65.23,101.27 65.09,101.42 v1(65.09,101.71)
  BOTTOM w0.079: v2(99.33,66.54) 99.25,66.54 99.12,66.41 99.12,66.15 98.62,65.64 98.51,65.64 98.09,65.22 98.09,64.52 97.51,63.94 97.33,63.94 97.09,63.84 96.99,63.84 96.83,63.92 96.66,63.92 96.55,63.9 U1.AG3
  BOTTOM w0.102: C552.2 54.75,103.99 54.63,103.87 54.63,103.64 54.9,103.36 55.56,103.36 58.09,100.84 61.24,100.84 61.48,101.08 61.48,102.62 61.78,102.92 63.17,102.92 63.71,102.37 64.43,102.37 v1(65.09,101.71)
INT_EDP_TXP0_C: length 3.6
  BOTTOM w0.102: CN29.20 53.35,106.74 53.22,106.61 53.22,106.47 54.2,105.48 54.58,105.48 54.78,105.29 54.78,104.93 54.93,104.77 C552.1
INT_EDP_TXP1: length 84.3
  IN3 w0.089: v2(98.99,65.26) 99.05,65.26 99.38,65.59 99.38,65.71 99.64,65.98 99.96,65.98 100.32,66.33 100.32,70.39 100.7,70.78 100.7,74.23 100.32,74.61 100.32,75.14 98.53,76.93 97.67,76.93 97.19,77.41 97.19,78.41 95.82,79.78 95.82,80.67 95.41,81.08 95.41,82 94.36,83.06 94.36,86.28 94.04,86.6 94.04,87.95 89.73,92.27 89.73,93.07 89.41,93.38 88.37,93.38 84.61,97.14 84.26,97.14 83.88,97.52 81.44,97.52 80.39,98.56 76.71,98.56 76.1,99.17 70.8,99.17 70.42,98.79 67.3,98.79 66.8,99.29 66.8,100.63 65.31,102.12 63.56,102.12 63.23,101.78 63.23,101.59 63.45,101.37 63.82,101.37 63.9,101.46 63.9,101.62 v1(63.82,101.71)
  BOTTOM w0.079: 99.13,64.75 99.05,64.67 98.64,64.67 97.53,63.57 97.47,63.57 U1.AG1
  BOTTOM w0.102: v2(98.99,65.26) 99.04,65.26 99.29,65.02 99.29,64.91 99.13,64.75 ; v1(63.82,101.71) 63.82,101.65 63.59,101.42 63.13,101.42 62.88,101.17 62.88,100.37 62.7,100.19 57.78,100.19 55.23,102.74 53.36,102.74 52.65,103.45 52.65,103.9 52.74,103.99 C554.2
INT_EDP_TXP1_C: length 3.7
  BOTTOM w0.102: C554.1 53.03,104.77 52.89,104.91 52.89,105.15 53.02,105.28 53.02,105.78 52.59,106.21 51.84,106.21 51.75,106.3 51.75,106.56 51.85,106.66 CN29.17
INT_EDP_TXP2: length 99.6
  IN3 w0.089: v2(98.86,61.58) 98.67,61.77 98.67,61.89 98.97,62.19 100.12,62.19 103.11,65.18 103.11,65.43 104,66.32 104,68.82 103.67,69.15 103.67,69.73 104.23,70.29 104.23,71.06 103.95,71.33 103.95,72.34 104.41,72.8 104.41,73.95 103.19,75.17 103.19,75.28 102.52,75.95 102.52,76.95 102.15,77.33 100.95,77.33 100.24,78.04 100.24,82.44 99.62,83.06 98.25,83.06 96.35,84.96 96.35,87.11 96.07,87.39 96.07,88.86 91.72,93.21 91.72,93.89 91.04,94.58 91.04,94.92 90.15,95.81 90.15,96.33 89.57,96.91 89.27,96.91 86.57,99.62 85.35,99.62 84.98,99.99 82.21,99.99 81.55,100.65 78.53,100.65 77.87,101.31 75.28,101.31 74.39,102.2 69.99,102.2 67.91,104.28 66.84,104.28 66.1,105.02 65.59,105.02 65.35,104.78 65.35,104.59 v1(65.09,104.33)
  BOTTOM w0.079: v2(98.86,61.58) 98.6,61.84 98.6,61.92 98.52,62 98.43,62.09 98.06,62.09 97.87,62.27 97.26,62.27 97.24,62.29 96.87,62.29 96.84,62.27 96.62,62.27 96.09,62.54 U1.AJ3
  BOTTOM w0.102: v1(65.09,104.33) 65.52,103.9 65.52,103.15 65.33,102.96 65.33,102.11 65.52,101.92 65.52,101.43 63.64,99.55 57.53,99.55 55.51,101.57 52.07,101.57 50.89,102.75 50.89,103.92 50.97,103.99 C1676.2
INT_EDP_TXP2_C: length 3.1
  BOTTOM w0.102: C1676.1 51,104.77 50.82,104.95 50.82,105.16 50.52,105.46 50.34,105.46 50.19,105.61 50.19,106.51 50.35,106.67 CN29.14
INT_EDP_TXP3: length 89.9
  IN3 w0.089: v2(99.58,62.8) 99.39,62.99 99.39,63.12 99.63,63.36 100.24,63.36 102.42,65.54 102.42,66.99 101.99,67.42 101.99,69.73 102.59,70.33 102.59,74.33 101.74,75.18 101.74,75.7 98.72,78.72 98.72,79.51 97.24,80.99 97.24,81.25 97.04,81.45 97.04,82.46 95.76,83.74 95.76,86.86 95.46,87.15 95.46,88.61 91.12,92.95 91.12,93.65 90.44,94.33 90.44,94.67 89.44,95.67 88.47,95.67 87.69,96.44 87.69,97.63 86.3,99.02 85.1,99.02 84.75,99.38 81.81,99.38 81.17,100.01 77.92,100.01 77.26,100.67 69.51,100.67 66.33,103.85 63.43,103.85 63.1,104.18 50.38,104.18 49.69,103.49 49.16,103.49 49.07,103.58 49.07,103.82 49.2,103.95 v1(49.31,103.95)
  BOTTOM w0.079: U1.AJ1 97.48,62.65 97.83,62.65 98.22,62.26 99.17,62.26
  BOTTOM w0.102: 99.17,62.26 99.34,62.43 99.34,62.56 v2(99.58,62.8) ; C1677.2 48.95,104.75 48.86,104.66 48.86,104.4 v1(49.31,103.95)
INT_EDP_TXP3_C: length 1.9
  BOTTOM w0.102: C1677.1 48.84,105.91 48.84,106.23 48.71,106.36 48.71,106.49 48.85,106.63 CN29.11
INT_HDMICLK+_OUT: length 3.6
  TOP w0.102: R702.1 15.78,80.3 15.94,80.46 17.07,80.46 17.67,79.86 17.98,79.86 18.12,79.72 U23.10
INT_HDMICLK-_OUT: length 3.6
  TOP w0.102: U23.9 18.12,80.22 17.98,80.08 17.76,80.08 17.16,80.68 15.94,80.68 15.78,80.83 R703.1
INT_HDMITX0N_OUT: length 4.7
  TOP w0.102: R697.1 15.78,75.08 15.88,74.98 16.07,74.98 16.51,75.41 16.51,76.2 17.09,76.78 17.45,76.78 17.75,77.08 17.98,77.08 18.12,77.22 U23.15
INT_HDMITX0P_OUT: length 4.8
  TOP w0.102: R696.1 15.78,74.64 15.9,74.76 16.16,74.76 16.72,75.32 16.72,76.11 17.18,76.57 17.54,76.57 17.84,76.86 17.98,76.86 18.12,76.72 U23.16
INT_HDMITX1N_OUT: length 3.9
  TOP w0.102: R699.1 15.78,76.97 15.88,76.87 16.06,76.87 16.77,77.57 17.22,77.57 17.73,78.08 17.98,78.08 18.12,78.22 U23.13
INT_HDMITX1P_OUT: length 3.9
  TOP w0.102: U23.14 18.12,77.72 17.98,77.86 17.82,77.86 17.31,77.36 16.86,77.36 16.15,76.65 15.89,76.65 15.78,76.54 R698.1
INT_HDMITX2N_OUT: length 3.6
  TOP w0.102: U23.11 18.12,79.22 17.98,79.08 16.93,79.08 16.62,78.77 15.89,78.77 15.78,78.88 R701.1
INT_HDMITX2P_OUT: length 3.6
  TOP w0.102: U23.12 18.12,78.72 17.98,78.86 17.02,78.86 16.71,78.55 15.89,78.55 15.78,78.44 R700.1
INTRUDER#_R: length 44.3
  TOP w0.102: v2(49.88,25.65) 49.51,26.02 R42.1
  BOTTOM w0.079: U1.BR35 75.65,46.68 74.95,46.68 74.77,46.76 74.2,46.76 71.33,43.9
  BOTTOM w0.102: 71.33,43.9 69.68,43.9 68.64,42.86 65.15,42.86 v1(65.08,42.93) 64.84,43.17 62.29,43.17 62.02,42.89 62.02,29.42 61.92,29.32 61.66,29.32 61.23,28.89 61.23,28.76 61.02,28.55 58.7,28.55 57.16,27.01 56.16,27.01 55.53,26.38 54.56,26.38 54.2,26.01 52.13,26.01 52.02,26.12 50.23,26.12 49.88,25.78 v2(49.88,25.65)
ISEN1N_CORE: length 34.2
  TOP w0.203: v1(140.75,48.7) 139.46,48.7 v1(138.82,48.07)
  IN3 w0.203: v1(138.82,48.07) 138.82,48.28 137.5,49.6 137.5,50.2 136.05,51.65 134.2,51.65 133.62,52.23 133.62,52.92 132.95,53.59 132.95,56.37 130.16,59.17 v2(130.16,59.26)
  BOTTOM w0.203: v1(138.82,48.07) 138.64,48.25 PR7075.2 138.16,48.65 137.61,49.2 PC7047.2 ; PR7074.2 124.73,62.11 125.03,61.81 125.03,59.99 126.23,58.79 129.37,58.79 129.85,59.26 v2(130.16,59.26) ; PC7025.2 140.96,48.91 v1(140.75,48.7) 140.57,48.7 140.27,49.01 v1(140.27,49.19) 140.17,49.28 139.03,49.28 138.55,49.77 PU7000.7
ISEN1N_GT: length 94.7
  TOP w0.203: PR7100.2 132.79,57.16 132.79,57.69 PC7100.2 PC7097.2 134.01,59.88 v1(134.53,59.88)
  IN1 w0.203: v2(136.16,63.94) 135.84,64.26 135.84,66.29 131.66,70.47 131.66,72.2 129.91,73.95 128.8,73.95 127.45,75.3 124.62,75.3 120.03,79.89 117.23,79.89 113.65,83.48 v1(113.65,83.68)
  IN3 w0.203: v2(136.16,63.94) 136.16,62.52 135.6,61.96 135.6,60.79 134.68,59.88 v1(134.53,59.88) 134.28,59.88 133.92,60.23 133.62,60.23 132.83,61.02 132.83,67.25 132.01,68.06 128.93,68.06 128.43,68.57 124.07,68.57 122.93,69.71 120.03,69.71 118.12,67.8 118.12,66.48 117.36,65.72 116.6,65.72 115.39,66.93 115.39,72.88 114.32,73.95 114.32,75.51 113.3,76.54 111.67,76.54 111.06,77.15 v1(111.06,77.38)
  BOTTOM w0.203: v1(113.65,83.68) 113.08,83.11 PR7101.2 ; PR7097.2 110.7,79.03 111.06,78.68 v1(111.06,77.38) ; v1(134.53,59.88) 134.53,60.11 134.73,60.31 134.73,60.51 134.86,60.64 PC7030.2 135.06,59.83 135.06,59.83 135.06,59.14 135.21,58.99 137.09,58.99 137.75,58.34 PU7000.28
ISEN1N_SA: length 40.7
  TOP w0.203: PR7092.2 143.19,60.06 v1(143.44,59.81)
  IN2 w0.203: v1(143.44,59.81) 143.17,60.08 138.91,60.08 137.7,58.88 137.7,49.19 134.15,45.63 134.15,45.29 133.87,45.01 133.87,44.05 133.41,43.6 132.7,43.6 v2(131.94,42.84)
  BOTTOM w0.203: PU7000.41 142.88,55.07 v2(142.98,55.17) 142.98,55.27 143.7,55.99 143.7,57.14 v1(143.78,57.21) 144.46,57.9 144.46,59.42 144.08,59.81 v1(143.44,59.81) ; v2(131.94,42.84) 131.94,42.46 128.35,38.87 PR7089.2
  BOTTOM w0.254: PR7093.2 132.65,43.55 v2(131.94,42.84)
  vias: v1(142.61,54.37)
ISEN1P_CORE: length 6.2
  BOTTOM w0.203: PR7076.2 138.19,46.93 138.16,46.95 PR7075.1 137.68,47.96 137.68,48.55 137.5,48.73 136.79,48.73 136.67,48.85 136.67,49.43 PC7047.1 137.35,50.11 PU7000.10
ISEN1P_GT: length 9.5
  TOP w0.203: v1(136.82,60.07) PR7098.2 135.62,59.72 v1(135.62,59.47) 134.91,59.47 134.81,59.37 134.28,59.37 PC7097.1 PC7100.1 133.57,57.69 133.57,56.99 PR7099.1
  BOTTOM w0.203: PU7000.29 138.15,58.41 137.21,59.35 136.23,59.35 136.1,59.47 v1(135.62,59.47)
ISEN1P_SA: length 9.7
  TOP w0.203: PR7091.2 142.76,59.1 143.29,58.56 v1(143.37,58.56) 143.37,57.97 v1(143.27,57.87) 143.14,57.87 142.19,56.92 142.19,56.76 PC7079.1 PC7099.1
  BOTTOM w0.203: PU7000.40 142.62,55.47 143.27,56.12 v1(143.27,57.87) 143.27,58.22 PR7090.1
ISEN2N_CORE: length 33.5
  IN3 w0.203: v2(129.64,57.77) 129.78,57.77 131.35,56.2 131.35,54.57 133.03,52.89 133.03,51.47 135.19,49.31 135.19,45.1 135.72,44.56 138.36,44.56 139.61,45.81 141.62,45.81 v1(141.64,45.83)
  BOTTOM w0.203: v2(129.64,57.77) 126.31,57.77 125.54,57 125.54,55.41 125.11,54.98 PR7083.2 ; v1(141.64,45.83) 141.64,46.04 141.7,46.09 PC7027.2 141.29,46.42 141.19,46.32 PR7085.1 140.55,46.68 PR7066.1 140.53,47.32 PC7065.2
ISEN2P_CORE: length 8.2
  BOTTOM w0.203: PR7065.2 140.16,45.77 140.13,45.8 PR7085.2 139.66,46.32 139.62,46.35 PR7084.2 139.15,46.85 139.03,46.98 139.03,47.54 PC7065.1 139.06,48.62 138.76,48.62 137.75,49.64 PU7000.9
ISOLATEB: length 6
  TOP w0.102: U24.20 48.27,105.2 48.86,104.61 R510.2 49.68,105.09 50.38,105.09 50.96,104.51 R509.1 51.14,105.21 v1(51.01,105.35)
JTAG_TCK: length 6.3
  BOTTOM w0.102: U8.AE5 97.1,113.31 97.1,114.65 96.77,114.98 96.77,115.18 95.72,116.23 TP70.1
JTAG_TCK_PCH: length 12.1
  TOP w0.102: R17.2 103.03,70.12 100.95,68.03 97.09,68.03 96.79,67.73 94.65,67.73 93.85,68.53 v2(93.85,68.54) 93.85,68.55 94.3,69 TP50.1
  BOTTOM w0.102: v2(93.85,68.54) 93.85,68.55 94.03,68.73 U1.W6
JTAG_TDI: length 6.1
  BOTTOM w0.102: U8.AE6 97.95,113.31 97.95,113.83 97.75,114.03 97.75,115.4 96.99,116.17 96.99,118.32 TP72.1
JTAG_TDI_PCH: length 12.1
  TOP w0.102: R3.1 101.18,72.25 v2(101.36,72.07)
  BOTTOM w0.079: R13.2 100.52,72.45 100.58,72.4 101.2,72.4 101.36,72.25 v2(101.36,72.07) 101.23,71.94 100.93,71.94 100.43,71.44 100.43,71.12 100.26,70.96 100.26,69.98 100.17,69.89 100.17,69.55 99.26,68.64 98.44,68.64 98.23,68.85 98.23,69.07 98,69.3 97.35,69.3 97.23,69.43 96.9,69.58 95.92,69.58 95.74,69.76 95.74,69.99 95.57,70.17 95.29,70.17 95.05,69.93 U1.U5
JTAG_TDO: length 6
  BOTTOM w0.102: U8.AF6 98.43,113.83 97.98,114.29 97.98,115.5 97.47,116.01 97.47,117.84 97.72,118.1 98.36,118.1 TP73.1
JTAG_TDO_PCH: length 13.3
  TOP w0.102: R14.2 105.06,72.09 104.96,72 v1(104.15,72) 103.65,71.5 103.09,71.5 102.72,71.13 R4.1 102.36,71.13 101.97,70.74 101.97,70.21 101.5,69.74 101.5,69.61 100.43,68.54 95.8,68.54 v2(94.89,69.45)
  BOTTOM w0.079: U1.W5 94.68,69.23 v2(94.89,69.45)
JTAG_TMS: length 8.9
  BOTTOM w0.102: TP71.1 94.45,116.55 96.33,114.67 96.33,112.64 96.56,112.41 98.08,112.41 98.43,112.06 U8.AD6
JTAG_TMS_PCH: length 13.1
  TOP w0.102: R12.2 103.15,76.63 103.06,76.54 R5.1 102.37,76.54 102.09,76.26 101.58,76.26 100.71,77.13 97.55,77.13 v1(97.34,76.92) 96.33,75.91 96.33,74.05 arc(96.33,74.05) 96.33,74.05 95.95,73.67 95.95,73.24 v2(94.93,72.22)
  BOTTOM w0.079: v2(94.93,72.22) 94.68,71.97 U1.P5
JTAG_TRST#: length 5.7
  BOTTOM w0.102: R396.1 94.67,118.87 94.88,118.65 94.88,116.5 96.73,114.65 U8.AG4
JTAGX_PCH: length 24.6
  TOP w0.102: R11.2 104.2,73.52 104.08,73.39 v1(103.8,73.39) 103.55,73.39 103.06,72.9 v2(103.06,72.88) 102.75,73.19 R7.1 ; v2(93.89,71.32) 93.89,71.2 93.41,70.73 93.41,69.84 93.25,69.68 93.25,69.02 93.33,68.95 93.33,66.61 93.66,66.28 95.44,66.28 95.69,66.03 96.94,66.03 97.93,67.02 102.5,67.02 102.96,67.47 v2(103.11,67.47)
  IN3 w0.089: v2(103.11,67.47) 103.08,67.5 103.08,67.58 102.63,68.03 102.63,69.66 103.06,70.09 v2(103.06,72.88)
  BOTTOM w0.102: U1.P6 94.03,71.46 v2(93.89,71.32)
KB_BL_LED: length 19.9
  TOP w0.102: v2(193.66,20.36) 193.84,20.53 193.84,22.68 192.71,23.81 190.57,23.81 189.91,24.47 189.39,24.47 189.29,24.57 188.65,24.57 188.22,24.14 187.88,24.14 187.61,24.41 187.61,26.78 188.98,28.15 189.65,28.15 190.38,28.89 190.64,28.89 190.85,29.09 U37.113
  BOTTOM w0.102: v2(193.66,20.36) 194.21,20.36 194.72,20.86 195.39,20.86 195.73,20.52 Q31.2
KL_NO_EC: length 180.8
  TOP w0.102: PR9269.2 142.18,27.16 142.73,27.16 142.89,27.32 v1(143.01,27.32) 143.01,26.86 142.96,26.81 142.96,26.25 144.77,24.45 144.77,24.04 144.97,23.84 144.97,23.44 145.16,23.24 145.16,19.48 143.95,18.27 v2(143.72,18.27) ; v1(48.02,10.2) 48.02,10.26 47.63,10.65 PR9271.2 ; v2(196.79,18.42) 196.97,18.24 197.55,18.24 198.01,17.78 U37.70
  IN2 w0.089: v2(95.44,16.12) 95.64,16.32 96.3,16.32 96.52,16.53 97.43,16.53 98.23,15.73 99.73,15.73 100.41,15.05 107.5,15.05 108.72,16.27 112.96,16.27 114.31,17.61 118.7,17.61 119.08,17.99 120.55,17.99 121.38,18.81 123.86,18.81 124.29,18.38 128.2,18.38 128.55,18.72 129.36,18.72 130.43,17.66 136.78,17.66 137.6,18.48 143.24,18.48 143.44,18.27 v2(143.72,18.27) 144.27,18.27 144.86,17.69 148.97,17.69 149.53,18.24 163,18.24 163.58,18.82 164.64,18.82 165.07,18.39 169.98,18.39 170.23,18.64 172.63,18.64 173.41,19.42 177.94,19.42 178.31,19.79 179.38,19.79 179.45,19.86 180.39,19.86 180.51,19.74 181.15,19.74 181.72,19.17 183.97,19.17 184.25,19.44 186.47,19.44 186.52,19.4 187.03,19.4 187.36,19.73 190.69,19.73 192.54,17.87 193.08,17.87 193.94,18.73 196.48,18.73 v2(196.79,18.42)
  IN3 w0.089: v1(48.02,10.2) 47.54,10.68 47.54,11.23 47.94,11.64 47.94,12.45 49.64,14.14 49.93,14.14 50.26,14.47 72.1,14.47 73.4,15.77 79.75,15.77 80.19,15.32 81.07,15.32 81.25,15.51 81.25,17.53 84.16,20.43 89.14,20.43 89.98,19.59 93.13,19.59 95.18,17.54 95.18,16.37 v2(95.44,16.12)
L_SPK+: length 110.2
  IN2 w1.016: 207.86,30.42 208.11,30.16 208.11,28.18 209.21,27.09 209.21,25.13 207.78,23.71 206.94,23.71 204.48,21.25 204.48,19.59 203.41,18.53 203.41,15 202.7,14.29 199.78,14.29 198.05,12.56 191.38,12.56 191.07,12.86 189.99,12.86 189.24,13.61 183.94,13.61 182.42,15.14 181.41,15.14 181.19,15.35 115.58,15.35 114.67,14.44
  vias: v1(114.41,16.04) v1(114.68,13.78) v1(115.31,13.78) v1(209.1,32.93) v1(209.74,32.93)
L_SPK+_1:
  vias: v1(115.07,20.23) v1(115.07,19.59)
L_SPK-: length 113.7
  IN2 w1.016: 116.52,14.03 180.68,14.03 180.91,13.8 181.89,13.8 185.57,10.12 203.29,10.12 204.74,11.57 204.74,17.92 205.8,18.99 205.8,20.68 206.32,21.2 207.4,21.2 208.29,22.08 208.29,22.29 211.34,25.34 211.34,28.36 210.75,28.94 210.75,31.23
  vias: v1(116.04,13.78) v1(116.27,16.04) v1(116.67,13.78) v1(208.81,32.34) v1(209.44,32.32)
L_SPK-_1:
  vias: v1(116.75,19.59) v1(116.8,20.26)
LAD0_R: length 2.3
  BOTTOM w0.102: R673.1 191.98,17.39 191.47,16.88 CN17.58
LAD1: length 3
  BOTTOM w0.102: R2662.1 192.85,13.58 191.54,14.88 CN17.66
LAD2: length 21.8
  IN2 w0.089: v2(189.6,22.26) 189.35,22.01 188.68,22.01 188.45,22.24 187.8,22.24 187.21,22.84 186.88,22.84 186.35,23.37 185.99,23.37 185.53,22.92 182.88,22.92 181.98,23.81 181.15,23.81 v2(180.83,24.13)
  BOTTOM w0.102: v2(189.6,22.26) 189.39,22.06 189.39,19.53 189.06,19.2 189.06,18.45 189.11,18.4 189.11,15.89 188.71,15.49 188.71,14.67 189,14.38 CN17.68 ; v2(180.83,24.13) 180.83,24.07 180.43,23.66 179.85,23.66 R2663.1
LAD3: length 20.1
  IN2 w0.089: v2(188.91,22.39) 188.87,22.43 187.88,22.43 187.29,23.03 186.96,23.03 186.42,23.56 185.84,23.56 185.39,23.11 182.95,23.11 182.06,24 181.6,24 v2(181.42,24.19)
  BOTTOM w0.102: CN17.70 188.86,13.88 188.48,14.26 188.48,15.58 188.89,15.99 188.89,18.31 188.83,18.36 188.83,19.29 189.16,19.62 189.16,22.13 v2(188.91,22.39) ; v2(181.42,24.19) 181.37,24.24 R2664.1
LAN_AMBLED#: length 3.1
  TOP w0.102: TP74.1 46.65,109.63 45.24,108.21 U24.27
LAN_LED1: length 4.7
  TOP w0.102: TP75.1 47.52,110.17 45.64,108.29 U24.26
LAN_LED2: length 3.2
  TOP w0.102: TP76.1 47.75,109.5 47.17,109.5 46.04,108.37 U24.25
LAN_MCTG0: length 4.4
  TOP w0.102: v1(37.53,109.56) 37.93,109.16 v1(38.21,109.16)
  TOP w0.508: v1(37.53,109.56) R516.2
  BOTTOM w0.508: U25.24 37.9,110.77 37.53,110.4 v1(37.53,109.56)
LAN_MCTG1: length 5.1
  TOP w0.508: R517.2 34.73,110.1 35.11,109.71 v1(35.11,108.85)
  BOTTOM w0.508: v1(35.11,108.85) 35.11,109.71 34.9,109.93 U25.21
LAN_MCTG2: length 4.3
  TOP w0.102: v1(31.9,109.64) v1(31.9,108.9)
  TOP w0.508: v1(31.9,109.64) 31.9,110.27 31.68,110.48 R518.2
  BOTTOM w0.508: U25.18 v1(31.9,109.64)
LAN_MCTG3: length 3.4
  TOP w0.508: v1(28.9,109.64) 28.9,110.35 28.76,110.48 R519.2
  BOTTOM w0.508: v1(28.9,109.64) U25.15
LAN_WAKE#: length 25.4
  TOP w0.102: v2(77.5,45.64) 77.09,45.64 76.01,46.72 73.85,46.72 72.58,45.45 69.55,45.45 68.75,46.25 68.75,47.12 69.18,47.54 69.18,48.25 68.59,48.83 66.03,48.83 65.52,49.34 65.52,52.46 64.91,53.07 61.91,53.07 61.16,52.32 R36.1
  BOTTOM w0.079: U1.BU32 77.74,45.4 v2(77.5,45.64)
LAN_XTAL1: length 3.7
  TOP w0.102: R511.1 45.78,111.23 C638.2 45.77,111.25 45.27,111.75 45.27,112.74 Y4.1
LFRAME#_R: length 3.4
  BOTTOM w0.102: R675.1 192.67,14.34 192.03,14.97 192.03,15.38 191.53,15.88 CN17.62
LGATE1_CORE: length 9
  IN3 w0.508: v1(118.98,66.94) 118.98,66.61 119.74,65.85 123.35,65.85 v1(124.52,67.02)
  BOTTOM w0.254: PU7002.7 118.46,67.42 arc(118.46,67.42) 118.46,67.42 118.93,66.94 arc(118.93,66.94) 118.94,66.94 v1(118.98,66.94)
  BOTTOM w0.508: v1(124.52,67.02) 124.95,66.58 PQ7000.8
LGATE2_CORE: length 6.1
  IN3 w0.508: v1(133.21,50.1) 132.28,49.17 130.66,49.17 130.31,49.52 130.21,49.52 v1(129.78,49.95)
  BOTTOM w0.254: PU7001.7 133.36,49.95 v1(133.21,50.1)
  BOTTOM w0.508: v1(129.78,49.95) 129.35,50.37 PQ7001.8
LGATE_GT: length 8.3
  IN3 w0.508: v3(122.01,79.49) 122.34,79.16 125.61,79.16 126,79.54 v1(128.26,79.54)
  BOTTOM w0.254: PU7003.7 128.25,79.53 v1(128.26,79.54)
  BOTTOM w0.508: PQ7004.8 121.54,79.02 v3(122.01,79.49)
LGATE_SA: length 8.1
  IN3 w0.508: v1(141.51,44.32) 139.91,42.72 139.91,40.35 139.38,39.81 138.54,39.81 v1(138.49,39.86)
  BOTTOM w0.254: v1(141.51,44.32) 141.53,44.32 141.87,43.98 PU7004.7
  BOTTOM w0.508: v1(138.49,39.86) 137.93,39.86 PQ7003.4
LID#: length 380.7
  TOP w0.102: v1(25,52.69) 26.96,52.69 27.09,52.56 27.09,48.63 25.49,47.03 25.49,46.1 25.25,45.86 24.63,45.86 24.29,45.52 24.29,44.63 24.12,44.46 24.12,42.92 23.65,42.45 23.07,42.45 22.43,41.81 21.17,41.81 20.51,41.15 20.51,40.96 19.66,40.11 19.58,40.11 17.97,38.5 v1(17.97,38.21) ; v2(173.9,16.8) 174,16.7 174.71,16.7 174.84,16.83 174.84,17.82 176.52,19.49 176.52,20.43 175.93,21.02 175.93,21.7 175.74,21.89 175.49,21.89 175.12,22.26 175.12,23.68 174.71,24.09 173.42,24.09 173.31,24.2 173.31,25.63 173.77,26.1 179.36,26.1 179.54,26.28 179.54,27.24 180.17,27.88 R25315.2 ; HE1.1 34.3,123.94 35.47,122.77 v2(35.47,122.41) ; D3.1 53.55,105.37 52.66,106.26 52,106.26 51.42,106.84 v2(51.42,108.37) 51.42,108.76 R25370.2
  IN2 w0.089: v2(51.42,108.37) 51.42,108.01 52.87,106.56 52.87,105.48 51.98,104.58 47.92,104.58 47.63,104.3 47.63,103.35 48.89,102.09 48.89,100.57 47.86,99.53 44.63,99.53 43.4,98.3 31.72,98.3 29.29,95.87 29.29,94.66 26.71,92.08 26.71,89.76 24.14,87.19 24.14,84.84 24.84,84.14 25.43,84.14 25.81,83.76 25.81,82.56 24.97,81.73 24.97,74.1 25.16,73.92 25.16,54.44 25.03,54.32 25.03,52.74 25,52.72 v1(25,52.69) ; v2(173.9,16.8) 173.39,16.29 127.37,16.29 127.19,16.47 125.46,16.47 125.13,16.8 123.12,16.8 122.61,16.29 114.71,16.29 112.09,13.66 91.79,13.66 91,14.46 91,17.25 88.1,20.15 84.43,20.15 81.47,17.2 81.47,16.09 80.46,15.07 74.05,15.07 72.93,13.96 48.93,13.96 46.15,11.18 v1(46.15,9.8)
  IN3 w0.089: v1(17.97,38.21) 17.84,38.34 17.33,38.34 15.87,36.88 15.87,27.34 12.7,24.17 11.72,24.17 11.14,23.58 11.14,21.63 11.92,20.84 15.78,20.84 16.06,20.56 16.06,20.05 16.97,19.14 16.97,14.95 18.96,12.97 18.96,9.93 21.8,7.1 21.8,6.09 22.94,4.95 24.44,4.95 25.12,4.27 30.38,4.27 31.05,3.61 32.18,3.61 32.42,3.85 37.32,3.85 41.84,8.37 44.72,8.37 v1(46.15,9.8)
  BOTTOM w0.102: CN24.4 44.95,11 v1(46.15,9.8) ; v2(35.47,122.41) 35.52,122.41 36.39,123.28 37.17,123.28 37.82,122.63 D13091.2 39.11,122.63 39.28,122.8 C841.1 42.91,122.8 v1(42.91,122.8) 46.26,122.8 46.54,122.52 46.54,116.38 47.92,115.01 47.92,113.6 50.03,111.49 51.88,111.49 52.64,110.73 54.16,110.73 54.67,110.22 54.67,109.54 54.11,108.98 51.88,108.98 51.42,108.52 v2(51.42,108.37)
LID#_C: length 12.2
  TOP w0.102: C6572.1 182.8,28.57 181.24,28.57 v1(181.24,28.56) 180.65,27.97 R25315.1 ; C6572.1 183.48,28.99 183.81,28.99 184.36,28.45 184.86,28.45 185.48,27.82 186.61,27.82 187.11,27.32 187.44,27.32 187.72,27.59 187.72,28.07 188.24,28.59 188.34,28.59 188.85,29.09 U37.118 ; C6572.1 183.33,29.15 D65.1
LINE1-L: length 16.9
  TOP w0.381: v1(210.75,42.15) 211.14,42.53 C589.1
  IN1 w0.381: v1(210.75,42.15) 209.79,42.15 209.5,41.86 206.86,41.86 203.9,38.9 203.9,38.6 202.62,37.32 201.76,37.32 200.59,36.16 v1(200.59,35.29)
  BOTTOM w0.203: v1(200.59,35.29) 200.72,35.17 200.72,34.28 200.97,34.03 U20.22
LINE1-R: length 17.6
  TOP w0.381: C594.1 209.64,43.06 v1(208.98,42.4)
  IN1 w0.381: v1(208.98,42.4) 208.37,43.01 206.76,43.01 203.01,39.27 203.01,38.96 202.26,38.21 201.31,38.21 199.6,36.51 199.6,35.02 v1(200.09,34.53)
  BOTTOM w0.203: U20.21 200.86,33.63 200.09,34.4 v1(200.09,34.53)
LINE1-VREFO-L: length 15.1
  TOP w0.381: v1(212.25,44.74) 212.79,44.74
  IN1 w0.381: v2(204.46,37.5) 204.56,37.5 205.27,38.21 205.27,39.01 207.23,40.97 210.35,40.97 211.52,42.14 211.52,44.51 211.75,44.74 v1(212.25,44.74)
  BOTTOM w0.203: v2(204.46,37.5) 204.86,37.1 U20.31
LINE1-VREFO-R: length 17.2
  TOP w0.381: v2(203.92,37.2) 203.77,37.35 203.77,39.79 v1(211.57,47.59) 211.57,47.92 212.28,48.63 212.7,48.63
  BOTTOM w0.203: U20.30 204.46,36.82 204.08,37.2 v2(203.92,37.2)
LPC_LAD0: length 133.8
  TOP w0.102: v2(184.34,24.09) 184.34,24.22 183.98,24.58 U37.10
  IN1 w0.089: v2(184.34,24.09) 184.24,24.19 181.94,24.19 181.57,24.57 180.46,24.57 180.22,24.81 177.41,24.81 176.98,24.38 174.3,24.38 173.65,25.02 170.32,25.02 169.98,25.37 167.82,25.37 167.59,25.14 166.68,25.14 165.53,26.29 160.87,26.29 160.57,26.59 154.8,26.59 153.55,27.84 147.48,27.84 146.57,28.74 146.05,28.74 145.24,29.55 144.45,29.55 144.3,29.7 142.45,29.7 141.29,30.85 138.57,30.85 138.16,31.26 136.06,31.26 135.45,31.87 132.07,31.87 131.72,32.21 128.65,32.21 127.97,31.53 125.79,31.53 123.83,29.57 119.2,29.57 118.65,29.01 110.5,29.01 110.31,28.82 109.24,28.82 108.37,29.69 107.6,29.69 107.09,30.2 105.24,30.2 104.72,30.73 103.8,30.73 103.1,31.42 100.48,31.42 99.27,32.63 98.62,32.63 98.08,33.16 97.4,33.16 95.4,35.17 86.96,35.17 85.94,36.18 84.97,36.18 83.07,38.08 83.07,39.41 82.82,39.66 82.13,39.66 81.63,40.16 81.63,41.15 81.13,41.65 81.13,42.23 80.95,42.4 80.41,42.4 v2(79.98,41.97) ; v2(193.36,16.72) 193.36,16.9 193.05,17.21 191.86,17.21 191.3,17.77 191.3,19.24 187.95,22.59 v2(187.95,23.33)
  IN2 w0.089: v2(187.95,23.33) 187.92,23.33 187.63,23.61 187.2,23.61 186.67,24.15 185.6,24.15 185.14,23.69 184.56,23.69 184.34,23.91 v2(184.34,24.09)
  BOTTOM w0.079: U1.CA29 79.69,42.26 v2(79.98,41.97)
  BOTTOM w0.102: v2(193.36,16.72) 193.3,16.78 R673.2
LPC_LAD1: length 150.8
  TOP w0.102: v2(182.07,24.91) 182.09,24.91 182.16,24.98 U37.9
  IN1 w0.089: v2(182.07,24.91) 182.04,24.91 181.49,25.47 180.92,25.47 180.84,25.55 180.53,25.55 180.37,25.39 177.08,25.39 176.65,24.96 174.54,24.96 173.89,25.61 170.57,25.61 170.22,25.95 168.01,25.95 167.08,26.88 161.11,26.88 160.82,27.17 155.04,27.17 153.79,28.42 147.72,28.42 146.82,29.32 146.29,29.32 145.48,30.13 144.7,30.13 144.54,30.28 142.69,30.28 140.78,32.19 137.7,32.19 137.36,31.84 136.3,31.84 135.7,32.45 132.31,32.45 131.97,32.8 128.33,32.8 127.64,32.12 125.55,32.12 123.58,30.15 118.96,30.15 118.41,29.6 110.26,29.6 110.07,29.41 109.63,29.41 108.76,30.28 107.84,30.28 107.33,30.78 105.49,30.78 104.96,31.31 104.04,31.31 103.35,32 100.72,32 99.37,33.35 98.88,33.35 98.47,33.76 97.64,33.76 95.87,35.52 87.1,35.52 86.09,36.53 85.12,36.53 83.42,38.23 83.42,40.05 81.51,41.97 81.51,43.1 81.32,43.29 79.79,43.29 79.45,42.95 79.45,42.92 v2(79.42,42.89)
  IN2 w0.089: v2(182.07,24.91) 183.58,23.4 185.27,23.4 185.72,23.86 186.55,23.86 187.08,23.32 187.41,23.32 187.94,22.79 189.04,22.79 189.16,22.67 190.18,22.67 191.33,23.82 192.68,23.82 193.41,24.55 196.45,24.55 196.66,24.75 197.37,24.75 197.67,24.45 v2(197.67,24.12)
  BOTTOM w0.079: v2(79.42,42.89) 79.43,42.89 79.69,43.15 U1.BY29
  BOTTOM w0.102: v2(197.67,24.12) 197.76,24.03 197.76,23.26 198.44,22.59 198.44,15.78 198.33,15.68 198.33,15.18 198.44,15.07 198.44,14.46 198.05,14.08 195.48,14.08 194.98,13.58 R2662.2
LPC_LAD2: length 116.7
  TOP w0.102: v2(180.73,25.11) 180.99,25.11 181.44,25.56 182.29,25.56 182.48,25.38 U37.8
  IN1 w0.089: v2(180.73,25.11) 180.73,25.1 177.25,25.1 176.82,24.67 174.42,24.67 173.77,25.32 170.44,25.32 170.1,25.66 167.89,25.66 166.96,26.59 160.99,26.59 160.69,26.88 154.92,26.88 153.67,28.13 147.6,28.13 146.69,29.03 146.17,29.03 145.36,29.84 144.57,29.84 144.42,29.99 142.57,29.99 140.72,31.84 137.93,31.84 137.65,31.55 136.18,31.55 135.57,32.16 132.19,32.16 131.84,32.5 128.45,32.5 127.77,31.82 125.67,31.82 123.7,29.86 119.08,29.86 118.53,29.3 110.38,29.3 110.19,29.11 109.36,29.11 108.49,29.98 107.72,29.98 107.21,30.49 105.37,30.49 104.84,31.02 103.92,31.02 103.23,31.71 100.6,31.71 99.39,32.92 98.74,32.92 98.19,33.46 97.51,33.46 95.63,35.34 87.03,35.34 86.02,36.36 85.04,36.36 83.25,38.15 83.25,39.97 81.32,41.9 81.32,42.33 80.79,42.86 v2(80.78,42.86)
  BOTTOM w0.079: v2(80.78,42.86) 80.79,42.87 80.79,42.97 80.99,43.18 U1.BY27
  BOTTOM w0.102: R2663.2 179.74,24.32 179.97,24.55 180.17,24.55 v2(180.73,25.11)
LPC_LAD3: length 121.6
  TOP w0.102: U37.7 183.94,25.78 184.34,25.39 v2(184.34,25.13)
  IN1 w0.089: v2(184.34,25.13) 183.71,25.76 181.04,25.76 180.96,25.84 180.41,25.84 180.34,25.77 177.24,25.77 177.1,25.91 170.67,25.91 170.34,26.24 168.13,26.24 167.2,27.17 161.23,27.17 160.9,27.5 159.92,27.5 157.85,29.57 155.35,29.57 155.19,29.73 146.3,29.73 145.6,30.42 144.82,30.42 144.66,30.57 142.81,30.57 140.9,32.48 137.73,32.48 137.2,33.01 136.5,33.01 136.24,33.26 134.17,33.26 133.66,32.75 132.43,32.75 132.09,33.09 128.06,33.09 127.48,32.51 125.38,32.51 123.32,30.44 118.84,30.44 118.29,29.89 110.54,29.89 109.86,30.57 107.96,30.57 107.45,31.08 105.61,31.08 105.08,31.6 104.16,31.6 103.31,32.45 100.68,32.45 98.58,34.56 97.22,34.56 96.08,35.7 87.18,35.7 86.16,36.71 85.19,36.71 83.6,38.3 83.6,40.13 81.73,42 81.73,43.39 81.35,43.78 v2(80.78,43.78)
  BOTTOM w0.089: v2(80.78,43.78) 80.78,43.88 80.99,44.09 U1.BV27
  BOTTOM w0.102: R2664.2 181.41,25.1 181.67,25.36 182.21,25.36 182.43,25.13 v2(184.34,25.13)
LPC_LFRAME#: length 149.5
  TOP w0.102: v2(186.07,26.78) 185.46,26.18 U37.6
  IN1 w0.089: v2(186.07,26.78) 186.07,26.71 185.33,25.97 185.33,23.93 185.09,23.69 179.76,23.69 179.49,23.96 179.49,24.14 179.11,24.52 177.55,24.52 177.12,24.08 174.17,24.08 173.53,24.73 170.2,24.73 169.86,25.07 167.94,25.07 167.67,24.81 166.6,24.81 165.41,26 160.74,26 160.45,26.29 154.68,26.29 153.42,27.55 147.35,27.55 146.45,28.45 145.92,28.45 145.12,29.25 144.33,29.25 144.18,29.41 142.32,29.41 141.17,30.56 138.44,30.56 138.04,30.97 135.94,30.97 135.53,31.38 128.23,31.38 128.09,31.24 125.91,31.24 123.95,29.27 119.33,29.27 118.77,28.72 110.62,28.72 110.43,28.53 109.12,28.53 108.25,29.4 107.48,29.4 106.97,29.91 105.12,29.91 104.6,30.43 102.7,30.43 102.01,31.13 100.36,31.13 99.15,32.33 98.5,32.33 97.96,32.87 97.28,32.87 95.29,34.86 93.34,34.86 93.22,34.99 86.88,34.99 85.87,36 84.9,36 82.7,38.2 81.85,38.2 81.45,38.59 81.45,41.02 80.73,41.74 v2(80.73,41.97)
  IN3 w0.089: v2(195.98,17.97) 196.12,17.83 196.83,17.83 197.34,18.35 197.34,19.41 197.01,19.75 196.71,19.75 196.45,20.01 196.45,22.87 196.02,23.3 195.34,23.3 195.22,23.18 194.01,23.18 193.13,24.05 191.05,24.05 190.3,24.81 190.3,25.49 189.36,26.42 188.25,26.42 187.93,26.1 186.75,26.1 v2(186.07,26.78)
  BOTTOM w0.079: U1.CA28 80.34,42.36 v2(80.73,41.97)
  BOTTOM w0.102: R675.2 194.13,14.34 194.84,15.05 196.4,15.05 196.66,15.3 196.66,15.99 196.3,16.34 v1(196.3,17.05) 196.3,17.46 195.98,17.78 v2(195.98,17.97)
M_A_A0: length 36.1
  IN1 w0.102: v1(51.6,60.01) 51.55,59.96 50.07,59.96 49.97,60.06 49.97,60.46 50.07,60.57 50.76,60.57 50.86,60.67 50.86,60.87 50.76,60.97 50.07,60.97 49.97,61.07 49.97,63.99 50.46,64.48 55.26,64.48 55.76,64.98 56.65,64.98 58.99,67.32 65.45,67.32 66.06,67.93 70.17,67.93 70.35,67.75 v2(70.42,67.75)
  BOTTOM w0.076: v2(70.42,67.75) 70.42,67.67 70.55,67.55 70.55,67.47 70.7,67.32 70.7,67 70.98,66.72 74.03,66.72 74.21,66.53 74.63,66.53 U1.AC37
  BOTTOM w0.127: v1(51.6,60.01) 51.6,60.18 51.33,60.46 JDIM1.144
M_A_A1: length 37.9
  IN1 w0.102: v1(56.28,63.5) 56.03,63.75 56.03,64.1 56.1,64.17 56.53,64.17 56.87,63.83 57.01,63.83 57.14,63.95 57.14,64.28 57.28,64.42 57.54,64.42 57.7,64.59 57.7,64.86 57.9,65.06 58.13,65.06 58.38,65.32 58.38,65.54 58.61,65.77 59.04,65.77 59.19,65.92 59.19,66.36 59.35,66.51 59.7,66.51 59.8,66.41 59.8,66.15 59.91,66.05 60.11,66.05 60.21,66.15 60.21,66.41 60.31,66.51 60.51,66.51 60.62,66.41 60.62,65.97 60.72,65.86 60.92,65.86 61.02,65.97 61.02,66.41 61.12,66.51 61.33,66.51 61.43,66.41 61.43,65.91 61.53,65.81 61.73,65.81 61.84,65.91 61.84,66.41 61.94,66.51 62.14,66.51 62.24,66.41 62.24,65.91 62.34,65.81 62.55,65.81 62.65,65.91 62.65,66.41 62.75,66.51 62.95,66.51 63.05,66.41 63.05,66.13 63.16,66.03 63.36,66.03 63.46,66.13 63.46,66.41 63.56,66.51 63.77,66.51 63.87,66.41 63.87,66.15 63.97,66.05 64.17,66.05 64.27,66.15 64.27,66.41 64.38,66.51 64.58,66.51 64.68,66.41 64.68,65.91 64.78,65.81 64.99,65.81 65.09,65.91 65.09,66.41 65.19,66.51 65.59,66.51 65.7,66.41 65.7,66.07 65.8,65.97 66,65.97 66.1,66.07 66.1,66.51 66.2,66.61 66.41,66.61 66.51,66.51 66.51,66.07 66.61,65.97 66.81,65.97 66.92,66.07 66.92,66.51 67.02,66.61 67.22,66.61 67.32,66.51 67.32,66.16 67.42,66.06 67.63,66.06 67.73,66.16 67.73,66.51 67.83,66.61 68.03,66.61 68.13,66.51 68.13,66.28 68.24,66.18 68.44,66.18 68.54,66.28 68.54,66.51 68.64,66.61 69.17,66.61 69.7,67.14 70.29,67.14 v2(70.32,67.17)
  BOTTOM w0.076: v2(70.32,67.17) 69.66,67.17 69.53,67.04 69.53,66.48 69.7,66.32 69.95,66.32 70.03,66.39 70.03,66.58 70.1,66.66 70.38,66.66 70.46,66.58 70.46,66.39 70.53,66.32 73.15,66.32 73.38,66.55 73.96,66.55 74.14,66.37 74.39,66.37 74.6,66.16 74.86,66.16 74.99,66.23 75.21,66.23 U1.AC36
  BOTTOM w0.127: v1(56.28,63.5) 56.58,63.2 JDIM1.133
M_A_A2: length 38.9
  IN1 w0.102: v1(53.68,64.93) 53.68,65.29 53.78,65.39 54.19,65.39 54.29,65.29 54.29,64.98 54.39,64.88 54.6,64.88 54.7,64.98 54.7,65.29 54.8,65.39 56.47,65.39 58.8,67.73 65.28,67.73 65.89,68.34 70.39,68.34 71.31,67.42 v2(71.31,67.32)
  BOTTOM w0.076: U1.AC34 76.44,66.67 75.29,66.67 75.2,66.65 74.95,66.65 74.81,66.7 74.28,66.7 74.1,66.88 71.59,66.88 71.31,67.17 v2(71.31,67.32)
  BOTTOM w0.127: JDIM1.132 51.67,63.46 51.8,63.58 51.8,63.87 51.92,63.99 52.18,63.99 52.3,63.87 52.3,63 52.43,62.87 52.69,62.87 52.81,63 52.81,64.25 52.94,64.38 53.19,64.38 53.32,64.25 53.32,63 53.45,62.87 54.02,62.87 54.16,62.72 54.16,62.09 54.29,61.96 54.54,61.96 54.67,62.09 54.67,62.85 54.01,63.51 54.01,64.6 v1(53.68,64.93)
M_A_A3: length 38.3
  IN1 w0.102: v2(69.28,67.45) 68.85,67.02 65.72,67.02 65.62,66.92 59.18,66.92 56.84,64.58 55.93,64.58 55.43,64.07 50.93,64.07 50.83,63.97 50.83,62.8 50.93,62.7 51.65,62.7 51.75,62.8 51.75,63.51 51.85,63.61 54.9,63.61 v1(55,63.51)
  BOTTOM w0.076: U1.AC35 75.69,66.06 75.03,66.06 74.9,65.99 74.53,65.99 74.32,66.2 74.08,66.2 73.89,66.39 73.45,66.39 73.21,66.15 69.4,66.15 69.28,66.28 v2(69.28,67.45)
  BOTTOM w0.127: v1(55,63.51) 55.45,63.96 57.15,63.96 57.4,63.7 JDIM1.131
M_A_A4: length 37.9
  IN1 w0.102: v1(52.41,64.91) 51.98,65.34 50.66,65.34 50.35,65.65 50.35,67.64 50.97,68.26 53.27,68.26 53.49,68.49 53.49,69.61 54.05,70.17 55.17,70.17 56.05,71.04 57.14,71.04 58.41,72.31 64.23,72.31 64.95,71.59 70.61,71.59 72.66,69.54 v2(72.66,68.41)
  BOTTOM w0.076: v2(72.66,68.41) 72.92,68.41 73.69,67.65 74.41,67.65 74.6,67.46 74.86,67.46 74.93,67.49 75.23,67.49 75.31,67.46 75.52,67.46 75.57,67.49 75.82,67.49 U1.AA35
  BOTTOM w0.127: v1(52.41,64.91) 52.41,64.71 52.16,64.46 JDIM1.128
M_A_A5: length 37.3
  IN1 w0.102: v2(72.53,67.3) 72.53,67.83 72.43,67.93 71.94,67.93 71.73,67.72 71.59,67.72 71.05,68.25 71.05,69 70.98,69.07 70.73,69.07 70.4,68.74 65.72,68.74 65.11,68.13 58.62,68.13 56.28,65.8 53.61,65.8 53.42,65.6 52.3,65.6 52.16,65.75 51.12,65.75 51.01,65.85 51.01,66.11 50.91,66.22 50.86,66.22 50.76,66.32 50.76,66.52 50.86,66.62 50.91,66.62 51.01,66.72 51.01,67.73 51.14,67.85 51.37,67.85 51.5,67.73 51.5,66.41 51.69,66.22 v1(52.45,66.22)
  BOTTOM w0.076: v2(72.53,67.3) 72.53,67.13 72.6,67.05 72.83,67.05 73.08,67.3 73.19,67.3 73.44,67.05 74.16,67.05 74.35,66.86 74.85,66.86 74.98,66.81 75.17,66.81 75.26,66.84 75.64,66.84 75.72,66.92 U1.AB35
  BOTTOM w0.127: v1(52.45,66.22) 52.77,65.9 52.77,65.52 52.61,65.37 51.6,65.37 51.19,64.95 JDIM1.126
M_A_A6: length 38.1
  IN1 w0.102: v2(66.97,69.96) 65.22,69.96 65.12,69.86 61.72,69.86 61.62,69.96 61.62,70.17 61.54,70.24 61.29,70.24 61.21,70.17 61.21,69.87 61.11,69.76 60.95,69.76 60.85,69.86 59.13,69.86 58.76,70.22 58.62,70.22 58.48,70.09 58.48,69.77 57.75,69.04 57.48,69.04 57.16,69.35 56.71,69.35 56.32,68.96 56.32,68.81 56.11,68.61 56,68.61 55.93,68.54 55.22,68.54 55.12,68.44 55.12,68.24 55.33,68.03 55.33,67.7 55.09,67.46 55.09,67 55.17,66.92 55.17,66.78 54.65,66.25 v1(54.65,66.23)
  BOTTOM w0.076: v2(66.97,69.96) 66.97,68.49 67.04,68.41 67.35,68.41 67.43,68.34 67.43,68.01 67.51,67.93 67.74,67.93 67.81,68.01 67.81,68.34 67.89,68.41 68.12,68.41 68.19,68.34 68.19,68.01 68.27,67.93 68.5,67.93 68.57,68.01 68.57,68.34 68.65,68.41 68.95,68.41 69.02,68.49 69.02,68.72 69.1,68.79 72.3,68.79 72.33,68.77 73.04,68.77 73.25,68.55 73.25,68.31 73.75,67.81 74.65,67.81 U1.AA37
  BOTTOM w0.127: v1(54.65,66.23) 54.33,66.23 54.07,65.96 54.07,65.7 54.19,65.57 55.19,65.57 55.32,65.44 55.32,65.19 55.19,65.06 54.57,65.06 54.44,64.93 54.44,64.5 54.56,64.39 55.56,64.39 55.69,64.51 55.69,64.92 55.82,65.05 56.07,65.05 56.2,64.92 56.2,64.51 56.33,64.39 56.58,64.39 56.71,64.51 56.71,64.92 56.83,65.05 57.01,65.05 57.35,64.7 JDIM1.127
M_A_A7: length 38.2
  IN1 w0.102: v1(53.73,66.25) 53.73,66.6 53.85,66.71 54.47,66.71 54.69,66.93 54.69,67.41 54.48,67.61 54.48,67.75 54.71,67.98 54.71,68.81 54.85,68.95 55.73,68.95 56.56,69.77 57.32,69.77 57.43,69.65 57.79,69.65 58.07,69.94 58.07,70.25 58.87,71.05 59.07,71.05 59.19,70.92 59.19,70.37 59.3,70.27 59.5,70.27 59.6,70.37 59.6,70.57 59.68,70.65 60.06,70.65 60.13,70.57 60.13,70.37 60.24,70.27 60.44,70.27 60.54,70.37 60.54,70.95 60.66,71.07 60.94,71.07 61.02,70.98 61.02,70.83 61.18,70.67 61.37,70.67 61.53,70.83 61.53,70.94 61.66,71.07 61.82,71.07 61.94,70.94 61.94,70.75 62.1,70.6 62.1,70.37 62.2,70.27 62.4,70.27 62.5,70.37 62.5,70.57 62.58,70.65 62.83,70.65 62.91,70.57 62.91,70.37 63.01,70.27 63.21,70.27 63.32,70.37 63.32,70.57 63.39,70.65 63.74,70.65 63.82,70.57 63.82,70.37 63.92,70.27 64.16,70.27 64.26,70.37 64.56,70.37 64.67,70.27 64.91,70.27 65.01,70.37 68.03,70.37 68.13,70.27 v2(68.13,69.96)
  BOTTOM w0.076: U1.AA36 75.22,67.89 75.03,67.89 74.83,67.97 74.83,67.98 73.82,67.98 73.43,68.37 73.43,68.63 73.12,68.93 72.4,68.93 72.37,68.96 68.4,68.96 68.32,68.88 68.32,68.77 68.25,68.69 68.02,68.69 67.94,68.77 67.94,68.88 67.87,68.96 67.49,68.96 67.37,69.07 67.37,69.46 67.5,69.58 68.06,69.58 68.13,69.66 v2(68.13,69.96)
  BOTTOM w0.127: JDIM1.122 51.24,65.95 51.4,65.8 51.73,65.8 51.85,65.92 51.85,66.53 52.24,66.92 52.39,66.92 52.64,66.66 53.7,66.66 53.83,66.53 53.83,66.35 v1(53.73,66.25)
M_A_A8: length 35.7
  IN1 w0.102: v1(55.94,66.25) 55.94,66.25 55.97,66.28 56.07,66.28 56.6,66.81 56.6,67.42 56.79,67.61 57.47,67.61 58.4,68.54 58.78,68.54 58.88,68.64 58.88,68.95 58.98,69.05 59.18,69.05 59.29,68.95 59.29,68.64 59.39,68.54 64.01,68.54 64.12,68.64 64.12,68.95 64.22,69.05 64.5,69.05 64.6,68.95 64.6,68.67 64.73,68.54 64.91,68.54 65.04,68.67 65.04,68.89 65.19,69.05 65.45,69.05 65.55,69.15 70.23,69.15 70.69,69.61 71.33,69.61 71.56,69.84 71.78,69.84 72.2,69.42 72.2,69.18 72.1,69.07 71.55,69.07 71.49,69.01 71.49,68.44 v2(71.46,68.41)
  BOTTOM w0.076: U1.AB34 76.11,67.32 75.61,67.32 75.56,67.3 75.28,67.3 75.2,67.32 74.96,67.32 74.9,67.3 74.53,67.3 74.34,67.48 73.62,67.48 73.04,68.06 72.1,68.06 72.08,68.05 71.7,68.05 71.63,67.97 71.63,67.75 71.55,67.68 71.27,67.68 71.19,67.75 71.19,67.97 71.12,68.05 70.86,68.05 70.8,68.1 69.48,68.1 69.4,68.19 69.4,68.49 69.48,68.57 71.31,68.57 v2(71.46,68.41)
  BOTTOM w0.127: v1(55.94,66.25) 55.86,66.25 55.71,66.1 55.71,65.63 55.85,65.48 57.19,65.48 57.47,65.2 JDIM1.125
M_A_A9: length 36.9
  IN1 w0.102: v1(54.19,67.12) 53.8,67.5 53.8,67.65 54.31,68.15 54.31,69.22 54.44,69.35 55.54,69.35 56.38,70.19 57.44,70.19 58.75,71.5 59.19,71.5 59.63,71.06 59.97,71.06 60.4,71.49 61.99,71.49 62.42,71.06 64.33,71.06 64.61,70.78 68.2,70.78 68.38,70.59 68.59,70.59 68.77,70.78 69.13,70.78 69.3,70.61 69.3,70.47 68.79,69.96 v2(68.74,69.96)
  BOTTOM w0.076: v2(68.74,69.96) 68.74,70.27 68.67,70.34 68.01,70.34 67.88,70.47 67.88,70.73 68.01,70.85 69.11,70.85 69.19,70.78 69.19,70.55 69.27,70.47 69.5,70.47 69.57,70.55 69.57,70.78 69.65,70.85 69.88,70.85 69.95,70.78 69.95,70.55 70.03,70.47 70.26,70.47 70.33,70.55 70.33,70.78 70.41,70.85 70.79,70.85 72.19,69.46 72.58,69.46 72.6,69.43 73.5,69.43 73.86,69.06 74.22,69.06 74.6,68.68 74.85,68.68 75.02,68.75 75.21,68.75 U1.W36
  BOTTOM w0.127: v1(54.19,67.12) 54.19,66.87 54.32,66.74 54.5,66.74 54.75,66.99 54.95,66.99 55.25,66.7 56.14,66.7 56.39,66.45 56.39,66.04 56.51,65.91 57.22,65.91 57.52,66.2 JDIM1.121
M_A_A10: length 35.8
  IN1 w0.102: v1(53.6,57.77) 53.6,57.9 54.79,59.09 57.14,59.09 60.38,62.33 67.2,62.33 67.31,62.22 72.38,62.22 73.26,63.11 73.72,63.11 75.28,64.66 75.28,64.91 75.75,65.38 75.75,66.38 77.28,67.91 77.86,67.91 78.09,68.14 v2(78.09,68.41)
  BOTTOM w0.076: v2(78.09,68.41) 78.09,68.23 U1.Y31
  BOTTOM w0.127: JDIM1.146 51.17,57.95 51.37,58.15 51.37,58.53 51.5,58.66 52.19,58.66 52.32,58.53 52.32,58.34 52.44,58.22 52.7,58.22 52.82,58.34 52.82,58.53 52.95,58.66 53.47,58.66 53.6,58.53 v1(53.6,57.77)
M_A_A11: length 34.6
  IN1 w0.102: v2(70.5,69.99) 70.8,70.29 70.8,70.82 70.44,71.18 70.17,71.18 70.04,71.06 70.04,70.85 69.91,70.73 69.76,70.73 69.3,71.18 64.78,71.18 64.06,71.91 58.58,71.91 57.28,70.61 56.19,70.61 55.34,69.76 54.21,69.76 53.9,69.45 53.9,68.32 53.65,68.07 53.43,67.85 52.38,67.85 52.16,67.64 52.16,67.22 52.26,67.12 v1(52.92,67.12)
  BOTTOM w0.076: v2(70.5,69.99) 71.19,69.29 72.51,69.29 72.54,69.26 73.43,69.26 73.8,68.9 74.15,68.9 74.53,68.51 74.88,68.51 75.05,68.58 75.45,68.58 75.55,68.68 76.44,68.68 U1.W34
  BOTTOM w0.127: JDIM1.120 51.19,66.46 51.38,66.65 51.38,66.67 52.22,67.51 52.74,67.51 52.92,67.33 v1(52.92,67.12)
