# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_RXN14_SSD_C: length 2
  BOTTOM w0.102: CN16.17 35.85,10.4 35.71,10.54 35.71,10.72 35.49,10.94 35.49,11.06 R2654.2
PCIE_RXN15_SSD: length 99.1
  IN3 w0.089: v2(94.93,51.88) 94.93,52.03 94.5,52.46 93.51,52.46 93.36,52.61 88.16,52.61 87.84,52.28 87.53,52.28 84.54,49.3 84.54,48.89 83.65,48 83.65,42.18 83.4,41.93 83.4,40.07 83.04,39.7 83.04,38.49 82.83,38.29 82.1,38.29 82.03,38.23 80.1,38.23 79.73,37.86 78.9,37.86 78.87,37.82 78.38,37.82 78.34,37.86 76.92,37.86 76.83,37.77 76.19,37.77 75.85,37.43 75.29,37.43 74.01,36.15 71.8,36.15 70.53,34.87 70.12,34.87 69.36,34.12 68.17,34.12 67.9,33.84 65.89,33.84 65.47,33.43 61.23,33.43 59.25,31.45 58.1,31.45 57.81,31.16 54.66,31.16 54.44,30.94 53.5,30.94 52.79,30.23 50.46,30.23 49.74,30.95 48.42,30.95 47.22,29.75 45.39,29.75 44.28,28.64 42.02,28.64 39.28,25.89 32.37,25.89 30.52,24.04 30.52,23.41 30.06,22.95 30.06,20.62 29.58,20.14 29.58,14.92 31.43,13.07 31.43,12.31 32.07,11.67 32.4,11.67 32.78,12.04 32.78,12.25 v1(32.96,12.44)
  BOTTOM w0.079: U1.BG5 94.68,51.6 94.93,51.85 v2(94.93,51.88)
  BOTTOM w0.102: R2656.1 32.95,12.43 v1(32.96,12.44)
PCIE_RXN15_SSD_C: length 1.9
  BOTTOM w0.102: R2656.2 32.95,11.13 32.71,10.89 32.71,10.62 32.85,10.48 CN16.29
PCIE_RXN16_SSD: length 97.9
  IN3 w0.089: v2(94.93,52.87) 94.93,52.92 94.42,53.43 92.52,53.43 92.34,53.61 87.41,53.61 83.85,50.04 83.85,49.26 82.66,48.07 82.66,41.81 82.76,41.71 82.76,40.3 81.29,38.82 76.34,38.82 75.58,38.07 75.07,38.07 73.75,36.75 71.54,36.75 70.26,35.47 69.8,35.47 69.07,34.73 68.35,34.73 68.22,34.86 66.06,34.86 65.22,34.02 60.98,34.02 59,32.05 57.85,32.05 57.58,31.77 53.79,31.77 53.55,31.54 50.3,31.54 49.72,32.12 46.89,32.12 44.3,29.53 42.07,29.53 39.07,26.53 37.15,26.53 36.57,27.11 35.44,27.11 34.89,26.55 32.18,26.55 29.91,24.28 29.91,23.65 29.4,23.14 29.4,20.82 28.4,19.83 28.4,14.92 29.3,14.02 29.3,12.34 v1(29.21,12.25)
  BOTTOM w0.079: v2(94.93,52.87) 94.68,52.62 U1.BE5
  BOTTOM w0.102: R646.1 29.14,12.19 v1(29.21,12.25)
PCIE_RXN16_SSD_C: length 1.9
  BOTTOM w0.102: R646.2 29.4,11.06 29.4,10.83 29.49,10.74 29.49,10.51 29.35,10.37 CN16.43
PCIE_RXN_LAN_L: length 3.3
  TOP w0.102: C637.1 48.19,102.62 48.07,102.5 47.74,102.5 47.64,102.61 47.64,103.97 47.21,104.4 U24.18
PCIE_RXP9_LAN: length 104.4
  TOP w0.102: C640.2 49.19,102.07 49.82,102.07 50.1,102.35 50.1,102.86 v1(50.23,102.98)
  IN3 w0.089: v1(50.23,102.98) 50.23,102.71 50.36,102.58 50.7,102.58 50.84,102.71 50.84,103.16 51.17,103.49 56.07,103.49 58.02,101.54 58.02,100.3 59.84,98.49 60.85,98.49 61.94,97.4 76.8,97.4 77.77,96.43 80.36,96.43 82.49,94.3 85.56,94.3 88.87,90.99 89.46,90.99 92.39,88.06 92.39,85.58 92.77,85.2 92.77,82.85 93.53,82.09 93.53,81.43 94.7,80.26 94.7,79.12 96.1,77.72 96.1,76.41 97.6,74.92 97.6,72.12 97.47,72 97.47,60.62 97.78,60.31 98.08,60.31 100.47,57.92 100.47,56.11 101.12,55.47 101.12,53.72 101.31,53.54 101.31,52.16 100.35,51.2 100.35,50.62 99.75,50.02 99.75,48.08 99.02,47.36 97.71,47.36 95.96,45.6 94.77,45.6 94.5,45.88 94.5,46.19 94.34,46.34 v2(94.34,46.34)
  BOTTOM w0.079: U1.BP6 94.03,46.69 94.34,46.37 v2(94.34,46.34)
PCIE_RXP10_WLAN: length 131.9
  IN1 w0.089: v1(186.4,33.31) 186.7,33.01 186.7,32.96 186.41,32.67 182.21,32.67 182.04,32.85 180.97,32.85 180.63,32.5 175.61,32.5 175.56,32.45 174.17,32.45 174.12,32.5 171.59,32.5 171.08,32 170.47,32 169.93,32.54 168.57,32.54 168.14,32.11 164.93,32.11 164.78,32.26 164.06,32.26 163.17,33.15 161.89,33.15 160.92,34.11 159.64,34.11 158.88,34.87 156.75,34.87 156.15,34.28 148.65,34.28 148.2,34.73 147.89,34.73 147.78,34.84 147.61,34.84 147.33,35.11 147.05,35.11 146.15,36.02 145.86,36.02 145.53,36.34 145.53,36.68 141,41.21 140.35,41.21 140.14,41.42 140.14,42.91 139.81,43.24 138.19,43.24 137.73,42.79 137.73,42.06 137.39,41.72 136.5,41.72 133.76,38.98 125.56,38.98 124.36,37.78 121.69,37.78 120.33,39.14 118.02,39.14 117.57,39.6 115.1,39.6 114.35,40.35 113.78,40.35 112.41,41.72 106.56,41.72 105.74,40.91 102.41,40.91 100.1,43.22 96.36,43.22 96.16,43.42 93.15,43.42 92.58,43.99 91.73,43.99 91.37,44.34 91.37,44.59 92.01,45.22 92.01,45.71 92.52,46.21 93.03,46.21 93.53,46.72 93.97,46.72 94.17,46.93 94.83,46.93 94.93,47.03 94.93,47.23 v2(94.85,47.31)
  BOTTOM w0.079: U1.BN5 94.65,47.76 94.55,47.66 94.55,47.53 94.77,47.31 v2(94.85,47.31)
  BOTTOM w0.102: CN17.41 183.95,21.13 184.23,20.85 184.69,20.85 184.78,20.75 185.67,20.75 186.02,21.09 186.02,22.3 186.6,22.88 186.6,24.85 187.01,25.26 187.01,25.61 186.47,26.14 186.47,26.96 186.24,27.19 186.24,29.3 185.52,30.02 185.52,31.54 185.87,31.89 185.87,32.35 186.5,32.98 186.5,33.21 v1(186.4,33.31)
PCIE_RXP13_SSD: length 99.7
  IN3 w0.089: v2(94.36,50.01) 93.82,50.56 93.38,50.56 93.34,50.6 90.7,50.6 90.52,50.79 88.93,50.79 86.02,47.87 86.02,43.43 85.7,43.12 85.58,43.12 85.05,42.59 85.05,39.18 85.2,39.03 85.2,37.79 84.89,37.47 83.73,37.47 82.9,36.65 80.64,36.65 80.23,36.24 79.3,36.24 78.77,35.72 77.47,35.72 77.2,35.44 75.36,35.44 74.88,34.96 74.12,34.96 73.37,34.2 73.37,33.06 73.08,32.78 69.79,32.78 69.51,32.5 67.12,32.5 66.18,31.56 64.88,31.56 64.7,31.74 61.25,31.74 59.73,30.21 59.26,30.21 58.88,29.83 56.16,29.83 55.36,29.03 55.36,27.88 54.9,27.42 53.93,27.42 53.53,27.03 51.95,27.03 51.47,26.55 47.85,26.55 47.01,25.72 41.51,25.72 40.47,24.67 32.84,24.67 31.74,23.57 31.74,22.6 31.35,22.22 31.35,15.58 33.87,13.07 34.61,13.07 35.29,12.38 35.29,12.04 35.72,11.62 36.24,11.62 v2(36.31,11.56)
  BOTTOM w0.079: v2(94.36,50.01) 94.68,49.7 U1.BK5
  BOTTOM w0.102: v2(36.31,11.56) 37.29,11.56 37.95,12.22 38.35,12.22 38.48,12.09 38.48,11.96 R2653.1
PCIE_RXP13_SSD_C: length 1.9
  BOTTOM w0.102: CN16.7 38.35,10.33 38.49,10.48 38.49,10.7 38.56,10.77 38.56,10.91 38.29,11.19 R2653.2
PCIE_RXP14_SSD: length 97.5
  IN3 w0.089: v1(34.22,11.81) 34.03,12 33.84,12 33.46,12.37 33.46,12.63 30.75,15.34 30.75,22.49 31.13,22.87 31.13,23.81 32.6,25.28 40.19,25.28 41.28,26.38 41.79,26.38 42.18,26.77 42.18,27.27 42.78,27.88 44.37,27.88 45.54,29.04 48.24,29.04 48.8,29.6 55.04,29.6 55.98,30.54 58.04,30.54 58.35,30.85 59.52,30.85 61.12,32.45 65.42,32.45 65.55,32.32 65.97,32.32 66.76,33.11 69.2,33.11 70.37,34.28 71.4,34.28 72.08,34.95 72.48,34.95 73.08,35.55 74.38,35.55 74.88,36.05 76.46,36.05 76.67,36.27 76.67,36.6 76.97,36.89 77.59,36.89 78.17,36.32 78.53,36.32 79.05,36.84 79.97,36.84 80.75,37.62 82.31,37.62 82.38,37.68 83.07,37.68 83.63,38.24 83.63,39.44 84.01,39.81 84.01,40.5 84.42,40.91 84.42,42.18 84.26,42.33 84.26,47.75 85.19,48.68 85.19,49.05 87.72,51.58 93.48,51.58 93.57,51.5 93.79,51.5 v2(94.36,50.93)
  BOTTOM w0.079: v2(94.36,50.93) 94.36,50.85 U1.BJ5
  BOTTOM w0.102: v1(34.22,11.81) 34.43,12.01 34.6,12.01 34.8,12.22 35.15,12.22 35.2,12.16 35.2,11.98 R2655.1
PCIE_RXP14_SSD_C: length 2
  BOTTOM w0.102: R2655.2 35.27,11.03 35.27,10.85 35.49,10.63 35.49,10.5 35.35,10.35 CN16.19
PCIE_RXP15_SSD: length 99
  IN3 w0.089: v2(94.34,51.84) 94.47,51.84 94.55,51.93 94.55,52.12 94.42,52.26 93.43,52.26 93.28,52.41 88.24,52.41 87.92,52.08 87.62,52.08 84.75,49.21 84.75,48.8 83.86,47.92 83.86,42.1 83.6,41.85 83.6,39.98 83.24,39.62 83.24,38.41 82.92,38.09 82.18,38.09 82.12,38.02 80.19,38.02 79.82,37.65 78.99,37.65 78.95,37.62 78.3,37.62 78.25,37.66 77,37.66 76.91,37.57 76.28,37.57 75.93,37.22 75.37,37.22 74.1,35.95 71.89,35.95 70.61,34.67 70.2,34.67 69.45,33.91 68.25,33.91 67.98,33.64 65.97,33.64 65.55,33.22 61.31,33.22 59.34,31.25 58.18,31.25 57.9,30.96 54.75,30.96 54.53,30.74 53.58,30.74 52.87,30.03 50.38,30.03 49.65,30.75 48.51,30.75 47.31,29.55 45.48,29.55 44.36,28.43 42.11,28.43 39.36,25.69 32.45,25.69 30.72,23.96 30.72,23.33 30.26,22.87 30.26,20.53 29.78,20.05 29.78,15.01 31.63,13.15 31.63,12.39 32.15,11.87 32.32,11.87 32.57,12.13 32.57,12.33 32.46,12.44 v1(32.19,12.44)
  BOTTOM w0.079: v2(94.34,51.84) 94.37,51.82 94.37,51.4 94.3,51.32 94.11,51.32 94.03,51.41 U1.BG6
  BOTTOM w0.102: v1(32.19,12.44) 32.34,12.44 32.57,12.2 32.57,11.95 32.39,11.77 R2657.1
PCIE_RXP15_SSD_C: length 1.9
  BOTTOM w0.102: CN16.31 32.35,10.48 32.49,10.62 32.49,10.84 32.19,11.13 R2657.2
PCIE_RXP16_SSD: length 97.8
  IN3 w0.089: v2(94.34,52.84) 94.5,53 94.5,53.06 94.34,53.22 92.43,53.22 92.26,53.4 87.5,53.4 84.05,49.96 84.05,49.18 82.86,47.99 82.86,41.9 82.97,41.79 82.97,40.21 81.38,38.62 76.42,38.62 75.67,37.87 75.15,37.87 73.83,36.54 71.62,36.54 70.34,35.27 69.89,35.27 69.15,34.53 68.26,34.53 68.13,34.66 66.14,34.66 65.31,33.82 61.06,33.82 59.09,31.84 57.94,31.84 57.66,31.57 53.87,31.57 53.64,31.34 50.21,31.34 49.63,31.91 46.98,31.91 44.38,29.32 42.15,29.32 39.15,26.33 37.06,26.33 36.48,26.9 35.52,26.9 34.97,26.35 32.27,26.35 30.11,24.19 30.11,23.56 29.6,23.05 29.6,20.74 28.61,19.74 28.61,15 29.5,14.11 29.5,12.53 29.77,12.25 v1(29.84,12.25)
  BOTTOM w0.079: U1.BE6 94.1,52.31 94.19,52.31 94.45,52.56 94.45,52.74 v2(94.34,52.84)
  BOTTOM w0.102: v1(29.84,12.25) 29.7,12.11 29.7,11.9 29.82,11.77 R647.1
PCIE_RXP16_SSD_C: length 1.9
  BOTTOM w0.102: CN16.41 29.85,10.37 29.71,10.51 29.71,10.83 29.61,10.92 29.61,11.03 R647.2
PCIE_RXP_LAN_L: length 3.3
  TOP w0.102: U24.17 47.31,104 47.42,103.88 47.42,102.52 47.65,102.28 48.03,102.28 48.19,102.13 C640.1
PCIE_TXN9_LAN: length 114.1
  TOP w0.102: v1(45.4,102.22) 45.17,102.22 45.11,102.28 45.11,102.64 45.24,102.77 U24.14
  IN3 w0.089: v1(45.4,102.22) 45.4,102.02 45.5,101.92 45.58,101.92 45.86,101.64 45.86,100.78 46.58,100.06 49.46,100.06 50.1,100.7 52.07,100.7 52.94,101.57 55.32,101.57 55.97,100.93 55.97,99.31 58.9,96.38 60.04,96.38 61.21,95.21 64.61,95.21 64.92,95.52 75.73,95.52 78.75,92.49 80.51,92.49 81.81,91.2 86.02,91.2 88.2,89.01 88.58,89.01 90.16,87.44 90.16,85.15 90.82,84.49 90.82,81.52 92.47,79.87 92.47,75.38 92.98,74.87 94.63,74.87 95.67,73.82 95.67,72.77 95.52,72.62 95.52,71.82 95.49,71.79 95.49,71.54 95.52,71.51 95.52,70.85 95.59,70.78 95.59,69.48 95.49,69.38 95.49,66.31 95.6,66.2 95.6,64.62 95.49,64.52 95.49,61.48 95.59,61.38 95.59,60.71 95.49,60.61 95.49,59.81 95.34,59.66 95.34,59.17 94.75,58.58 94.75,57.31 96.61,55.46 100.11,55.46 100.49,55.08 100.49,53.41 100.66,53.24 v2(100.66,52.35)
  BOTTOM w0.102: C200.2 101.14,45.74 101.29,45.74 101.88,46.33 104.52,46.33 105.05,46.86 105.69,46.86 106.16,47.33 106.16,49.26 104.05,51.37 100.95,51.37 100.47,51.85 100.47,52.14 100.66,52.33 v2(100.66,52.35)
PCIE_TXN9_LAN_C: length 4.2
  BOTTOM w0.079: C200.1 100.22,45.68 99.88,45.68 99.52,46.04 97.99,46.04 97.82,46.21 97.3,46.21 97.06,46.44 97.06,46.52 97,46.58 U1.BR2
PCIE_TXN10_WLAN: length 132
  IN3 w0.089: v2(105.42,47.84) 105.98,47.28 106.42,47.28 107.45,46.25 107.45,43.65 107.17,43.37 106.59,43.37 103.92,40.7 103.64,40.7 103.36,40.42 103.36,39.23 104.68,37.91 104.91,37.91 105.33,37.49 105.33,37.21 106.21,36.33 106.21,34.81 106.65,34.37 106.65,31.66 108.49,29.81 108.49,29.22 110.07,27.65 110.07,24.88 109.59,24.4 109.59,22.67 110.55,21.7 113.19,21.7 114.29,22.8 114.29,23.88 114.74,24.34 118.8,24.34 119.33,24.87 123.03,24.87 123.37,24.52 125.78,24.52 126.5,25.23 135.21,25.23 135.26,25.28 136.96,25.28 139.13,27.46 139.64,27.46 139.75,27.57 141.41,27.57 142.21,28.38 145.44,28.38 146.38,27.44 153.69,27.44 154.72,26.4 160.04,26.4 160.27,26.17 168.02,26.17 168.25,26.4 170.73,26.4 171.44,27.11 179.94,27.11 180.52,27.7 183.17,27.7 183.52,27.35 184.22,27.35 v2(184.39,27.52)
  BOTTOM w0.079: 100.3,47.49 100.25,47.44 100.05,47.44 99.13,46.52 98.2,46.52 98.02,46.7 97.91,46.7 97.59,47.02 97.29,47.02 97.11,46.96 97.05,46.95 96.97,46.96 96.74,47.02 96.53,46.99 96.29,46.87 95.77,46.8 U1.BR4
  BOTTOM w0.102: v2(184.39,27.52) 184.39,26.83 184.71,26.52 184.71,26.09 185.33,25.46 185.33,24.84 185.2,24.71 183.33,24.71 182.39,23.77 181.15,23.77 C203.2 ; v2(105.42,47.84) 105.01,48.25 104.51,48.25 103.43,47.17 101.87,47.17 101.42,47.61 100.42,47.61 100.3,47.49
PCIE_TXN10_WLAN_C: length 3
  BOTTOM w0.102: CN17.37 182.41,22.13 182.35,22.19 181.21,22.19 180.86,22.54 180.86,22.87 C203.1
PCIE_TXN13_SSD: length 91.8
  TOP w0.102: C788.1 35.75,10.28 35.75,12.26 36.11,12.62 36.77,12.62 v1(36.95,12.44)
  IN3 w0.089: v1(36.95,12.44) 37.07,12.56 38.28,12.56 39.4,13.68 40.38,13.68 41.85,15.14 41.85,15.77 43.67,17.59 44.73,17.59 48.12,20.98 48.12,21.17 49.75,22.8 53.33,22.8 54.73,24.2 58.73,24.2 59.35,24.82 60.24,24.82 61,25.58 64.5,25.58 64.84,25.93 66.75,25.93 66.94,26.12 68.89,26.12 70.25,24.76 70.5,24.76 70.79,24.48 73.09,24.48 73.48,24.87 73.62,24.87 75.14,26.38 75.14,30.11 76.67,31.63 80.51,31.63 81.55,32.67 81.55,32.96 81.77,33.18 82.7,33.18 82.92,33.41 84.06,33.41 85.51,34.86 86.46,34.86 87.4,35.8 89.3,35.8 90.64,37.14 90.64,42.3 91.37,43.04 91.37,44.86 92.01,45.49 92.01,45.71 93.04,46.73 95.44,46.73 95.58,46.6 96.1,46.6 96.58,47.08 96.58,47.97 96.99,48.37 98.06,48.37 98.11,48.32 98.13,48.32 v2(98.23,48.22)
  BOTTOM w0.079: U1.BM4 96.01,48.2 96.54,48.2 96.74,48.4 98.05,48.4 v2(98.23,48.22)
PCIE_TXN13_SSD_C: length 7
  TOP w0.102: v1(36.55,6.53) 36.27,6.81 36.27,7.06 35.6,7.73 35.6,8.85 C788.2
  BOTTOM w0.102: CN16.11 37.35,8.47 37.21,8.33 37.21,8.04 36.26,7.09 36.26,6.82 v1(36.55,6.53)
PCIE_TXN14_SSD: length 92.7
  TOP w0.102: C790.1 33.97,10.73 34.15,10.91 34.28,10.91 34.94,11.57 34.94,12.33 36.13,13.53 v1(36.13,14.06)
  IN3 w0.089: v2(99.1,49.72) 98.94,49.87 98.94,50.11 98.7,50.35 97.66,50.35 95.2,47.89 92.13,47.89 91.2,46.96 91.2,45.83 90.21,44.85 90.21,43.43 89.35,42.56 89.35,36.98 89.03,36.66 87.13,36.66 86.13,35.66 84.51,35.66 83.71,34.86 81.41,34.86 80.93,34.38 80.22,34.38 79.54,33.7 79.54,33.18 78.85,32.5 75.57,32.5 74.06,30.99 70.53,30.99 68.31,28.76 67.06,28.76 65.41,27.11 63.46,27.11 63.01,26.66 62.04,26.66 61.86,26.83 60.44,26.83 59.93,26.33 59.93,25.82 59.73,25.62 59.02,25.62 58.4,25 54.25,25 53.7,24.45 53.19,24.45 52.76,24.01 49.81,24.01 47.31,21.51 47.31,21.3 44.59,18.58 43.52,18.58 41.05,16.11 41.05,15.48 40.05,14.48 39.06,14.48 38.49,13.9 37.18,13.9 36.99,13.7 36.49,13.7 v1(36.13,14.06)
  BOTTOM w0.079: U1.BL2 97.01,48.74 97.61,48.74 98.05,49.18 98.65,49.18 99.1,49.62 v2(99.1,49.72)
PCIE_TXN14_SSD_C: length 4.3
  TOP w0.102: v1(34.49,7.71) 34.21,7.99 34.21,8.31 33.57,8.95 33.57,9.13 33.69,9.25 C790.2
  BOTTOM w0.102: v1(34.49,7.71) 34.21,7.99 34.21,8.45 34.35,8.59 CN16.23
PCIE_TXN15_SSD: length 111.6
  TOP w0.102: C792.1 31.16,10.43 31.16,12.49 32.16,13.49 32.74,13.49 33.17,13.05 34.47,13.05 34.86,13.45 34.86,13.57 35.87,14.58 37.04,14.58 v1(37.32,14.3)
  IN3 w0.089: v2(98.46,50.76) 98.68,50.98 98.68,51.08 98.59,51.17 97.57,51.17 95.21,48.8 92.01,48.8 91.86,48.65 91.27,48.65 90.42,47.8 90.42,46.66 89.58,45.81 89.58,44.87 88.6,43.9 88.6,40 88.43,39.83 88.43,38.41 88.08,38.06 87.4,38.06 87.31,37.97 87.31,37.45 85.91,36.05 84.35,36.05 83.55,35.25 81.23,35.25 80.83,34.85 79.88,34.85 79.35,34.32 79.04,34.32 78.75,34.04 78.75,33.71 78.05,33.01 75.5,33.01 73.88,31.38 70.37,31.38 68.38,29.4 65.63,29.4 64.78,28.55 64.78,28.23 64.25,27.7 63.49,27.7 62.85,27.06 62.27,27.06 62.09,27.24 59.45,27.24 58.79,26.58 58.79,25.94 58.23,25.39 53.87,25.39 53.74,25.52 53.16,25.52 52.92,25.28 52.92,24.83 52.51,24.42 49.21,24.42 48.91,24.73 48.17,24.73 47.53,24.09 47.09,24.09 45.79,22.8 33.6,22.8 33.18,22.38 33.18,21.96 32.78,21.55 32.78,17.28 34.94,15.12 36.23,15.12 36.87,15.76 37.75,15.76 37.96,15.55 37.96,14.93 v1(37.32,14.3)
  BOTTOM w0.079: U1.BL4 95.92,49.29 96.45,49.38 96.54,49.42 96.65,49.46 96.82,49.46 97,49.38 97.06,49.38 97.5,49.55 98.33,50.38 98.55,50.38 98.63,50.46 98.63,50.66 98.53,50.76 v2(98.46,50.76)
PCIE_TXN15_SSD_C: length 4.2
  TOP w0.102: v1(31.49,7.58) 31.21,7.86 31.21,8.26 31.16,8.31 31.16,8.85 C792.2
  BOTTOM w0.102: CN16.35 31.35,8.59 31.21,8.45 31.21,7.86 v1(31.49,7.58)
PCIE_TXN16_SSD: length 111.3
  TOP w0.102: C794.1 28.42,10.24 28.42,10.39 28.51,10.48 28.51,12.38 28.85,12.72 30.33,12.72 31.72,14.12 33.04,14.12 33.59,14.66 33.95,14.66 34.03,14.59 34.03,14.42 v1(33.82,14.21)
  IN3 w0.089: v2(99.15,51.8) 98.99,51.95 98.99,52.23 98.74,52.49 97.74,52.49 94.87,49.62 91.11,49.62 90.96,49.47 90.68,49.47 90.6,49.39 89.23,49.39 88.61,48.76 88.61,48.14 87.67,47.21 87.67,45.23 87.79,45.11 87.79,40.33 87.5,40.04 86.67,40.04 86.22,39.59 86.22,38.18 86.35,38.05 86.35,37.64 85.58,36.87 84.03,36.87 83.21,36.05 80.88,36.05 80.48,35.65 79.55,35.65 79.02,35.12 77.72,35.12 77.43,34.83 75.8,34.83 74.75,33.78 74.75,33.4 73.53,32.18 70.04,32.18 69.33,31.48 67.15,31.48 66.44,30.77 65.04,30.77 64.34,30.08 64.34,29.24 64.12,29.02 63.76,29.02 63.5,28.76 62.46,28.76 61.83,28.13 61.05,28.13 60.51,28.66 58.83,28.66 57.23,27.06 56.2,27.06 55.52,26.38 54.01,26.38 53.97,26.42 52.52,26.42 52.06,25.95 52.06,25.37 51.92,25.23 49.7,25.23 49.3,25.64 47.78,25.64 47.25,25.11 41.79,25.11 40.29,23.61 33.28,23.61 32.35,22.67 32.35,22.3 31.96,21.91 31.96,16.95 33.97,14.94 33.97,14.36 v1(33.82,14.21)
  BOTTOM w0.079: v2(99.15,51.8) 99.12,51.78 99.12,51.75 98.94,51.57 98.94,51.48 98.73,51.26 98.42,51.26 97.85,50.69 97.85,50.16 97.61,49.91 97.3,49.91 97.29,49.9 97.27,49.9 97.18,49.94 96.92,49.94 96.89,49.92 96.67,49.88 96.54,49.92 96.46,49.96 95.79,50.08 U1.BJ4
PCIE_TXN16_SSD_C: length 3.9
  TOP w0.102: v1(28.49,7.71) 28.21,7.99 28.21,8.27 28.24,8.3 28.24,8.85 C794.2
  BOTTOM w0.102: CN16.47 28.35,8.59 28.21,8.45 28.21,7.99 v1(28.49,7.71)
PCIE_TXP9_LAN: length 114.1
  TOP w0.102: v1(45.25,101.56) 45.25,101.69 44.89,102.04 44.89,102.73 44.84,102.78 U24.13
  IN3 w0.089: v2(100.09,52.54) 100.21,52.54 100.46,52.78 100.46,53.15 100.28,53.32 100.28,55 100.03,55.26 96.52,55.26 94.55,57.23 94.55,58.67 95.13,59.25 95.13,59.74 95.29,59.9 95.29,60.69 95.39,60.79 95.39,61.29 95.29,61.4 95.29,64.6 95.39,64.71 95.39,66.11 95.29,66.22 95.29,69.46 95.39,69.56 95.39,70.69 95.31,70.77 95.31,71.43 95.29,71.45 95.29,71.88 95.31,71.9 95.31,72.71 95.46,72.86 95.46,73.74 94.54,74.66 92.9,74.66 92.26,75.3 92.26,79.78 90.61,81.43 90.61,84.41 89.95,85.07 89.95,87.35 88.5,88.81 88.12,88.81 85.93,90.99 81.72,90.99 80.43,92.29 78.67,92.29 75.64,95.31 65,95.31 64.7,95.01 61.12,95.01 59.96,96.18 58.81,96.18 55.76,99.22 55.76,100.84 55.24,101.37 53.03,101.37 52.15,100.49 50.18,100.49 49.55,99.86 46.49,99.86 45.65,100.7 45.65,101.55 45.49,101.71 45.4,101.71 v1(45.25,101.56)
  BOTTOM w0.102: C201.2 101.1,45.96 101.2,45.96 101.79,46.54 104.43,46.54 104.96,47.08 105.6,47.08 105.94,47.42 105.94,49.17 103.96,51.15 100.86,51.15 100.29,51.73 100.29,52.34 v2(100.09,52.54)
PCIE_TXP9_LAN_C: length 4.2
  BOTTOM w0.079: 100.39,45.83 99.95,45.83 99.59,46.19 98.05,46.19 97.88,46.36 97.37,46.36 97.32,46.41 97.32,46.52 U1.BR1 ; 100.57,45.83 100.62,45.88 100.62,46.11 100.54,46.19 C201.1
  BOTTOM w0.102: 100.57,45.83 100.39,45.83
PCIE_TXP10_WLAN: length 132
  IN3 w0.089: v2(184.97,27.52) 184.97,27.27 184.85,27.14 183.44,27.14 183.09,27.49 180.6,27.49 180.02,26.91 171.53,26.91 170.82,26.2 168.34,26.2 168.11,25.97 160.18,25.97 159.95,26.2 154.64,26.2 153.6,27.23 146.3,27.23 145.36,28.17 142.3,28.17 141.49,27.37 139.84,27.37 139.72,27.25 139.22,27.25 137.04,25.08 135.34,25.08 135.29,25.03 126.58,25.03 125.87,24.32 123.29,24.32 122.94,24.66 119.41,24.66 118.89,24.14 114.83,24.14 114.49,23.8 114.49,22.72 113.27,21.5 110.47,21.5 109.38,22.58 109.38,24.48 109.87,24.96 109.87,27.56 108.29,29.14 108.29,29.73 106.44,31.58 106.44,34.29 106.01,34.73 106.01,36.25 105.13,37.13 105.13,37.4 104.83,37.71 104.6,37.71 103.16,39.14 103.16,40.51 103.56,40.91 103.84,40.91 106.51,43.57 107.09,43.57 107.25,43.73 107.25,46.16 106.34,47.08 105.9,47.08 105.51,47.46 105.21,47.46 v2(104.84,47.84)
  BOTTOM w0.079: U1.BR3 96.34,46.58 96.38,46.62 96.38,46.71 96.41,46.74 96.58,46.83 96.73,46.85 96.94,46.8 97.04,46.78 97.06,46.78 97.35,46.86 97.52,46.86 97.85,46.54 97.96,46.54 98.13,46.37 99.2,46.37 100.11,47.28 100.39,47.28 100.46,47.34
  BOTTOM w0.102: C202.2 181.65,23.55 182.48,23.55 183.42,24.5 185.29,24.5 185.55,24.75 185.55,25.55 184.92,26.17 184.92,26.61 184.61,26.92 184.61,27.15 v2(184.97,27.52) ; 100.46,47.34 100.51,47.4 101.33,47.4 101.78,46.95 103.52,46.95 104.6,48.03 104.74,48.03 104.84,47.93 v2(104.84,47.84)
PCIE_TXP10_WLAN_C: length 2.9
  BOTTOM w0.102: CN17.35 182.37,22.63 182.14,22.4 181.3,22.4 181.08,22.63 181.08,22.7 181.33,22.95 C202.1
PCIE_TXP13_SSD: length 91.8
  TOP w0.102: C789.1 35.22,10.03 35.53,10.34 35.53,12.35 36.02,12.84 36.55,12.84 v1(36.78,13.07)
  IN3 w0.089: v1(36.78,13.07) 36.89,13.07 37.2,12.76 38.19,12.76 39.31,13.88 40.3,13.88 41.65,15.23 41.65,15.85 43.59,17.79 44.65,17.79 47.92,21.06 47.92,21.25 49.67,23 53.25,23 54.64,24.4 58.65,24.4 59.27,25.02 60.15,25.02 60.92,25.79 64.41,25.79 64.76,26.13 66.66,26.13 66.86,26.33 68.97,26.33 70.33,24.97 70.59,24.97 70.88,24.68 73.01,24.68 73.4,25.07 73.54,25.07 74.94,26.47 74.94,30.19 76.58,31.84 80.42,31.84 81.34,32.76 81.34,33.04 81.69,33.39 82.61,33.39 82.84,33.62 83.98,33.62 85.42,35.06 86.38,35.06 87.32,36 89.22,36 90.44,37.22 90.44,42.39 91.17,43.12 91.17,44.94 91.81,45.58 91.81,45.79 92.95,46.94 95.52,46.94 95.66,46.8 96.02,46.8 96.38,47.16 96.38,48.05 96.9,48.58 98,48.58 v2(98.23,48.8)
  BOTTOM w0.079: U1.BM3 96.56,48.46 96.67,48.57 98,48.57 v2(98.23,48.8)
PCIE_TXP13_SSD_C: length 6.9
  TOP w0.102: v1(35.77,6.53) 36.05,6.81 36.05,6.97 35.39,7.64 35.39,8.85 C789.2
  BOTTOM w0.102: v1(35.77,6.53) 36.04,6.79 36.04,7.17 36.99,8.13 36.99,8.33 36.85,8.47 CN16.13
PCIE_TXP14_SSD: length 92.7
  TOP w0.102: C791.1 33.47,10.03 33.54,10.1 33.54,10.28 33.76,10.5 33.76,10.82 34.06,11.12 34.19,11.12 34.72,11.66 34.72,12.42 35.62,13.32 v1(35.62,13.68)
  IN3 w0.089: v2(98.45,49.74) 98.64,49.74 98.74,49.85 98.74,50.02 98.62,50.15 97.75,50.15 95.29,47.69 92.21,47.69 91.4,46.87 91.4,45.75 90.42,44.76 90.42,43.34 89.55,42.48 89.55,36.9 89.11,36.46 87.22,36.46 86.21,35.46 84.59,35.46 83.79,34.66 81.49,34.66 81.01,34.17 80.3,34.17 79.74,33.62 79.74,33.1 78.94,32.29 75.65,32.29 74.14,30.79 70.62,30.79 68.39,28.56 67.14,28.56 65.49,26.91 63.55,26.91 63.09,26.45 61.95,26.45 61.78,26.63 60.52,26.63 60.13,26.24 60.13,25.73 59.82,25.42 59.11,25.42 58.48,24.8 54.34,24.8 53.78,24.24 53.27,24.24 52.84,23.81 49.9,23.81 47.51,21.42 47.51,21.21 44.67,18.38 43.61,18.38 41.25,16.02 41.25,15.39 40.14,14.27 39.15,14.27 38.57,13.7 37.27,13.7 37.07,13.5 36.23,13.5 35.95,13.22 35.75,13.22 35.62,13.35 v1(35.62,13.68)
  BOTTOM w0.079: v2(98.45,49.74) 98.51,49.8 98.64,49.8 98.73,49.71 98.73,49.48 98.59,49.34 97.99,49.34 97.55,48.91 97.49,48.91 U1.BL1
PCIE_TXP14_SSD_C: length 4.3
  TOP w0.102: C791.2 33.24,9.25 33.36,9.13 33.36,8.86 33.99,8.22 33.99,7.99 v1(33.71,7.71)
  BOTTOM w0.102: v1(33.71,7.71) 33.99,7.99 33.99,8.38 33.85,8.52 CN16.25
PCIE_TXP15_SSD: length 111.6
  TOP w0.102: v1(37.32,14.93) 37.19,14.8 35.78,14.8 34.64,13.66 34.64,13.54 34.38,13.27 33.26,13.27 32.83,13.7 32.07,13.7 30.94,12.58 30.94,10.43 C793.1
  IN3 w0.089: v2(99.05,50.76) 98.88,50.93 98.88,51.16 98.67,51.37 97.49,51.37 95.13,49.01 91.93,49.01 91.77,48.86 91.19,48.86 90.22,47.88 90.22,46.74 89.37,45.9 89.37,44.96 88.4,43.98 88.4,40.09 88.23,39.92 88.23,38.49 88,38.26 87.32,38.26 87.11,38.06 87.11,37.54 85.83,36.26 84.26,36.26 83.46,35.46 81.15,35.46 80.74,35.05 79.79,35.05 79.27,34.53 78.95,34.53 78.55,34.12 78.55,33.79 77.96,33.21 75.42,33.21 73.79,31.59 70.28,31.59 68.3,29.6 65.54,29.6 64.58,28.63 64.58,28.32 64.16,27.9 63.41,27.9 62.77,27.27 62.35,27.27 62.17,27.44 59.36,27.44 58.58,26.66 58.58,26.03 58.15,25.6 53.95,25.6 53.82,25.73 53.07,25.73 52.72,25.37 52.72,24.91 52.43,24.62 49.3,24.62 48.99,24.93 48.09,24.93 47.45,24.29 47,24.29 45.71,23 33.51,23 32.98,22.47 32.98,22.04 32.57,21.63 32.57,17.2 34.85,14.92 36.32,14.92 36.95,15.56 37.67,15.56 37.76,15.47 37.76,15.02 37.67,14.93 v1(37.32,14.93)
  BOTTOM w0.079: v2(99.05,50.76) 98.94,50.66 98.87,50.66 98.79,50.58 98.79,50.39 98.62,50.22 98.4,50.22 97.59,49.41 97.29,49.3 97.28,49.29 97.09,49.21 96.96,49.21 96.78,49.29 96.68,49.29 96.61,49.26 U1.BL3
PCIE_TXP15_SSD_C: length 4.2
  TOP w0.102: C793.2 30.94,8.85 30.94,8.22 30.99,8.17 30.99,7.86 v1(30.71,7.58)
  BOTTOM w0.102: CN16.37 30.85,8.52 30.99,8.38 30.99,7.86 v1(30.71,7.58)
PCIE_TXP16_SSD: length 111.2
  TOP w0.102: C795.1 28.04,10.03 28.21,10.2 28.21,10.48 28.29,10.57 28.29,12.47 28.76,12.94 30.24,12.94 31.63,14.34 32.95,14.34 33.5,14.88 34.04,14.88 34.24,14.68 34.24,14.34 34.38,14.21 v1(34.58,14.21)
  IN3 w0.089: v2(98.56,51.8) 98.79,52.03 98.79,52.15 98.66,52.28 97.83,52.28 94.96,49.41 91.2,49.41 91.04,49.26 90.77,49.26 90.69,49.19 89.32,49.19 88.81,48.68 88.81,48.06 87.88,47.13 87.88,45.32 88,45.2 88,40.25 87.59,39.84 86.75,39.84 86.42,39.51 86.42,38.26 86.55,38.14 86.55,37.55 85.66,36.66 84.11,36.66 83.3,35.85 80.97,35.85 80.56,35.44 79.63,35.44 79.11,34.92 77.8,34.92 77.51,34.63 75.89,34.63 74.95,33.69 74.95,33.32 73.61,31.98 70.12,31.98 69.42,31.28 67.23,31.28 66.53,30.57 65.12,30.57 64.55,29.99 64.55,29.16 64.2,28.82 63.84,28.82 63.59,28.56 62.55,28.56 61.91,27.93 60.96,27.93 60.43,28.46 58.91,28.46 57.31,26.86 56.29,26.86 55.61,26.18 53.93,26.18 53.89,26.22 52.61,26.22 52.26,25.87 52.26,25.28 52.01,25.03 49.62,25.03 49.21,25.44 47.86,25.44 47.33,24.9 41.87,24.9 40.37,23.4 33.36,23.4 32.55,22.59 32.55,22.21 32.17,21.83 32.17,17.03 34.17,15.02 34.17,14.44 34.4,14.21 v1(34.58,14.21)
  BOTTOM w0.079: U1.BJ3 96.14,50.3 96.61,50.08 96.68,50.05 96.83,50.08 96.89,50.11 97.21,50.11 97.3,50.07 97.54,50.07 97.69,50.22 97.69,50.76 98.35,51.42 98.66,51.42 98.79,51.54 98.79,51.63 98.61,51.8 v2(98.56,51.8)
PCIE_TXP16_SSD_C: length 3.9
  TOP w0.102: v1(27.71,7.71) 27.99,7.99 27.99,8.36 28.02,8.39 28.02,8.85 C795.2
  BOTTOM w0.102: v1(27.71,7.71) 27.99,7.99 27.99,8.38 27.85,8.52 CN16.49
PCIE_WAKE#: length 308.7
  TOP w0.079: v2(78.7,44.61) 78.7,44.75 78.33,45.11 76.89,45.11 76.85,45.07 75.6,45.07 75.25,45.43
  TOP w0.102: 75.25,45.43 74.47,46.21 73.69,46.21 72.71,45.22 69.46,45.22 67.4,47.28 67.4,48.28 67.07,48.6 65.93,48.6 65.29,49.24 65.29,51.98 64.58,52.69 62.16,52.69 61.53,52.06 61.53,51.29 60.64,50.41 60,50.41 R33.1 59.23,50.78 58.66,50.2 58.66,48.47 57.59,47.4 57.59,33.01 56.35,31.76 56.35,30.62 55.33,29.6 55.33,27.93 54.82,27.42 52.77,27.42 52.64,27.55 v2(52.64,27.57) ; v2(50.61,105.93) 50.61,105.65 50.53,105.57 R513.1
  IN1 w0.089: v2(78.7,44.61) 78.7,44.59 78.29,44.18 78.29,42.38 78.45,42.23 78.45,41.64 78.57,41.52 80.7,41.52 81.28,40.94 81.28,38.52 81.77,38.02 82.62,38.02 84.82,35.82 85.8,35.82 86.81,34.81 92.63,34.81 92.8,34.64 95.1,34.64 97.04,32.7 97.04,32.22 97.23,32.03 99.04,32.03 100.23,30.83 101.89,30.83 102.82,29.9 103.26,29.9 103.54,29.62 106.02,29.62 106.74,28.89 108.25,28.89 108.91,28.24 110.55,28.24 110.74,28.43 118.89,28.43 119.45,28.98 124.07,28.98 126.03,30.95 128.21,30.95 128.35,31.09 131.74,31.09 132.35,30.48 137.97,30.48 138.18,30.27 141.05,30.27 142.27,29.05 144.12,29.05 144.21,28.96 145,28.96 145.8,28.15 146.33,28.15 147.23,27.25 153.3,27.25 154.55,26 160.33,26 160.62,25.71 165.28,25.71 166.48,24.52 167.79,24.52 168.06,24.78 169.74,24.78 170.08,24.44 173.41,24.44 174.05,23.79 177.25,23.79 177.6,24.14 v2(178.95,24.14)
  IN2 w0.089: v1(24.9,48.25) 24.9,48.09 26.1,46.9 26.1,43.55 25.51,42.96 25.51,41.45 25.63,41.33 25.63,38.69 26.47,37.86 27.41,36.91 27.41,34.36 27.75,34.02 33.31,34.02 33.37,34.07 35.7,34.07 38.65,31.12 39.37,31.12 39.92,30.57 42.19,30.57 45.93,26.83 48.19,26.83 48.4,27.04 48.4,28.1 48.66,28.36 51.5,28.36 52.28,27.57 v2(52.64,27.57)
  IN3 w0.089: v1(24.9,48.25) 24.32,48.83 24.32,52.95 24.68,53.31 24.68,60.19 25.14,60.65 25.14,61.27 27.18,63.31 27.18,63.73 27.36,63.91 27.36,68.08 26.54,68.9 26.54,72.41 24.74,74.2 23.98,74.2 23.68,74.5 23.68,76.49 23.56,76.62 23.56,80.69 22.88,81.37 22.88,86.81 25.13,89.06 25.13,90.54 25.05,90.62 25.05,92.32 25.74,93.01 25.74,96.13 26.35,96.73 26.35,98.38 27.22,99.25 29.87,99.25 31.55,100.93 36.99,100.93 37.45,100.47 40.3,100.47 40.6,100.77 40.6,101.08 40.96,101.43 41.31,101.43 44.14,104.26 45.68,104.26 46.96,105.54 50.21,105.54 v2(50.61,105.93)
  BOTTOM w0.079: v2(78.7,44.61) 78.7,44.75 78.72,44.77 78.72,44.82 79.04,45.14 U1.BU30
  BOTTOM w0.102: Q33.3 179.89,17.83 179.49,18.23 179.49,19.57 180.38,20.46 EC13.1 180.38,21.42 180.07,21.73 179.64,21.73 v1(179.47,21.89) 179.18,22.19 179.18,23.91 v2(178.95,24.14)
PCIE_WAKE#_R: length 2.6
  TOP w0.102: U24.21 47.29,105.6 47.46,105.42 49.05,105.42 R513.2
PD#: length 32.9
  TOP w0.102: C595.1 210.34,30.53 210.63,30.82 211.44,30.82 211.64,30.62 211.85,30.62 212.15,30.31 215.5,30.31 216.01,29.81 216.01,27.72 214.49,26.2 214.49,25.72 212.43,23.66 208.65,23.66 206.77,25.54 205.65,25.54 205.17,26.02 v2(204,26.02) ; C595.1 210.26,30.31 R479.1 210.26,28.82 210.43,28.66 R478.1 ; C595.1 210.17,30.39 v1(209.61,29.83)
  BOTTOM w0.102: D12.2 202.38,23.6 202.3,23.68 202.3,24.21 D13.2 203.07,25.7 203.21,25.84 203.82,25.84 v2(204,26.02) ; U20.47 208.24,30.82 208.41,30.66 208.41,30.49 209.06,29.83 v1(209.61,29.83)
PEDET: length 5.9
  TOP w0.102: v1(22.67,10.15) 22.51,9.99 R654.2
  TOP w0.381: R654.2 22.68,9.09 R649.2 23.17,8.24 v1(23.31,8.1) 23.95,8.74 Q34.2
  BOTTOM w0.254: CN16.69 22.85,8.44 23.2,8.1 v1(23.31,8.1)
PEG_RXN5: length 84.7
  TOP w0.102: v1(93.36,109.97) 93.17,110.16 93.17,110.31 93.5,110.64 94.46,110.64 94.89,110.22 97.34,110.22 C358.1
  IN1 w0.089: v2(92.4,44.45) 92.48,44.45 93.26,43.67 96.37,43.67 97.65,44.95 97.65,47.89 97.67,47.92 97.67,47.97 97.37,48.28 97.37,49.27 96.45,50.18 96.45,52.59 95.54,53.5 94.75,53.5 94.68,53.43 92.81,53.43 92.08,54.16 90.79,54.16 90.64,54.32 90.64,58.94 90.41,59.17 90.41,69.3 90.74,69.63 90.74,73.81 90.36,74.19 90.36,80.89 91.12,81.65 91.12,84.19 90.59,84.71 90.59,85.9 92.07,87.37 92.07,92.4 91.88,92.58 91.88,98.07 92.18,98.36 92.18,101.79 92.74,102.36 92.74,108.8 93.15,109.21 93.15,109.76 v1(93.36,109.97)
  BOTTOM w0.079: U1.BW9 92.08,44.13 v2(92.4,44.45)
PEG_RXN5_C: length 3.8
  TOP w0.102: C358.2 98.5,110.1 98.61,110.22 99,110.22 99.22,110.44 99.22,110.98 99.48,111.24 99.82,111.24 99.95,111.11 100.19,111.11 v2(100.49,110.81)
  BOTTOM w0.102: U8.AB9 v2(100.49,110.81)
PEG_RXN6: length 94.7
  TOP w0.102: v1(97.52,119.23) 97.32,119.43 97.32,119.59 97.6,119.87 98.51,119.87 98.77,120.13 98.77,120.64 99.2,121.07 100.04,121.07 100.26,121.3 101.08,121.3 101.43,120.95 101.43,120.03 C384.1
  IN1 w0.089: v1(97.52,119.23) 97.34,119.05 97.34,118.48 93.84,114.97 93.46,114.97 92.9,114.41 92.9,111.87 92.15,111.12 92.15,102.63 91.58,102.06 91.58,98.61 91.29,98.32 91.29,92.33 91.47,92.15 91.47,87.62 90,86.15 90,84.79 89.6,84.39 89.6,58.66 90.03,58.23 90.03,53.15 90.54,52.64 93.34,52.64 93.52,52.46 95.19,52.46 95.57,52.08 95.57,50.21 96.76,49.02 96.76,48.03 97.06,47.72 97.06,45.12 96.02,44.08 94.69,44.08 v2(94.31,44.46)
  BOTTOM w0.079: U1.BU6 94.31,44.71 v2(94.31,44.46)
PEG_RXN6_C: length 9.3
  TOP w0.102: C384.2 101.34,118.85 101.83,118.36 101.83,117.98 101.46,117.61 101.46,116.88 101.66,116.67 101.66,112.71 102.33,112.04 102.33,111.68 102.27,111.62 v2(102.12,111.62)
  BOTTOM w0.102: U8.AC10 101.77,111.17 101.99,111.17 102.14,111.33 102.14,111.59 v2(102.12,111.62)
PEG_RXN7: length 97.6
  TOP w0.102: v2(103.07,122.54) 102.91,122.37 102.91,121.81 C6554.1
  IN1 w0.089: v2(93.68,45.38) 93.78,45.38 94.32,44.84 95.18,44.84 96.45,46.11 96.45,47.48 96.15,47.79 96.15,48.76 95.32,49.59 92.86,49.59 91.82,50.63 90.24,50.63 89.42,51.45 89.42,57.75 88.99,58.18 88.99,68.39 88.44,68.94 88.44,81.15 88.89,81.6 88.89,84.62 89.4,85.13 89.4,86.4 90.87,87.87 90.87,91.9 90.69,92.09 90.69,98.57 90.97,98.85 90.97,102.31 91.55,102.89 91.55,108.27 90.99,108.83 90.99,114.57 92.16,115.73 93.58,115.73 94.97,117.12 94.97,118.63 97.86,121.53 102.28,121.53 102.91,122.16 102.91,122.37 v2(103.07,122.54)
  BOTTOM w0.079: U1.BT7 93.38,45.74 93.68,45.43 v2(93.68,45.38)
PEG_RXN7_C: length 10.5
  TOP w0.102: C6554.2 103.11,120.68 103.11,120.13 102.79,119.81 102.79,115.95 103.59,115.15 103.59,112.91 103.39,112.71 103.39,112.06 v2(102.97,111.64)
  BOTTOM w0.102: v2(102.97,111.64) 102.96,111.64 U8.AC11
PEG_RXN8: length 103.5
  TOP w0.102: v1(104.72,122.03) 104.49,121.81 104.49,121.46 103.93,120.9 103.93,120.03 C6557.1
  IN1 w0.089: v2(92.39,45.38) 92.56,45.55 92.56,45.76 92.76,45.96 95.15,45.96 95.49,46.3 95.49,46.72 95.24,46.98 95.24,47.74 95.34,47.84 95.34,48.42 95.01,48.75 92.52,48.75 92.2,49.07 90.54,49.07 88.61,51.01 88.61,57.24 88.17,57.67 88.17,67.67 87.13,68.71 87.13,72.2 87.54,72.6 87.54,81.65 88.07,82.18 88.07,85.11 88.6,85.64 88.6,86.73 90.07,88.2 90.07,91.57 89.88,91.77 89.88,98.89 90.17,99.18 90.17,102.67 90.74,103.24 90.74,104.35 90.13,104.96 90.13,114.98 91.8,116.65 93.23,116.65 94.17,117.59 94.17,118.98 97.24,122.05 97.24,122.6 97.64,123 101.58,123 101.83,123.25 103.91,123.25 104.53,122.63 104.53,122.22 v1(104.72,122.03)
  BOTTOM w0.079: v2(92.39,45.38) 92.08,45.07 U1.BU9
PEG_RXN8_C: length 9.3
  TOP w0.102: v2(103.8,110.82) 104.2,111.23 104.2,111.92 104.42,112.14 104.42,115.62 103.93,116.11 103.93,117.9 104.25,118.22 104.25,118.77 C6557.2
  BOTTOM w0.102: v2(103.8,110.82) 103.39,110.42 U8.AB12
PEG_RXP5: length 84.7
  TOP w0.102: C370.1 97.34,110.43 94.98,110.43 94.55,110.86 93.41,110.86 92.95,110.4 92.95,110.12 92.8,109.97 v2(92.72,109.97)
  IN1 w0.089: v2(93.03,44.46) 93.03,44.2 93.37,43.85 96.29,43.85 97.47,45.03 97.47,47.89 97.17,48.2 97.17,49.19 96.25,50.1 96.25,52.51 95.46,53.3 94.84,53.3 94.76,53.22 92.73,53.22 91.99,53.96 90.71,53.96 90.44,54.23 90.44,58.86 90.21,59.08 90.21,69.39 90.54,69.72 90.54,73.72 90.16,74.1 90.16,80.97 90.92,81.73 90.92,84.1 90.39,84.63 90.39,85.99 91.86,87.46 91.86,92.31 91.68,92.5 91.68,98.16 91.97,98.45 91.97,101.88 92.54,102.45 92.54,108.88 92.95,109.29 92.95,109.87 92.85,109.97 v2(92.72,109.97)
  BOTTOM w0.079: U1.BW8 92.84,43.95 93,43.95 93.08,44.03 93.08,44.41 v2(93.03,44.46)
PEG_RXP5_C: length 3.8
  TOP w0.102: v2(100.49,111.62) 100.2,111.33 100.04,111.33 99.91,111.45 99.39,111.45 99.01,111.07 99.01,110.53 98.91,110.43 98.6,110.43 98.5,110.53 C370.2
  BOTTOM w0.102: v2(100.49,111.62) 100.88,111.23 U8.AC9
PEG_RXP6: length 94.7
  TOP w0.102: v1(96.84,119.24) 96.99,119.24 97.1,119.35 97.1,119.68 97.51,120.09 98.42,120.09 98.55,120.22 98.55,120.73 99.11,121.28 99.95,121.28 100.18,121.51 101.17,121.51 101.64,121.04 101.64,120.03 C382.1
  IN1 w0.089: v1(96.84,119.24) 96.99,119.24 97.14,119.09 97.14,118.56 93.75,115.18 93.37,115.18 92.7,114.5 92.7,111.96 91.94,111.2 91.94,102.71 91.37,102.14 91.37,98.7 91.08,98.4 91.08,92.25 91.27,92.06 91.27,87.71 89.79,86.23 89.79,84.87 89.39,84.47 89.39,58.58 89.83,58.14 89.83,53.06 90.45,52.44 93.25,52.44 93.44,52.25 95.11,52.25 95.36,52 95.36,50.13 96.56,48.93 96.56,47.94 96.86,47.64 96.86,45.21 95.94,44.28 95.15,44.28 v2(94.97,44.46)
  BOTTOM w0.079: v2(94.97,44.46) 94.8,44.46 94.68,44.59 U1.BU5
PEG_RXP6_C: length 9.3
  TOP w0.102: v2(102.13,110.78) 102.55,111.21 102.55,112.13 101.88,112.8 101.88,116.76 101.67,116.97 101.67,117.52 102.04,117.89 C382.2
  BOTTOM w0.102: v2(102.13,110.78) 102.1,110.78 U8.AB10
PEG_RXP7: length 97.6
  TOP w0.102: v2(102.32,122.54) 102.5,122.54 102.69,122.35 102.69,121.74 102.48,121.53 C6556.1
  IN1 w0.089: v2(102.32,122.54) 102.6,122.54 102.7,122.44 102.7,122.24 102.19,121.73 97.78,121.73 94.77,118.72 94.77,117.2 93.5,115.94 92.08,115.94 90.79,114.65 90.79,108.74 91.35,108.19 91.35,102.98 90.77,102.4 90.77,98.93 90.49,98.65 90.49,92 90.67,91.82 90.67,87.95 89.2,86.48 89.2,85.22 88.68,84.7 88.68,81.68 88.23,81.23 88.23,68.85 88.78,68.3 88.78,58.09 89.22,57.66 89.22,51.36 90.15,50.42 91.74,50.42 92.77,49.39 95.24,49.39 95.95,48.68 95.95,47.7 96.25,47.4 96.25,46.2 95.1,45.05 94.41,45.05 94.34,45.11 v2(94.34,45.38)
  BOTTOM w0.079: U1.BT6 94.21,45.91 94.47,45.66 94.47,45.5 v2(94.34,45.38)
PEG_RXP7_C: length 10.4
  TOP w0.102: v2(102.94,112.44) 103.11,112.44 103.17,112.5 103.17,112.8 103.38,113 103.38,115.06 102.57,115.86 102.57,119.9 102.89,120.22 102.89,120.34 102.75,120.48 102.75,120.66 102.66,120.75 C6556.2
  BOTTOM w0.102: U8.AD11 102.81,112.03 102.94,112.16 v2(102.94,112.44)
PEG_RXP8: length 103.5
  TOP w0.102: v1(103.94,122.03) 104.2,122.03 104.28,121.96 104.28,121.55 103.71,120.99 103.71,120.03 C6555.1
  IN1 w0.089: v1(103.94,122.03) 104.23,122.03 104.33,122.13 104.33,122.54 103.82,123.05 101.92,123.05 101.66,122.8 97.72,122.8 97.45,122.52 97.45,121.97 94.37,118.89 94.37,117.5 93.31,116.45 91.88,116.45 90.33,114.9 90.33,105.04 90.94,104.43 90.94,103.15 90.37,102.58 90.37,99.09 90.08,98.8 90.08,91.85 90.28,91.65 90.28,88.12 88.8,86.64 88.8,85.55 88.28,85.03 88.28,82.1 87.74,81.56 87.74,72.52 87.34,72.11 87.34,68.79 88.38,67.75 88.38,57.75 88.81,57.32 88.81,51.09 90.63,49.27 92.28,49.27 92.6,48.96 95.09,48.96 95.54,48.51 95.54,47.76 95.44,47.65 95.44,47.06 95.69,46.81 95.69,46.21 95.24,45.76 92.85,45.76 92.76,45.67 92.76,45.46 92.85,45.38 v2(93.02,45.38)
  BOTTOM w0.079: U1.BU8 92.87,44.99 93.02,45.14 v2(93.02,45.38)
PEG_RXP8_C: length 9.2
  TOP w0.102: C6555.2 103.83,118.85 103.9,118.78 103.9,118.59 104.04,118.46 104.04,118.31 103.71,117.99 103.71,116.02 104.2,115.53 104.2,112.23 103.99,112.01 103.99,111.71 103.9,111.62 v2(103.8,111.62)
  BOTTOM w0.102: v2(103.8,111.62) 103.84,111.57 103.84,111.39 103.67,111.21 103.41,111.21 U8.AC12
PEG_TXN5: length 94
  IN1 w0.089: v2(104.21,42.58) 104.43,42.8 104.43,43.06 104.22,43.28 104.22,44.11 101.18,47.15 101.18,52.96 100.71,53.43 99.37,53.43 98.71,54.09 95.62,54.09 95.53,54.18 93.95,54.18 93.48,54.65 93.48,56.77 93.39,56.86 92.47,56.86 92.14,57.19 92.14,70.23 92.09,70.29 92.09,73.36 92.26,73.54 92.26,80 92.01,80.25 92.01,84.06 90.99,85.08 90.99,85.71 92.46,87.19 92.46,92.56 92.28,92.74 92.28,97.91 92.58,98.21 92.58,100.48 93.14,101.04 93.14,108.28 94.6,109.75 94.6,113.32 97.55,116.27 98.44,116.27 v2(98.61,116.45)
  BOTTOM w0.102: v2(98.61,116.45) 98.77,116.29 99.13,116.29 99.38,116.04 99.38,115.4 98.98,115.01 98.98,114.68 U8.AG7 ; C192.2 101.77,42.52 102.84,42.52 103.26,42.1 104.2,42.1 104.37,42.27 104.37,42.42 v2(104.21,42.58)
PEG_TXN5_C: length 7.1
  BOTTOM w0.079: C192.1 100.88,42.61 100.21,42.61 99.99,42.84 99.99,43.54 99.31,44.21 98.02,44.21 97.66,44.58 97.36,44.58 97.04,44.51 96.99,44.52 96.78,44.58 96.65,44.58 96.35,44.46 95.92,44.41 U1.BW4
PEG_TXN6: length 84.2
  IN1 w0.089: v2(98.84,113.22) 98.56,113.5 98.36,113.5 96.71,111.85 96.71,108.11 95.78,107.19 95.78,103.05 95.16,102.42 95.16,100.62 95.34,100.44 95.34,98.06 94.7,97.42 94.7,93.8 95.13,93.37 95.13,92.19 94.56,91.62 94.56,82.03 94.65,81.93 94.65,80.18 95.41,79.42 95.41,77.74 96.05,77.11 96.05,75.02 96.51,74.56 96.51,59.96 96.81,59.65 96.81,58.25 97.29,57.77 99.68,57.77 101.81,55.64 101.81,55.29 103.44,53.66 103.44,49.85 104.11,49.19 104.6,49.19 104.68,49.26 105.56,49.26 107.73,47.09 107.73,44.77 107.4,44.43 106.08,44.43 105.99,44.34 105.99,44.25 v2(106.21,44.03)
  BOTTOM w0.102: v2(98.84,113.22) 98.87,113.19 98.87,113.19 U8.AE7 ; C194.2 104.8,43.38 105.74,43.38 105.99,43.64 105.99,43.81 v2(106.21,44.03)
PEG_TXN6_C: length 9.6
  BOTTOM w0.079: U1.BU4 95.76,45.2 96.45,45.1 96.59,45.02 96.85,45.02 96.98,45.09 97.1,45.09 97.21,45.04 97.32,45.02 98.9,45.02 100.72,43.2 101.66,43.2 101.69,43.17 101.71,43.17
  BOTTOM w0.102: C194.1 104.08,43.17 101.71,43.17
PEG_TXN7: length 90.2
  IN1 w0.089: v2(100.49,114.06) 100.19,113.75 100.14,113.75 100.13,113.75 99.21,114.67 98.38,114.67 95.9,112.19 95.9,108.45 94.96,107.51 94.96,103.49 94.35,102.88 94.35,100.04 94.17,99.86 94.17,98.6 93.89,98.32 93.89,93.45 93.97,93.37 93.97,93.03 93.76,92.82 93.76,85.08 93.41,84.73 93.41,80.63 93.48,80.55 93.48,78.49 94.98,76.99 94.98,73.76 95.49,73.25 95.49,72.18 95.21,71.9 95.21,71.5 95.31,71.4 95.31,70.79 95.41,70.69 95.41,69.59 95.29,69.46 95.29,68.76 95.31,68.74 95.31,67.3 95.29,67.28 95.29,66.35 95.31,66.32 95.31,64.69 95.29,64.66 95.29,61.4 95.39,61.3 95.39,60.26 95.18,60.06 95.18,59.07 95.85,58.41 95.85,57.85 97.14,56.55 99.75,56.55 100.93,55.38 100.93,55.05 102.5,53.47 102.5,47.6 102.85,47.26 106.21,47.26 106.87,46.6 106.87,45.62 106.78,45.53 106.58,45.53 v2(106.37,45.74)
  BOTTOM w0.102: C6551.2 101.77,44.28 102.7,44.28 103.22,44.8 105.23,44.8 105.97,45.54 106.17,45.54 v2(106.37,45.74) ; U8.AF9 100.91,113.64 v2(100.49,114.06)
PEG_TXN7_C: length 5.1
  BOTTOM w0.079: C6551.1 100.86,44.34 100.31,44.34 99.12,45.53 97.78,45.53 97.59,45.71 96.98,45.71 U1.BU2
PEG_TXN8: length 86.5
  IN1 w0.089: v2(105.09,45.27) 104.94,45.43 103.76,45.43 101.87,47.32 101.87,53.24 100.29,54.82 100.29,55.05 100.09,55.26 96.45,55.26 94.22,57.49 94.22,59.97 93.38,60.81 93.38,63.3 93.22,63.46 93.22,68.21 93.27,68.26 93.27,68.75 93,69.02 93,69.72 93.23,69.95 93.23,71.06 93.28,71.11 93.28,77.12 92.87,77.52 92.87,80.25 92.64,80.48 92.64,84.27 92.18,84.73 92.18,85.79 93.06,86.67 93.06,92.81 92.87,92.99 92.87,97.51 93.18,97.82 93.18,100.21 93.73,100.77 93.73,107.28 95.24,108.78 95.24,112.38 98.26,115.4 99.19,115.4 99.37,115.58 99.78,115.58 v2(99.99,115.78)
  BOTTOM w0.102: v2(105.09,45.27) 104.9,45.46 104.62,45.46 104.55,45.4 C6550.2 ; v2(99.99,115.78) 100.2,115.57 100.96,115.57 101.55,114.98 101.55,114.59 U8.AG10
PEG_TXN8_C: length 9.3
  BOTTOM w0.079: U1.BT4 96.01,45.76 96.69,45.76 96.81,45.88 97.68,45.88 97.85,45.71 99.28,45.71 100.06,44.92 100.56,44.92 100.59,44.89 100.61,44.89
  BOTTOM w0.102: 100.61,44.89 101.41,44.89 102.01,45.49 103.84,45.49 C6550.1
PEG_TXP5: length 94
  IN1 w0.089: v2(104.79,42.58) 104.63,42.74 104.63,43.15 104.42,43.36 104.42,44.2 101.38,47.24 101.38,53.05 100.8,53.63 99.45,53.63 98.79,54.29 95.7,54.29 95.61,54.38 94.04,54.38 93.69,54.73 93.69,56.85 93.48,57.06 92.55,57.06 92.34,57.27 92.34,70.32 92.29,70.37 92.29,73.27 92.47,73.45 92.47,80.08 92.21,80.33 92.21,84.14 91.19,85.17 91.19,85.63 92.66,87.1 92.66,92.64 92.48,92.83 92.48,97.82 92.78,98.13 92.78,100.4 93.34,100.95 93.34,108.2 94.8,109.66 94.8,113.24 97.63,116.06 98.54,116.06 98.61,115.99 v2(98.61,115.81)
  BOTTOM w0.102: U8.AG6 98.58,114.43 98.77,114.62 98.77,115.1 99.16,115.49 99.16,115.95 99.04,116.07 98.77,116.07 98.61,115.91 v2(98.61,115.81) ; v2(104.79,42.58) 104.58,42.37 104.58,42.18 104.29,41.88 103.17,41.88 102.75,42.3 101.73,42.3 C193.2
PEG_TXP5_C: length 7
  BOTTOM w0.079: C193.1 101.18,42.07 101.26,42.15 101.26,42.38 101.18,42.45 100.15,42.45 99.83,42.77 99.83,43.48 99.25,44.06 97.96,44.06 97.59,44.42 97.43,44.42 97.05,44.34 97.01,44.34 96.94,44.36 96.76,44.41 96.68,44.41 96.36,44.28 U1.BW3
PEG_TXP6: length 84.2
  IN1 w0.089: v2(98.84,114.02) 98.51,113.7 98.28,113.7 96.51,111.93 96.51,108.2 95.58,107.27 95.58,103.13 94.96,102.51 94.96,100.54 95.13,100.36 95.13,98.14 94.5,97.5 94.5,93.71 94.93,93.29 94.93,92.28 94.35,91.71 94.35,81.95 94.45,81.85 94.45,80.09 95.21,79.34 95.21,77.66 95.85,77.02 95.85,74.93 96.3,74.48 96.3,59.87 96.61,59.57 96.61,58.17 97.21,57.57 99.6,57.57 101.61,55.55 101.61,55.21 103.24,53.58 103.24,49.77 104.02,48.98 104.68,48.98 104.76,49.06 105.47,49.06 107.53,47 107.53,44.85 107.31,44.63 106,44.63 105.79,44.42 105.79,44.25 v2(105.6,44.06)
  BOTTOM w0.102: v2(98.84,114.02) U8.AF7 ; v2(105.6,44.06) 105.78,43.88 105.78,43.73 105.65,43.6 104.81,43.6 C195.2
PEG_TXP6_C: length 9.6
  BOTTOM w0.079: U1.BU3 96.07,45.53 96.14,45.59 96.34,45.59 96.4,45.53 96.4,45.35 96.43,45.28 96.63,45.18 96.81,45.18 96.94,45.25 97.16,45.25 97.27,45.2 97.4,45.18 98.96,45.18 100.79,43.35 101.66,43.35 101.69,43.38 101.71,43.38
  BOTTOM w0.102: C195.1 104.13,43.83 104.13,43.6 104.04,43.51 103.91,43.51 103.78,43.38 101.71,43.38
PEG_TXP7: length 90.3
  IN1 w0.089: v2(100.49,113.25) 100.19,113.55 100.14,113.55 100.04,113.55 99.13,114.46 98.46,114.46 96.1,112.1 96.1,108.37 95.16,107.43 95.16,103.41 94.55,102.8 94.55,99.95 94.37,99.77 94.37,98.51 94.09,98.23 94.09,93.53 94.17,93.46 94.17,92.95 93.96,92.74 93.96,84.99 93.61,84.64 93.61,80.72 93.69,80.64 93.69,78.57 95.18,77.08 95.18,73.84 95.69,73.33 95.69,72.1 95.41,71.82 95.41,71.59 95.52,71.49 95.52,70.88 95.62,70.78 95.62,69.51 95.49,69.38 95.49,68.85 95.52,68.82 95.52,67.22 95.49,67.19 95.49,66.43 95.52,66.41 95.52,64.6 95.49,64.58 95.49,61.49 95.59,61.39 95.59,60.18 95.39,59.97 95.39,59.15 96.05,58.49 96.05,57.93 97.23,56.76 99.83,56.76 101.13,55.46 101.13,55.13 102.7,53.55 102.7,47.69 102.93,47.46 106.29,47.46 107.07,46.68 107.07,45.53 106.86,45.33 106.58,45.33 v2(106.37,45.11)
  BOTTOM w0.102: U8.AE9 v2(100.49,113.25) ; v2(106.37,45.11) 106.37,45.22 106.26,45.33 106.06,45.33 105.32,44.59 103.31,44.59 102.79,44.06 101.77,44.06 C6553.2
PEG_TXP7_C: length 5
  BOTTOM w0.079: U1.BU1 97.47,45.55 97.53,45.55 97.71,45.37 99.06,45.37 100.25,44.18 101.18,44.18 101.26,44.11 101.26,43.88 101.18,43.8 C6553.1
PEG_TXP8: length 86.4
  IN1 w0.089: v2(99.99,115.05) 99.99,115.28 99.88,115.38 99.45,115.38 99.27,115.2 98.34,115.2 95.44,112.3 95.44,108.7 93.94,107.2 93.94,100.68 93.38,100.13 93.38,97.73 93.08,97.43 93.08,93.08 93.26,92.89 93.26,86.58 92.38,85.7 92.38,84.82 92.85,84.35 92.85,80.56 93.08,80.33 93.08,77.61 93.48,77.2 93.48,71.03 93.43,70.98 93.43,69.86 93.2,69.63 93.2,69.1 93.47,68.83 93.47,68.17 93.42,68.12 93.42,63.55 93.58,63.38 93.58,60.9 94.42,60.06 94.42,57.58 96.54,55.46 100.17,55.46 100.49,55.14 100.49,54.9 102.07,53.33 102.07,47.41 103.85,45.63 104.86,45.63 v2(105.09,45.86)
  BOTTOM w0.102: U8.AG9 101.11,114.24 101.26,114.24 101.33,114.31 101.33,114.9 100.87,115.35 100.06,115.35 99.99,115.28 v2(99.99,115.05) ; v2(105.09,45.86) 104.91,45.68 104.63,45.68 104.55,45.76 C6552.2
PEG_TXP8_C: length 9.3
  BOTTOM w0.079: U1.BT3 96.25,46.02 96.15,46.11 96.15,46.21 96.25,46.32 96.61,46.32 96.88,46.04 97.74,46.04 97.92,45.86 99.35,45.86 100.13,45.08 100.56,45.08 100.59,45.11 100.61,45.11
  BOTTOM w0.102: C6552.1 103.85,45.71 101.92,45.71 101.32,45.11 100.61,45.11
PEGX_RST#: length 8.1
  TOP w0.102: R384.2 102.69,124.34 103.19,124.84 103.69,124.84 104.02,124.5 v1(104.02,124.19)
  BOTTOM w0.102: R305.1 R306.2 100.65,124.58 100.93,124.85 102.71,124.85 102.81,124.95 R296.1 103.19,125.34 v1(103.69,124.83) 104.02,124.5 v1(104.02,124.19)
PEGX_RST#_C: length 2.7
  BOTTOM w0.102: v1(99.68,122.46) 99.88,122.66 R305.2 99.76,123.3 98.73,124.33 U9.4
PEX_CLKREQ#: length 39.7
  TOP w0.102: v1(91.5,110.7) 91.5,109.71 90.1,108.32 87.16,108.32 86.42,107.58 86.42,106.92 85.63,106.13 85.63,103.82 85.02,103.21 85.02,99.55 86.04,98.54 v1(86.04,98.41)
  IN2 w0.089: v1(84.52,93.46) 85.02,93.97 85.28,93.97 85.91,94.6 85.91,96.63 85.55,96.99 85.55,97.92 v1(86.04,98.41)
  BOTTOM w0.102: U8.AC6 97.95,110.76 94.91,110.76 94.58,111.09 93.94,111.09 93.53,111.49 92.29,111.49 v1(91.5,110.7) ; Q9.1 83.95,91.69 83.12,92.52 83.12,94.4 84.19,95.46 v1(84.29,95.46) 85.04,95.46 R297.1 84.62,94.87 84.62,94.21 R25487.2 84.74,93.68 v1(84.52,93.46)
PEX_TERMP: length 7.3
  BOTTOM w0.102: v1(116.67,119.44) 117.08,119.04 117.08,118.1 116.82,117.83 R312.2 116.65,116.83 114.49,114.67 114.49,113.99 U8.AF25
PEX_TSTCLK: length 6.3
  BOTTOM w0.102: U8.AF22 112.2,114.2 112.2,114.81 113.46,116.06 114.49,116.06 115.16,116.73 115.16,117.45 115.03,117.58 R307.2
PEX_TSTCLK#: length 7.2
  BOTTOM w0.102: R307.1 115.48,117.56 115.35,117.43 115.35,116.65 114.57,115.87 113.54,115.87 112.39,114.73 112.39,114.12 112.08,113.81 112.08,113.28 U8.AE22
PHASE1_CORE: length 14.4
  TOP w0.508: v1(118.35,71.12) 118.35,70.46 PC7105.1
  IN2 w0.508: v1(126.55,65.31) 126.27,65.59 120.51,65.59 120.25,65.85 120.25,67.22 119.19,68.29 119.19,69.46 118.35,70.29 v1(118.35,71.12)
  BOTTOM w0.254: PU7002.2 118.46,71 118.35,71.11 v1(118.35,71.12)
  vias: v1(132.4,62.83)
PHASE2_CORE: length 12.6
  IN3 w0.508: v1(133.36,45.72) 133.36,46.01 132.78,46.6 131.08,46.6 126.1,51.57 v1(126.1,52.06)
  BOTTOM w0.254: v1(133.36,45.72) PU7001.2
  BOTTOM w0.508: PC7056.1 133.36,45.24 v1(133.36,45.72)
  vias: v1(131.05,55.56)
PHASE_GT: length 16
  TOP w0.508: v1(128.46,75.42) 128.3,75.59 PC7101.1
  IN3 w0.508: v3(118.73,78.75) 119.09,78.4 127.01,78.4 128.3,77.11 128.3,75.59 v1(128.46,75.42)
  BOTTOM w0.254: PU7003.2 128.25,75.63 v1(128.46,75.42)
  BOTTOM w0.508: 113.96,76.89 PR7095.2
  vias: v1(117.82,79.13)
PHASE_SA: length 10.3
  TOP w0.508: v1(135.7,39.36) v1(137.02,39.36) 137.73,39.36 137.88,39.2 138.85,39.2 139.25,39.61 141.21,39.61 141.46,39.86 141.46,40.58 141.38,40.66 PC7103.1 141.97,40.96 v1(142.63,40.3)
  BOTTOM w0.254: PU7004.2 141.87,40.55 142.12,40.3 v1(142.63,40.3)
  vias: v1(134.71,43.12)
PIRQA#: length 77.6
  TOP w0.079: v2(77.51,41.92) 78,41.42 79.53,41.42 79.69,41.26 79.69,40.88 79.94,40.63 80.77,40.63 81.02,40.38 81.02,38.13 80.55,37.66 80.55,36.82 79.69,35.95 79.69,35.67
  TOP w0.102: R593.1 R580.1 120.88,24.34 120.51,23.98 119.87,23.98 119.54,23.64 v2(118.92,23.64) ; 79.69,35.67 79.69,33.08 79.13,32.52 79.13,32.07 79.56,31.63 79.89,31.63 80.86,30.67 80.86,29.09 80.71,28.94 78.8,28.94 78.04,28.18 78.04,25.89 78.16,25.78 R179.1 78.29,25.83 78.29,27.7 v2(78.8,28.21)
  IN2 w0.089: v2(118.92,23.64) 118.32,24.24 112.41,24.24 112.21,24.05 111.13,24.05 108.26,21.18 104.34,21.18 103.56,20.4 102.36,20.4 96.98,25.78 96.01,25.78 95.57,26.22 94.12,26.22 93.89,26.45 93.89,27.27 93.25,27.9 91.6,27.9 91.5,27.79 89.51,27.79 88.28,29.02 87.44,29.02 85.87,30.59 82.3,30.59 81.47,29.76 81.47,29.29 80.59,28.41 79.41,28.41 79.21,28.21 v2(78.8,28.21)
  BOTTOM w0.079: U1.CC32 77.74,41.69 v2(77.51,41.92)
PLTRST#: length 450.8
  TOP w0.102: v1(48.04,104.13) 48.04,104.28 47.52,104.8 U24.19 ; v1(95.92,121.3) 94.85,120.23 94.85,116.23 94.56,115.94 92.14,115.94 90.23,114.03 90.23,111.21 87.74,108.72 86.99,108.72 85.91,107.65 85.91,107.05 85.23,106.36 85.23,104 84.54,103.31 84.54,99.83 84.26,99.55 84.26,99 v1(84.49,98.77) ; v1(29.53,3.42) 29.4,3.54 R648.2 ; v2(175.65,17.05) 176,16.71 v1(176.52,16.71) 176.82,16.71 178.32,18.21 R2665.2 178.42,18.27 R894.1 ; v2(119.62,16.85) 119.62,19.14 119.87,19.39 119.87,21.4 119.57,21.7 119.57,22.26 119.29,22.54 119.01,22.54 118.52,23.03 118.52,23.83 118.77,24.08 119.29,24.08 119.63,24.42 120.33,24.42 120.74,24.83 122.31,24.83 122.42,24.72 R601.1
  IN1 w0.089: v1(29.02,67.4) 27.83,66.21 27.83,64.94 27.01,64.12 27.01,39.88 27.14,39.75 27.14,38.79 31.17,34.75 35.42,34.75 36.19,33.98 42.71,33.98 44.43,32.27 46.21,32.27 48.18,30.31 48.18,29.91 48.77,29.31 52.16,29.31 52.17,29.32 52.25,29.32 ; 52.25,29.32 52.25,27.17 52.79,26.63 52.79,22.58 52.09,21.88 52.09,21.45 52.91,20.63 52.91,19.71 53.35,19.26 54.27,19.26 56.01,17.53 56.01,14.98 55.49,14.47 49.96,14.47 48,12.51 48,11.86 46.7,10.55 46.7,9.63 46.24,9.17 42.08,9.17 38.59,5.68 38.59,4.05 38.01,3.47 38.01,2.83 37.76,2.58 30.36,2.58 v1(29.53,3.42) ; 52.25,29.32 52.39,29.46 52.96,29.46 53.29,29.79 53.59,29.79 53.96,29.42 55.87,29.42 56.46,30.01 59.61,30.01 v2(59.99,29.63) 60.26,29.36 61.62,29.36 62.08,28.9 62.08,28.5 61.58,28 61.58,27.72 60.12,26.26 60.12,25.7 59.36,24.95 59.36,21.03 63.46,16.93 73.47,16.93 74.44,17.9 78.15,17.9 83.14,22.89 89.26,22.89 94.39,17.75 98.73,17.75 98.88,17.6 101.47,17.6 102.64,16.43 107.67,16.43 108.27,17.03 119.44,17.03 v2(119.62,16.85) 120.06,16.41 122.61,16.41 122.97,16.78 125.16,16.78 125.52,16.41 138.47,16.41 139.28,17.23 142.59,17.23 143.4,16.41 175.34,16.41 175.65,16.72 v2(175.65,17.05) ; v1(48.04,104.13) 48.27,104.13 50.45,106.3 50.69,106.3 51.52,107.14 52.79,107.14 55.03,104.89 58.86,104.89 60.39,103.36 62.55,103.36 63.69,102.22 65.21,102.22 65.95,101.48 73.13,101.48 73.45,101.81 74.46,101.81 74.97,101.29 77.38,101.29 78.05,100.63 81.54,100.63 82.87,99.3 83.96,99.3 v1(84.49,98.77)
  IN3 w0.089: v1(29.02,67.4) 28.62,67.8 28.62,73.24 28.14,73.72 27.01,73.72 25.47,75.26 25.47,76.48 24.85,77.1 24.85,81.9 24.59,82.17 24.43,82.17 24.17,82.43 24.17,84.72 24.87,85.41 24.87,86.82 25.66,87.62 26.86,87.62 27.95,88.71 27.95,92.84 29.57,94.46 29.57,95.39 32.33,98.16 42.48,98.16 44.69,100.37 44.69,102.27 45.3,102.88 46.19,102.88 47.43,104.13 v1(48.04,104.13)
  BOTTOM w0.079: 71.33,45.93 71.47,45.93 73.79,48.26 73.79,48.6 74.97,49.77 75.72,49.77 U1.BJ35
  BOTTOM w0.102: v1(95.92,121.3) 96.23,121.3 96.77,121.84 96.77,122.37 97.24,122.84 97.24,123.53 97.09,123.68 U9.2 ; 71.33,45.93 69.49,45.93 68.99,46.43 67.79,46.43 67.02,47.2 66.25,47.2 65.39,48.07 65.39,49.78 65.24,49.93 65.24,50.62 R56.2 65.21,51.13 65.21,52.12 64.41,52.92 62.52,52.92 61.78,52.18 61.78,50.88 59.91,49.01 59.91,29.71 v2(59.99,29.63)
