# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ59: length 47.9
  TOP w0.102: U4.C8 v1(45.07,38.68)
  IN3 w0.089: v1(45.07,38.68) 45.4,38.35 45.4,38.12 45.47,38.05 45.47,37.64 46.28,36.83 46.86,36.83 48.69,35.01 57.73,35.01 57.94,35.21 57.94,35.34 57.77,35.51 57.77,35.63 57.89,35.76 58.02,35.76 58.19,35.59 58.31,35.59 58.44,35.72 58.44,35.84 58.27,36.01 58.27,36.14 58.4,36.26 58.52,36.26 58.69,36.09 58.82,36.09 58.94,36.22 58.94,36.34 58.77,36.51 58.77,36.64 58.9,36.77 59.02,36.77 59.19,36.6 59.32,36.6 59.44,36.72 59.44,36.85 59.28,37.02 59.28,37.14 59.4,37.27 59.53,37.27 59.7,37.1 59.82,37.1 60.12,37.4 64.41,37.4 66.12,39.11 66.36,39.11 66.45,39.03 66.45,38.84 66.54,38.75 66.72,38.75 66.8,38.84 66.8,39.03 66.89,39.11 68.57,39.11 69.44,39.98 71.68,39.98 73.4,41.7 74.19,41.7 74.84,42.35 74.84,43.65 75.62,44.43 75.62,46.1 76.55,47.03 77.46,47.03 77.63,47.2 77.63,48.09 78.72,49.18 v2(78.72,49.25)
  BOTTOM w0.079: v2(78.72,49.25) 78.39,49.58 U1.BK31
M_B_DQ60: length 48.9
  TOP w0.102: v1(43.88,40.63) 43.93,40.68 43.93,43.02 U4.D3
  IN3 w0.089: v2(80.02,51.99) 79.63,51.61 78.86,51.61 78.7,51.45 77.91,51.45 77.66,51.19 77.66,50.91 77.02,50.28 77.02,49.39 76.06,48.42 76.06,47.73 74.76,46.43 74.76,45.17 71.69,42.1 68.88,42.1 68.11,41.32 67.35,41.32 66.77,40.75 65.35,40.75 64.27,39.67 62.22,39.67 61.83,39.28 59.31,39.28 56.87,36.84 50.71,36.84 48.21,39.34 47.57,39.34 46.92,39.99 44.51,39.99 v1(43.88,40.63)
  BOTTOM w0.079: U1.BG29 79.69,51.66 v2(80.02,51.99)
M_B_DQ61: length 48.6
  TOP w0.102: v1(44.51,40.63) 44.51,40.68 44.28,40.91 44.28,43.45 44.67,43.83 U4.C2
  IN3 w0.089: v1(44.51,40.63) 45.5,40.63 46.07,41.2 47.12,41.2 47.84,40.47 49.31,40.47 50.41,39.38 50.41,39.09 51.1,38.4 52.11,38.4 52.74,39.03 54.3,39.03 54.92,38.4 57.19,38.4 58.95,40.16 61.47,40.16 61.85,40.54 63.91,40.54 64.99,41.63 66.41,41.63 67.76,42.98 71.3,42.98 73.47,45.15 73.47,45.9 75.53,47.95 75.53,48.67 76.49,49.63 76.49,50.5 77.13,51.13 77.13,51.57 77.9,52.35 79.02,52.35 79.37,52 v2(79.37,51.99)
  BOTTOM w0.079: v2(79.37,51.99) 79.04,51.66 U1.BG30
M_B_DQ62: length 49.3
  TOP w0.102: U4.C7 v1(45.07,39.48)
  IN3 w0.089: v2(79.37,49.25) 79.3,49.25 77.81,47.76 77.81,46.95 77.59,46.73 76.51,46.73 75.8,46.02 75.8,44.25 75.13,43.58 75.13,42.23 74.32,41.41 73.52,41.41 71.76,39.65 69.52,39.65 68.16,38.29 67.51,38.29 67.42,38.38 67.42,38.56 67.33,38.64 67.15,38.64 67.06,38.56 67.06,38.38 66.98,38.29 65.71,38.29 64.49,37.07 60.26,37.07 57.9,34.71 47.98,34.71 47.77,34.92 47.77,35.05 47.94,35.21 47.94,35.34 47.81,35.47 47.69,35.47 47.52,35.3 47.39,35.3 47.27,35.42 47.27,35.55 47.44,35.72 47.44,35.84 47.31,35.97 47.18,35.97 47.02,35.8 46.89,35.8 45.49,37.2 44.9,37.2 44.67,37.43 44.67,39.08 v1(45.07,39.48)
  BOTTOM w0.079: v2(79.37,49.25) 79.04,49.58 U1.BK30
M_B_DQ63: length 50
  TOP w0.102: U4.D7 44.27,39.48 v1(44.27,39.48)
  IN3 w0.089: v1(44.27,39.48) 43.85,39.06 43.85,37.73 44.67,36.91 45.37,36.91 47.86,34.42 58.02,34.42 60.38,36.78 64.61,36.78 65.83,38 68.28,38 69.63,39.35 71.87,39.35 73.64,41.12 74.36,41.12 75.42,42.18 75.42,43.47 75.98,44.02 75.98,44.72 76.87,45.61 76.87,45.86 77.57,46.56 77.8,46.56 78.27,47.03 78.93,47.03 79.14,47.23 79.14,47.97 78.97,48.14 78.97,48.56 79.25,48.84 79.48,48.84 79.75,49.1 79.75,49.54 79.37,49.92 v2(79.37,50.16)
  BOTTOM w0.079: v2(79.37,50.16) 79.69,49.84 U1.BK29
M_B_DQSN0: length 51.3
  TOP w0.102: U6.A7 v1(46.67,88.16)
  IN3 w0.089: v1(46.67,88.16) 46.67,87.85 46.82,87.69 47.09,87.69 48.11,86.67 48.11,85.99 48.66,85.43 49.05,85.43 49.6,85.98 50.15,85.98 51.51,84.62 53.18,84.62 53.59,85.03 55.25,85.03 55.66,84.62 62.6,84.62 62.8,84.41 62.8,83.11 62.92,82.99 63.21,82.99 63.3,83.08 63.3,84.41 63.51,84.62 63.99,84.62 64.2,84.41 64.2,83.51 64.29,83.43 64.61,83.43 64.7,83.51 64.7,84.41 64.9,84.62 65.57,84.62 65.82,84.36 65.82,83.56 65.99,83.39 66.79,83.39 67.92,82.27 73.76,82.27 74.2,81.82 77.63,81.82 77.91,81.55 77.91,80.73 79.56,79.08 79.98,79.08 80.62,78.45 82.11,78.45 83.1,77.46 83.1,76.22 82.97,76.09 82.87,75.99 82.66,75.99 82.66,75.99 v2(82.44,75.78)
  BOTTOM w0.102: v2(82.44,75.78) 82.81,75.42 U1.H24
M_B_DQSN1: length 62.3
  TOP w0.102: U6.F3 v1(42.67,90.56)
  IN3 w0.089: v2(83.5,81.82) 83.99,82.31 83.99,84.5 82.1,86.38 79.37,86.38 79.28,86.47 79.28,87.12 79.07,87.33 78.58,87.33 78.38,87.12 78.38,86.47 78.29,86.38 77.97,86.38 77.88,86.47 77.88,87.61 77.67,87.81 77.19,87.81 76.98,87.61 76.98,86.47 76.89,86.38 75.61,86.38 74.89,85.66 73.56,85.66 73.27,85.37 69.24,85.37 66.23,88.38 61.22,88.38 60.79,88.82 59.31,88.82 58.55,89.58 57.8,89.58 57.49,89.27 54.84,89.27 54.75,89.36 54.75,90.08 54.54,90.29 53.87,90.29 53.67,90.08 53.67,89.66 53.58,89.57 53.26,89.57 53.17,89.66 53.17,90.08 52.96,90.29 52.48,90.29 52.27,90.08 52.27,89.66 52.18,89.57 51.86,89.57 51.77,89.66 51.77,90.08 51.57,90.29 50.48,90.29 49.63,91.14 48.13,91.14 47.31,91.96 44.92,91.96 44.56,91.6 43.65,91.6 43.29,91.24 43.29,90.33 43,90.04 42.46,90.04 42.37,90.13 42.37,90.26 v1(42.67,90.56)
  BOTTOM w0.076: v2(83.5,81.82) 83.23,81.82 83.13,81.73 83.13,79.86 83.3,79.69 83.3,79.2 83.3,79.19
  BOTTOM w0.079: U1.C23 83.53,78.18 83.45,78.1 83.37,78.1 83.29,78.15 83.27,78.29 83.27,78.39 83.3,78.55 83.3,78.77 83.27,78.87 83.27,79.07 83.3,79.19
M_B_DQSN2: length 51.5
  TOP w0.102: U7.F3 42.6,77.66 42.73,77.53 42.73,77.32 v1(42.67,77.26)
  IN3 w0.089: v1(42.67,77.26) 42.37,77.26 42.25,77.38 42.25,77.56 43.06,78.37 43.06,79.18 43.88,79.99 44.27,79.99 44.93,80.65 44.93,80.94 45.02,81.03 45.34,81.03 45.43,80.94 45.43,80.49 45.69,80.23 46.19,80.23 46.47,80.52 46.47,80.94 46.56,81.03 46.88,81.03 46.97,80.94 46.97,80.65 47.94,79.68 53.59,79.68 53.94,79.34 56.69,79.34 57.05,78.97 59.31,78.97 59.57,79.23 59.57,79.32 59.66,79.41 59.97,79.41 60.06,79.32 60.06,79.18 60.27,78.97 60.93,78.97 61.14,79.18 61.14,79.67 61.23,79.75 61.55,79.75 61.64,79.67 61.64,79.18 61.84,78.97 62.33,78.97 62.54,79.18 62.54,79.67 62.63,79.75 62.94,79.75 63.03,79.67 63.03,79.18 63.24,78.97 63.73,78.97 63.94,79.18 63.94,79.67 64.02,79.75 64.34,79.75 64.43,79.67 64.43,79.18 64.64,78.97 65.12,78.97 65.33,79.18 65.33,79.67 65.42,79.75 65.74,79.75 65.83,79.67 65.83,78.36 66.17,78.01 66.67,78.01 66.92,78.27 67.6,78.27 67.85,78.01 72.1,78.01 72.35,78.26 73.46,78.26 73.73,78 75.8,78 76.87,76.93 76.87,76.37 77.19,76.06 78.89,76.06 78.98,75.96 78.98,75.88 78.79,75.68 v2(78.79,75.68)
  BOTTOM w0.102: U1.G30 78.79,76.14 78.65,76 78.65,75.82 v2(78.79,75.68)
M_B_DQSN3: length 41
  TOP w0.102: U7.A7 45.85,74.88 v1(45.85,75.06)
  IN3 w0.089: v1(45.85,75.06) 45.75,74.96 45.75,74.71 45.84,74.61 47.67,74.61 48.13,75.07 49.55,75.07 49.85,74.77 57.21,74.77 57.62,75.18 60.17,75.18 60.47,74.88 60.47,74.2 60.56,74.11 60.88,74.11 60.97,74.2 60.97,74.97 61.18,75.18 61.66,75.18 61.87,74.97 61.87,74.2 61.96,74.11 62.28,74.11 62.37,74.2 62.37,74.56 62.57,74.77 63.06,74.77 63.27,74.56 63.27,74.2 63.36,74.11 63.67,74.11 63.76,74.2 63.76,74.56 63.97,74.77 64.64,74.77 65.15,74.26 65.64,74.26 65.94,74.55 66.43,74.55 66.72,74.26 72.96,74.26 73.01,74.2 75.68,74.2 76.08,73.8 76.91,73.8 77.24,73.47 78.64,73.47 79.19,72.92 v2(79.3,72.92)
  BOTTOM w0.079: U1.L30 79.04,73.18 v2(79.3,72.92)
M_B_DQSN4: length 43
  TOP w0.102: U5.A7 46.07,53.03 45.99,53.1 45.99,53.33 46.06,53.4 46.06,54.11 46.32,54.36 v1(46.48,54.36)
  IN3 w0.089: v2(78.12,61.98) 78.29,61.98 78.36,61.9 78.36,61.73 78.2,61.58 75.99,61.58 75.72,61.3 75.72,61.03 74.61,59.93 74.61,59.17 73.79,58.35 72.97,58.35 72.09,57.47 71.73,57.47 69.91,55.65 69.91,55.14 69.54,54.76 68.35,54.76 68.14,54.56 68.14,54.3 68.05,54.22 67.73,54.22 67.65,54.3 67.65,54.56 67.44,54.76 66.86,54.76 65.44,53.35 61.48,53.35 61.18,53.04 60.34,53.04 59.18,51.88 54.59,51.88 53.9,51.2 50.42,51.2 49.06,52.55 48.45,52.55 47.2,53.8 46.37,53.8 46.05,54.12 46.05,54.21 46.21,54.36 v1(46.48,54.36)
  BOTTOM w0.079: U1.AL31 78.39,61.83 78.24,61.98 v2(78.12,61.98)
M_B_DQSN5: length 51.2
  TOP w0.102: U5.F3 42.2,56.16 41.9,56.16 41.8,56.06 41.8,55.51 41.87,55.43 42.34,55.43 42.41,55.36 42.41,55 v1(42.27,54.86)
  IN3 w0.089: v2(78.07,58.37) 78.07,58.13 77.95,58.02 77.29,58.02 74.21,54.94 73.63,54.94 69.78,51.09 69.78,50.74 68.97,49.92 66.48,49.92 66.2,49.64 65.18,49.64 64.98,49.44 64.98,49.11 64.89,49.02 64.57,49.02 64.48,49.11 64.48,49.44 64.27,49.64 63.55,49.64 63.4,49.49 63.4,49.07 63.31,48.98 62.99,48.98 62.9,49.07 62.9,49.29 62.7,49.5 62.03,49.5 59.89,47.36 55.19,47.36 54.9,47.07 50.25,47.07 48.24,49.08 47.94,49.08 47.51,49.52 43.95,49.52 42.47,51 42.47,53.71 41.94,54.25 41.94,54.53 v1(42.27,54.86)
  BOTTOM w0.079: U1.AU31 78.39,58.22 78.24,58.37 v2(78.07,58.37)
M_B_DQSN6: length 50.1
  TOP w0.102: U4.F3 v1(42.67,42.68)
  IN3 w0.089: v2(78.72,53.81) 78.72,54.09 78.63,54.18 77.85,54.18 77.6,53.92 77.6,53.85 77.01,53.26 77.01,53.03 75.75,51.78 75.75,51.42 75.35,51.01 75.35,50.08 75.31,50.04 75.31,50 73.81,48.5 73.81,47.71 71.04,44.94 64.8,44.94 63.01,43.15 59.03,43.15 57.71,41.84 57.31,41.84 57.1,42.05 57.1,42.47 57.01,42.56 56.69,42.56 56.6,42.47 56.6,42.05 56.4,41.84 55.9,41.84 55.7,41.64 54.97,41.64 54.71,41.38 54.22,41.38 53.96,41.64 53.96,41.91 53.87,42 53.47,42 53.38,41.91 53.38,41.63 53.13,41.38 52.62,41.38 52.42,41.59 52.42,41.79 52.33,41.88 52.01,41.88 51.92,41.79 51.92,41.59 51.71,41.38 51.19,41.38 49.15,43.42 46.17,43.42 45.76,43.01 45.22,43.01 45.05,43.19 45.05,43.59 44.96,43.68 44.64,43.68 44.55,43.59 44.55,43.32 44.35,43.12 43.87,43.12 43.38,43.61 42.88,43.61 42.38,43.12 42.38,42.97 v1(42.67,42.68)
  BOTTOM w0.079: v2(78.72,53.81) 78.72,54.15 78.6,54.27 U1.BC31
M_B_DQSN7: length 48
  TOP w0.102: U4.A7 v1(46.67,39.48)
  IN3 w0.089: v2(78.72,51.08) 78.72,50.81 78.6,50.7 77.85,50.7 77.38,50.22 77.38,48.64 75,46.25 75,44.7 71.88,41.59 70.57,41.59 70.36,41.38 70.36,41.06 70.27,40.98 69.95,40.98 69.86,41.06 69.86,41.38 69.66,41.59 69.08,41.59 68.24,40.75 67.49,40.75 67,40.26 65.86,40.26 64.76,39.15 64.36,39.15 64.13,38.93 64.13,38.53 64.01,38.41 63.51,38.41 63.42,38.49 63.42,38.96 63.22,39.17 62.73,39.17 62.52,38.96 62.52,38.49 62.43,38.41 62.12,38.41 62.03,38.49 62.03,38.58 61.82,38.78 61.33,38.78 61.13,38.58 61.13,38.49 61.04,38.41 60.77,38.41 60.39,38.78 59.52,38.78 57.06,36.33 49.91,36.33 49.82,36.42 49.82,37.02 49.11,37.73 48.76,37.73 48.39,37.36 48.27,37.36 48.04,37.59 48.04,37.71 48.41,38.08 48.41,38.38 47.94,38.85 46.7,38.85 46.42,39.13 46.42,39.23 v1(46.67,39.48)
  BOTTOM w0.102: v2(78.72,51.08) 78.78,51.01 78.78,50.75 78.65,50.62 U1.BH31
M_B_DQSP0: length 51.3
  TOP w0.102: U6.B7 v1(45.87,88.16)
  IN3 w0.089: v1(45.87,88.16) 46.54,87.49 47,87.49 47.9,86.59 47.9,85.9 48.58,85.23 49.13,85.23 49.68,85.77 50.06,85.77 51.42,84.42 53.26,84.42 53.67,84.82 55.16,84.82 55.57,84.42 62.51,84.42 62.6,84.33 62.6,83.02 62.83,82.79 63.3,82.79 63.5,83 63.5,84.33 63.59,84.42 63.91,84.42 64,84.33 64,83.43 64.21,83.22 64.69,83.22 64.9,83.43 64.9,84.33 64.99,84.42 65.48,84.42 65.62,84.28 65.62,83.48 65.91,83.19 66.71,83.19 67.83,82.07 73.67,82.07 74.12,81.62 77.55,81.62 77.71,81.46 77.71,80.65 79.48,78.88 79.9,78.88 80.54,78.24 82.03,78.24 82.9,77.37 82.9,76.31 82.83,76.24 82.83,76.24 82.78,76.19 82.66,76.19 v2(82.45,76.41)
  BOTTOM w0.102: v2(82.45,76.41) 82.79,76.07 U1.G24
M_B_DQSP1: length 62.4
  TOP w0.102: U6.G3 v1(41.87,90.56)
  IN3 w0.089: v1(41.87,90.56) 42.17,90.26 42.17,90.05 42.38,89.84 43.09,89.84 43.5,90.25 43.5,91.16 43.74,91.4 44.65,91.4 45,91.76 47.23,91.76 48.05,90.94 49.55,90.94 50.4,90.09 51.48,90.09 51.57,90 51.57,89.58 51.78,89.37 52.27,89.37 52.47,89.58 52.47,90 52.56,90.09 52.88,90.09 52.97,90 52.97,89.58 53.18,89.37 53.66,89.37 53.87,89.58 53.87,90 53.96,90.09 54.45,90.09 54.54,90 54.54,89.27 54.75,89.06 57.58,89.06 57.89,89.37 58.47,89.37 59.23,88.61 60.71,88.61 61.14,88.18 66.14,88.18 69.16,85.17 73.35,85.17 73.64,85.46 74.97,85.46 75.7,86.18 76.97,86.18 77.18,86.39 77.18,87.52 77.27,87.61 77.59,87.61 77.68,87.52 77.68,86.39 77.89,86.18 78.37,86.18 78.58,86.39 78.58,87.04 78.67,87.13 78.99,87.13 79.08,87.04 79.08,86.39 79.28,86.18 82.02,86.18 83.79,84.41 83.79,82.69 v2(83.5,82.41)
  BOTTOM w0.076: v2(83.5,82.41) 83.5,82.33 82.97,81.79 82.97,79.79 83.13,79.62 83.13,79.21 83.1,79.09 83.1,78.85 83.13,78.75 83.13,78.57 83.1,78.41 83.1,78.27 83.14,78.05 83.32,77.93 83.45,77.93 83.53,77.85 U1.D23
M_B_DQSP2: length 51.4
  TOP w0.102: U7.G3 v1(41.87,77.26)
  IN3 w0.089: v1(41.87,77.26) 42.05,77.43 42.05,77.64 42.86,78.46 42.86,79.26 43.8,80.2 44.19,80.2 44.73,80.74 44.73,81.03 44.94,81.23 45.42,81.23 45.63,81.03 45.63,80.58 45.77,80.44 46.1,80.44 46.27,80.6 46.27,81.03 46.48,81.23 46.96,81.23 47.17,81.03 47.17,80.74 48.02,79.89 53.68,79.89 54.03,79.54 56.77,79.54 57.13,79.18 59.23,79.18 59.36,79.31 59.36,79.41 59.57,79.62 60.06,79.62 60.26,79.41 60.26,79.27 60.35,79.18 60.85,79.18 60.94,79.27 60.94,79.75 61.15,79.96 61.63,79.96 61.84,79.75 61.84,79.27 61.93,79.18 62.25,79.18 62.33,79.27 62.33,79.75 62.54,79.96 63.03,79.96 63.24,79.75 63.24,79.27 63.33,79.18 63.64,79.18 63.73,79.27 63.73,79.75 63.94,79.96 64.43,79.96 64.63,79.75 64.63,79.27 64.72,79.18 65.04,79.18 65.13,79.27 65.13,79.75 65.34,79.96 65.82,79.96 66.03,79.75 66.03,78.44 66.25,78.22 66.58,78.22 66.84,78.47 67.68,78.47 67.93,78.22 72.01,78.22 72.26,78.47 73.55,78.47 73.81,78.21 75.85,78.21 77.05,77.01 77.05,76.45 77.26,76.23 78.96,76.23 79.16,76.03 79.16,75.92 v2(79.39,75.69)
  BOTTOM w0.102: U1.H30 79.11,75.23 79.31,75.42 79.31,75.61 v2(79.39,75.69)
M_B_DQSP3: length 40.9
  TOP w0.102: U7.B7 45.47,74.54 45.05,74.97 v1(45.05,75.06)
  IN3 w0.089: v2(78.67,72.89) 78.67,73.17 78.56,73.28 77.16,73.28 76.83,73.61 76,73.61 75.61,74 72.92,74 72.87,74.05 66.64,74.05 66.34,74.34 66.02,74.34 65.73,74.05 65.07,74.05 64.55,74.57 64.06,74.57 63.97,74.48 63.97,74.11 63.76,73.91 63.27,73.91 63.06,74.11 63.06,74.48 62.98,74.57 62.66,74.57 62.57,74.48 62.57,74.11 62.36,73.91 61.88,73.91 61.67,74.11 61.67,74.89 61.58,74.98 61.26,74.98 61.17,74.89 61.17,74.11 60.96,73.91 60.48,73.91 60.27,74.11 60.27,74.8 60.09,74.98 57.7,74.98 57.29,74.57 49.76,74.57 49.46,74.87 48.21,74.87 47.76,74.41 45.76,74.41 45.11,75.06 v1(45.05,75.06)
  BOTTOM w0.079: U1.N30 79.04,72.52 v2(78.67,72.89)
M_B_DQSP4: length 42.9
  TOP w0.102: U5.B7 45.78,53.34 45.78,53.42 45.85,53.49 45.85,54.19 v1(45.68,54.36)
  IN3 w0.089: v1(45.68,54.36) 45.85,54.19 45.85,54.03 46.28,53.6 47.12,53.6 48.37,52.35 48.98,52.35 50.33,51 53.98,51 54.67,51.68 59.27,51.68 60.42,52.84 61.26,52.84 61.56,53.14 65.52,53.14 66.94,54.56 67.35,54.56 67.44,54.47 67.44,54.22 67.65,54.01 68.14,54.01 68.34,54.22 68.34,54.47 68.43,54.56 69.62,54.56 70.12,55.05 70.12,55.56 71.82,57.26 72.17,57.26 73.05,58.14 73.87,58.14 74.81,59.08 74.81,59.84 75.89,60.92 75.89,61.23 76.07,61.4 78.28,61.4 78.55,61.67 78.55,61.81 v2(78.72,61.98)
  BOTTOM w0.079: U1.AL30 79.04,61.65 v2(78.72,61.98)
M_B_DQSP5: length 51
  TOP w0.102: U5.G3 41.58,56.12 41.58,54.86 v1(41.59,54.85)
  IN3 w0.089: v2(78.72,58.37) 78.19,57.84 77.36,57.84 74.28,54.76 73.74,54.76 69.99,51.01 69.99,50.65 69.06,49.72 66.57,49.72 66.29,49.44 65.27,49.44 65.18,49.35 65.18,49.03 64.97,48.82 64.49,48.82 64.28,49.03 64.28,49.35 64.19,49.44 63.64,49.44 63.6,49.4 63.6,48.98 63.39,48.77 62.91,48.77 62.7,48.98 62.7,49.2 62.61,49.29 62.11,49.29 59.97,47.16 55.28,47.16 54.99,46.87 50.17,46.87 48.15,48.88 47.86,48.88 47.42,49.31 43.87,49.31 42.27,50.91 42.27,53.63 41.74,54.16 41.74,54.7 v1(41.59,54.85)
  BOTTOM w0.079: v2(78.72,58.37) 79.04,58.04 U1.AU30
M_B_DQSP6: length 50.1
  TOP w0.102: U4.G3 v1(41.87,42.68)
  IN3 w0.089: v2(78.72,54.72) 78.35,54.35 77.78,54.35 77.42,54 77.42,53.96 76.81,53.34 76.81,53.08 75.58,51.85 75.58,51.49 75.17,51.09 75.17,50.15 73.61,48.58 73.61,47.8 70.95,45.15 64.71,45.15 62.92,43.36 58.94,43.36 57.63,42.04 57.39,42.04 57.3,42.13 57.3,42.55 57.09,42.76 56.61,42.76 56.4,42.55 56.4,42.13 56.31,42.04 55.82,42.04 55.62,41.85 54.89,41.85 54.63,41.58 54.3,41.58 54.16,41.73 54.16,42 53.95,42.21 53.39,42.21 53.18,42 53.18,41.72 53.05,41.58 52.71,41.58 52.62,41.67 52.62,41.87 52.41,42.08 51.92,42.08 51.72,41.87 51.72,41.67 51.63,41.58 51.27,41.58 49.23,43.63 46.09,43.63 45.68,43.22 45.31,43.22 45.25,43.27 45.25,43.67 45.04,43.88 44.56,43.88 44.35,43.67 44.35,43.41 44.27,43.32 43.95,43.32 43.46,43.81 42.79,43.81 42.18,43.2 42.18,42.99 v1(41.87,42.68)
  BOTTOM w0.079: v2(78.72,54.72) 79.04,54.4 U1.BC30
M_B_DQSP7: length 48.1
  TOP w0.102: U4.B7 v1(45.87,39.48)
  IN3 w0.089: v1(45.87,39.48) 46.21,39.14 46.21,39.04 46.61,38.64 47.86,38.64 48.21,38.29 48.21,38.17 47.84,37.8 47.84,37.5 48.18,37.16 48.48,37.16 48.85,37.53 49.02,37.53 49.62,36.93 49.62,36.34 49.83,36.13 57.15,36.13 59.6,38.58 60.3,38.58 60.68,38.2 61.12,38.2 61.33,38.41 61.33,38.49 61.42,38.58 61.74,38.58 61.82,38.49 61.82,38.41 62.03,38.2 62.52,38.2 62.73,38.41 62.73,38.88 62.81,38.97 63.13,38.97 63.22,38.88 63.22,38.41 63.43,38.2 64.09,38.2 64.34,38.45 64.34,38.85 64.44,38.95 64.84,38.95 65.95,40.05 67.08,40.05 67.58,40.55 68.32,40.55 69.16,41.39 69.57,41.39 69.66,41.3 69.66,40.98 69.87,40.77 70.36,40.77 70.56,40.98 70.56,41.3 70.65,41.39 71.97,41.39 75.2,44.62 75.2,46.19 77.58,48.58 77.58,50.18 77.93,50.52 78.36,50.52 v2(78.72,50.16)
  BOTTOM w0.102: v2(78.72,50.16) 79.04,50.49 U1.BH30
M_B_PARITY: length 163.9
  TOP w0.076: R293.2 30.86,96.24 32.76,94.33 32.76,92.46 v1(33.44,91.78) U6.T3 ; U4.T3 34.23,43.12 33.75,43.12 33.67,43.19 33.67,43.32 33.59,43.39 33.47,43.39 33.39,43.32 33.39,43.19 33.31,43.12 33.19,43.12 33.11,43.19 33.11,43.32 33.03,43.39 32.91,43.39 32.83,43.32 32.83,43.19 32.76,43.12 31.51,43.12 v1(31.43,43.04) ; U7.T3 32.54,77.66 32.27,77.93 v1(30.95,77.93) ; v1(30.95,56.5) 32.27,56.5 32.54,56.23 U5.T3
  IN1 w0.089: v1(33.44,91.78) 33.44,91.51 32.56,90.63 32.56,90.36 32.43,90.23 32.24,90.23 31.89,90.58 31.18,90.58 30.98,90.38 30.98,82.67 31.82,81.84 31.82,80.29 31.37,79.84 31.37,78.35 v1(30.95,77.93) 30.78,77.76 30.78,71.14 31.25,70.66 31.25,70.53 31.17,70.45 30.86,70.45 30.78,70.36 30.78,70.24 30.86,70.16 31.17,70.16 31.25,70.07 31.25,67.99 31.17,67.91 30.87,67.91 30.8,67.84 30.8,67.73 30.87,67.65 31.17,67.65 31.25,67.57 31.25,67.46 31.17,67.38 30.87,67.38 30.8,67.3 30.8,67.19 30.87,67.11 31.17,67.11 31.25,67.04 31.25,66.93 31.17,66.85 30.87,66.85 30.8,66.77 30.8,66.66 30.87,66.58 31.17,66.58 31.25,66.5 31.25,66.39 31.17,66.31 30.87,66.31 30.8,66.24 30.8,66.13 30.87,66.05 31.17,66.05 31.25,65.97 31.25,61.43 31.51,61.17 31.51,59.97 31.37,59.84 31.37,56.93 v1(30.95,56.5) 30.57,56.12 30.57,55.87 30.65,55.79 30.7,55.79 30.78,55.71 30.78,55.6 30.7,55.52 30.65,55.52 30.57,55.44 30.57,55.33 30.65,55.25 30.7,55.25 30.78,55.18 30.78,55.07 30.7,54.99 30.65,54.99 30.57,54.91 30.57,54.8 30.65,54.72 30.7,54.72 30.78,54.64 30.78,54.53 30.7,54.45 30.65,54.45 30.57,54.38 30.57,54.27 30.65,54.19 30.7,54.19 30.78,54.11 30.78,54 30.7,53.92 30.65,53.92 30.57,53.84 30.57,53.73 30.65,53.65 30.7,53.65 30.78,53.58 30.78,53.47 30.7,53.39 30.65,53.39 30.57,53.31 30.57,53.2 30.65,53.12 30.7,53.12 30.78,53.04 30.78,52.93 30.7,52.85 30.65,52.85 30.57,52.78 30.57,52.67 30.65,52.59 30.7,52.59 30.78,52.51 30.78,52.4 30.7,52.32 30.65,52.32 30.57,52.24 30.57,52.13 30.65,52.05 30.86,52.05 30.95,51.97 30.95,51.88 30.86,51.79 30.65,51.79 30.57,51.71 30.57,48.33 30.97,47.92 31.21,47.92 31.68,47.45 31.68,47.11 31.52,46.95 30.87,46.95 30.73,46.81 30.73,46.55 30.61,46.44 30.36,46.44 30.11,46.19 30.11,45.15 30.36,44.89 30.59,44.89 30.68,44.8 30.68,44.58 31.61,43.65 31.61,43.21 v1(31.43,43.04)
  IN3 w0.14: v2(67.88,65.77) 64.89,65.77 64.77,65.9 64.77,66.32 64.68,66.41 64.38,66.41 64.26,66.29 64.26,66.15 64.14,66.03 63.96,66.03 63.84,66.15 63.84,66.29 63.72,66.41 63.55,66.41 63.42,66.29 63.42,66.16 63.3,66.03 63.13,66.03 63,66.16 63,66.29 62.88,66.41 60.66,66.41 60.52,66.27 60.52,66.17 60.39,66.05 60.22,66.05 60.1,66.17 60.1,66.27 59.96,66.41 59.68,66.41 59.36,66.09 59.36,65.87 59.27,65.78 59,65.78 58.88,65.66 58.88,65.48 58.75,65.36 58.58,65.36 58.46,65.48 58.46,65.66 58.34,65.78 58.16,65.78 58.04,65.66 58.04,65.48 57.92,65.36 57.74,65.36 57.62,65.48 57.62,65.66 57.5,65.78 57.32,65.78 57.2,65.66 57.2,65.48 57.08,65.36 56.9,65.36 56.78,65.48 56.78,65.66 56.66,65.78 56.49,65.78 56.36,65.66 56.36,65.48 56.24,65.36 56.07,65.36 55.94,65.48 55.94,65.66 55.82,65.78 55.65,65.78 55.52,65.66 55.52,65.48 55.4,65.36 55.23,65.36 55.11,65.48 55.11,65.66 54.98,65.78 54.81,65.78 54.69,65.66 54.69,65.48 54.56,65.36 54.39,65.36 54.27,65.48 54.27,65.66 54.14,65.78 53.97,65.78 53.85,65.66 53.85,65.48 53.73,65.36 53.55,65.36 53.43,65.48 53.43,65.66 53.31,65.78 53.13,65.78 53.01,65.66 53.01,65.48 52.86,65.33 51.08,65.33 51.07,65.32 40.76,65.32 40.48,65.6 35.81,65.6 31.49,61.28 31.49,60.32 29.16,57.99 29.16,57.61 29.04,57.49 28.83,57.49 28.71,57.36 28.71,57.19 28.83,57.07 29.04,57.07 29.16,56.94 29.16,56.77 29.04,56.65 28.83,56.65 28.71,56.52 28.71,56.35 28.83,56.23 29.04,56.23 29.16,56.11 29.16,55.93 29.04,55.81 28.83,55.81 28.71,55.69 28.71,55.51 28.83,55.39 29.04,55.39 29.16,55.27 29.16,55.09 29.04,54.97 28.83,54.97 28.71,54.85 28.71,54.67 28.83,54.55 29.04,54.55 29.16,54.43 29.16,54.26 29.04,54.13 28.83,54.13 28.71,54.01 28.71,53.84 28.83,53.71 29.04,53.71 29.16,53.59 29.16,53.42 29.04,53.29 28.83,53.29 28.71,53.17 28.71,53 28.83,52.88 29.04,52.88 29.16,52.75 29.16,51.99 29.41,51.75 29.41,47.14 29.28,47.02 29.01,47.02 28.88,46.9 28.88,46.72 29.01,46.6 29.21,46.6 29.33,46.48 29.33,46.3 29.21,46.18 29.02,46.18 28.9,46.06 28.9,45.88 29.02,45.76 29.28,45.76 29.41,45.64 29.41,45.43 29.56,45.27 29.9,45.27 30.07,45.44 30.07,46.14 30.37,46.44 30.86,46.44 31.19,46.11 31.19,45.06 31.67,44.58 31.67,43.28 v1(31.43,43.04)
  BOTTOM w0.076: U1.AE34 76.69,64.42 76.55,64.27 76.03,64.27 76.01,64.3 75.65,64.3 75.53,64.32 75.28,64.32 75.18,64.3 74.96,64.3 74.87,64.32 74.27,64.32 74.2,64.25 73.7,64.25 73.42,64.53 68.17,64.53 67.13,65.57 67.13,66.06 67.26,66.19 67.46,66.19 v2(67.88,65.77)
M_B_RAS#: length 169.8
  TOP w0.076: v1(36.13,76.23) 36.43,76.23 37.91,74.75 37.91,74.02 U7.L8 ; v1(37.23,88.89) 37.23,88.72 37.91,88.05 37.91,87.36 38.27,87 U6.L8 ; v1(36.13,54.8) 36.51,54.8 37.91,53.4 37.91,52.63 38.27,52.27 U5.L8 ; U4.L8 38.27,39.12 37.83,39.56 37.83,40 36.82,41.01 36.54,41.01 v1(36.54,41.01) ; v1(33.59,94.47) 33.59,94.64 32.5,95.74 R290.2
  IN1 w0.089: v1(36.54,41.01) 36.94,41.01 37.1,41.16 37.1,41.32 36.98,41.44 36.66,41.44 36.38,41.72 36.38,45.12 37.12,45.86 37.12,46.39 37.2,46.47 37.58,46.47 37.65,46.55 37.65,46.66 37.58,46.74 37.2,46.74 37.12,46.82 37.12,46.93 37.2,47 37.58,47 37.65,47.08 37.65,47.19 37.58,47.27 37.2,47.27 37.12,47.35 37.12,47.46 37.2,47.54 37.58,47.54 37.65,47.62 37.65,47.73 37.58,47.8 37.2,47.8 37.12,47.88 37.12,49.6 37.03,49.69 36.74,49.69 36.13,50.3 36.13,52.32 36.25,52.44 36.25,54.68 v1(36.13,54.8) 36.56,55.22 36.56,55.49 36.65,55.58 36.65,56.83 37.26,57.44 37.26,59.67 37.5,59.91 37.5,60.2 37.58,60.27 37.78,60.27 37.86,60.35 37.86,60.46 37.78,60.54 37.58,60.54 37.5,60.62 37.5,60.73 37.58,60.81 38.06,60.81 38.14,60.89 38.14,61 38.06,61.07 37.58,61.07 37.5,61.15 37.5,67.22 36.14,68.59 36.14,71.72 36.13,71.73 36.13,73.75 36.25,73.87 36.25,76.1 v1(36.13,76.23) 36.56,76.65 36.56,76.91 36.65,77 36.65,78.25 37.26,78.87 37.26,81.94 36.34,82.86 36.34,86.88 36.7,87.24 37.68,87.24 37.75,87.31 37.75,87.42 37.68,87.5 37.22,87.5 37.14,87.58 37.14,87.69 37.22,87.77 37.65,87.77 37.76,87.88 37.76,88.36 v1(37.23,88.89)
  IN3 w0.089: v1(37.23,88.89) 37.02,88.89 36.51,89.39 36.51,90.2 36.05,90.66 34.61,90.66 33.88,91.39 33.88,94.18 v1(33.59,94.47)
  IN3 w0.14: v2(71.59,63.21) 71.28,63.52 71.28,63.65 71.42,63.79 72.96,63.79 73.1,63.93 73.1,64.07 72.88,64.29 67.47,64.29 66.98,63.8 65.57,63.8 65.41,63.96 60.7,63.96 58.71,61.97 58.01,61.97 57.88,62.09 57.88,62.3 57.76,62.43 57.59,62.43 57.46,62.3 57.46,62.09 57.34,61.97 57.17,61.97 57.05,62.09 57.05,62.3 56.92,62.43 56.75,62.43 56.63,62.3 56.63,62.09 56.5,61.97 56.33,61.97 56.21,62.09 56.21,62.3 56.08,62.43 55.91,62.43 55.79,62.3 55.79,62.09 55.67,61.97 55.49,61.97 55.37,62.09 55.37,62.3 55.25,62.43 55.07,62.43 54.95,62.3 54.95,62.09 54.83,61.97 54.65,61.97 54.53,62.09 54.53,62.3 54.41,62.43 54.23,62.43 54.11,62.3 54.11,62.09 53.99,61.97 53.87,61.97 53.73,61.83 53.73,61.44 53.61,61.31 53.44,61.31 53.31,61.44 53.31,61.74 53.19,61.87 53.02,61.87 52.89,61.74 52.89,61.44 52.77,61.31 52.6,61.31 52.48,61.44 52.48,61.74 52.35,61.87 52.18,61.87 52.06,61.74 52.06,61.44 51.93,61.31 51.76,61.31 51.64,61.44 51.64,61.74 51.51,61.87 51.21,61.87 51.09,61.99 51.09,62.65 50.73,63.01 40.04,63.01 39.27,63.78 37.67,63.78 37.11,63.22 36.3,63.22 36.09,63 36.09,62.55 36.47,62.17 36.47,61.83 33.86,59.23 33.86,58.86 33.2,58.19 32.64,58.19 32.49,58.04 32.49,57.65 32.61,57.53 32.92,57.53 33.04,57.41 33.04,57.23 32.92,57.11 32.61,57.11 32.49,56.99 32.49,56.74 32.61,56.62 32.92,56.62 33.04,56.49 33.04,56.32 32.92,56.2 32.61,56.2 32.49,56.08 32.49,55.9 32.61,55.78 33.33,55.78 33.46,55.66 33.46,55.48 33.33,55.36 32.55,55.36 32.42,55.22 32.42,51.5 32.54,51.38 32.63,51.38 32.75,51.25 32.75,51.08 32.63,50.96 32.54,50.96 32.42,50.84 32.42,50.54 32.17,50.3 32.17,49.45 32.3,49.32 32.63,49.32 32.75,49.2 32.75,49.03 32.63,48.9 32.3,48.9 32.17,48.78 32.17,48.54 32.31,48.4 32.55,48.4 32.75,48.19 32.75,46.94 35.1,44.6 35.1,43.73 35.38,43.45 35.38,43.22 35.22,43.05 33.82,43.05 33.68,42.92 33.68,42.72 33.82,42.58 35.77,42.58 35.85,42.5 35.85,40.88 35.95,40.78 36.31,40.78 v1(36.54,41.01)
  BOTTOM w0.076: U1.AJ34 76.48,62.68 76.15,63.01 75.12,63.01 74.86,63.11 74.53,63.11 74.49,63.07 72.56,63.07 72.35,62.85 71.8,62.85 71.59,63.06 v2(71.59,63.21)
M_B_WE#: length 162.9
  TOP w0.076: U5.L2 38.27,56.84 37.91,56.48 37.91,55.69 v1(38.03,55.56) ; U7.L2 38.27,78.26 37.91,77.9 37.91,77.11 v1(38.03,76.99) ; v1(38.09,90.19) 38.09,90.24 37.91,90.41 37.91,91.39 U6.L2 ; v1(36.23,94.5) 36.36,94.63 R288.2 ; v1(38.19,41.46) 38.19,41.74 37.88,42.05 37.88,43.39 38.27,43.78 U4.L2
  IN1 w0.089: v1(38.19,41.46) 38.72,40.93 38.72,39.97 38.81,39.88 38.94,39.88 39.03,39.97 39.03,41.29 37.4,42.91 37.4,44.7 38.2,45.5 38.63,45.5 38.8,45.67 38.8,50.98 37.27,52.51 37.27,54.28 37.61,54.62 37.61,55.1 38.03,55.53 v1(38.03,55.56) 38.28,55.8 38.28,58.05 38.77,58.54 38.77,59.74 39.15,60.12 39.15,64.15 39.05,64.25 38.72,64.25 38.64,64.32 38.64,64.44 38.72,64.51 39.07,64.51 39.15,64.59 39.15,64.7 39.07,64.78 38.6,64.78 38.52,64.86 38.52,64.97 38.6,65.05 39.07,65.05 39.15,65.13 39.15,65.24 39.07,65.31 38.6,65.31 38.52,65.39 38.52,67.64 37.96,68.2 37.96,73.24 37.27,73.94 37.27,75.7 37.61,76.04 37.61,76.53 38.03,76.95 v1(38.03,76.99) 38.52,77.47 38.52,78.12 38.28,78.36 38.28,86.05 38.27,86.06 38.27,88.63 37.94,88.96 37.94,90.04 v1(38.09,90.19)
  IN3 w0.089: v1(36.23,94.5) 36.23,94.07 35.67,93.51 35.67,92.01 37.49,90.19 38.08,90.19 v1(38.09,90.19)
  IN3 w0.14: v2(66.58,61.39) 66.58,61.5 66.45,61.64 65.78,61.64 65.67,61.53 65.67,61.31 65.22,60.86 64.87,60.86 64.16,60.15 60.16,60.15 58.57,58.56 58.57,58.21 58.51,58.15 58.02,58.15 57.9,58.02 57.9,57.73 57.78,57.61 57.6,57.61 57.48,57.73 57.48,58.02 57.36,58.15 55.84,58.15 55.72,58.02 55.72,57.73 55.59,57.61 55.42,57.61 55.3,57.73 55.3,58.02 55.17,58.15 54.88,58.15 54.69,57.96 54.69,57.54 54.36,57.21 51,57.21 50.6,57.61 50.6,58.06 50.74,58.2 53.82,58.2 53.96,58.34 53.96,58.51 53.82,58.65 50.41,58.65 50.05,59.01 50.05,59.31 49.93,59.43 49.3,59.43 49.18,59.55 49.18,59.72 49.3,59.85 49.93,59.85 50.05,59.97 50.05,60.3 49.87,60.48 46.82,60.48 46.07,61.23 41.19,61.23 40.98,61.01 40.82,61.01 40.59,61.24 40.37,61.24 40.14,61.01 39.46,61.01 39.46,61.01 39.28,61.01 38.85,61.44 38.67,61.44 38.55,61.32 38.55,61.15 38.99,60.71 38.99,60.54 38.86,60.41 38.69,60.41 38.2,60.91 38.02,60.91 37.9,60.78 37.9,60.61 38.4,60.12 38.4,59.94 38.27,59.82 38.1,59.82 37.61,60.32 37.43,60.32 37.31,60.19 37.31,60.02 37.8,59.52 37.8,59.35 37.35,58.9 37.35,57.29 37.2,57.14 36.84,57.14 36.61,56.91 36.61,53.69 36.74,53.57 37.28,53.57 37.4,53.45 37.4,53.27 37.28,53.15 36.74,53.15 36.61,53.03 36.61,52.86 36.74,52.73 37.28,52.73 37.4,52.61 37.4,52.44 37.28,52.31 36.74,52.31 36.61,52.19 36.61,50.04 36.75,49.9 37.26,49.9 37.4,49.76 37.4,49.47 37.28,49.35 36.52,49.35 36.4,49.23 36.4,49.05 36.52,48.93 37.28,48.93 37.4,48.81 37.4,48.63 37.28,48.51 36.77,48.51 36.65,48.39 36.65,48.22 36.77,48.09 37.28,48.09 37.4,47.97 37.4,45.06 37.41,45.05 37.41,42.76 38.28,41.89 38.38,41.89 38.71,41.56 38.71,41.27 38.62,41.18 38.47,41.18 v1(38.19,41.46)
  BOTTOM w0.076: U1.AJ35 75.79,62.43 75.26,62.43 75.18,62.46 74.92,62.46 74.86,62.43 74.49,62.43 74.34,62.58 72.77,62.58 72.55,62.36 67.98,62.36 67.83,62.2 67.83,61.81 67.75,61.74 67.63,61.74 67.55,61.81 67.55,62.28 67.47,62.36 67.35,62.36 67.27,62.28 67.27,61.81 67.19,61.74 67.07,61.74 66.99,61.81 66.99,62.25 66.89,62.36 66.69,62.36 66.58,62.25 v2(66.58,61.39)
MAIND: length 128.8
  TOP w0.102: PQ9.2 25.67,32.66 25.35,32.98 ; PR2060.2 105.09,37.43 104.89,37.22 v2(104.71,37.22)
  TOP w0.114: v1(29.14,32.5) 26.27,32.5 PQ9.2 ; PR59.2 27.09,36.16 26.1,35.17 24.45,35.17 24.31,35.03 PC51.1 24.56,34.53 PQ6.3 25.35,32.98
  IN2 w0.089: v1(29.14,32.5) 29.44,32.5 31.81,30.13 34.58,30.13 36.34,28.36 39.7,28.36 40.46,27.6 40.46,26.87 43.3,24.03 47.03,24.03 49.24,21.81 52.4,21.81 52.98,21.23 57.9,21.23 59.68,19.46 62.18,19.46 63.64,17.99 69.65,17.99 70.42,18.76 75.58,18.76 75.94,19.12 79.21,19.12 83.38,23.29 89.34,23.29 94.27,18.36 96.29,18.36 96.33,18.4 98.3,18.4 98.45,18.25 104.22,18.25 105.1,19.14 109.13,19.14 110.68,20.69 v2(111.95,20.69)
  IN3 w0.089: v2(104.71,37.22) 104.42,36.93 104.42,34.77 104.89,34.3 105.7,34.3 106.05,33.95 106.05,31.37 107.88,29.53 107.88,28.97 109.13,27.72 109.13,24.78 108.99,24.64 108.99,22.42 110.72,20.69 v2(111.95,20.69)
MAINON: length 359
  TOP w0.102: v1(54.06,19.8) 54.06,19.75 54.32,19.49 54.32,14.77 53.76,14.21 49.08,14.21 v1(47.67,12.8) 47.28,12.4 PR9270.2 ; PQ16.2 28.02,41.07 27.82,40.88 27.34,40.88 26.91,40.45 v2(26.2,40.45) ; PR6417.2 168.08,18.55 v2(168.9,19.37) ; v2(136.31,19.57) 136.13,19.75 136.13,20.41 135.8,20.74 135.8,22.74 135.42,23.13 135.42,23.73 135.57,23.88 135.57,24.23 135.86,24.53 136.31,24.53 138.44,26.66 139.15,26.66 v2(139.36,26.86) 139.36,26.94 140.04,27.62 PR9268.2 ; v2(179.44,16.42) 179.66,16.64 R890.1 180.5,16.64 180.96,17.11 181.95,17.11 182.48,16.58 U37.30 ; v1(27.87,28.05) 27.44,28.49 PR6028.1 ; v2(25.03,49.54) 25.03,49.69 25.98,50.64 PR120.1
  TOP w0.254: PR265.2 66.71,125.43 v1(66.71,125.56)
  IN1 w0.089: v1(62.8,110.15) 63.51,110.86 63.51,111.67 63.35,111.83 63.35,120.8 65.02,122.46 65.94,122.46 66.99,123.51 66.99,124.19 66.71,124.47 v1(66.71,125.56)
  IN2 w0.089: v2(168.9,19.37) 168.9,19.26 168.42,18.79 166.14,18.79 165.87,19.06 165.87,19.52 165.65,19.74 165.34,19.74 164.98,19.39 163.33,19.39 162.77,18.83 155.05,18.83 154.42,19.46 151.42,19.46 151.33,19.37 136.5,19.37 v2(136.31,19.57) 136.18,19.44 132.9,19.44 131.99,18.53 130.74,18.53 129.75,19.52 128.26,19.52 127.98,19.24 124.65,19.24 124.19,19.7 120.32,19.7 119.4,18.78 118.78,18.78 118.47,18.48 114.09,18.48 112.76,17.14 108.52,17.14 107.24,15.87 102.45,15.87 101.3,17.02 98.03,17.02 97.75,17.3 93.98,17.3 88.97,22.31 83.89,22.31 79.05,17.47 72.33,17.47 71.48,16.62 63.36,16.62 61.5,18.48 55.33,18.48 54.06,19.75 v1(54.06,19.8) 54.06,19.87 53.66,20.28 52.59,20.28 52.01,20.86 48.75,20.86 46.54,23.07 42.91,23.07 39.51,26.48 39.51,27.21 39.3,27.41 35.95,27.41 34.93,28.43 28.26,28.43 v1(27.87,28.05) ; v1(28.13,35.9) 28.13,36.79 26.66,38.26 26.66,39.99 v2(26.2,40.45) 26.67,40.92 26.67,45.49 26.57,45.6 26.57,48 v2(25.03,49.54) 25.33,49.54 26.07,50.27 26.07,74.09 25.74,74.42 25.74,81.41 26.61,82.29 26.61,84.08 25.79,84.9 25.16,84.9 24.9,85.16 24.9,86.88 27.56,89.53 27.56,91.85 30.14,94.43 30.14,95.64 32.04,97.54 43.85,97.54 45.06,98.75 48.84,98.75 49.73,99.63 49.73,101.16 50.86,102.29 50.86,103.13 51.23,103.49 51.96,103.49 53.94,105.47 54.57,105.47 54.89,105.79 54.89,106.8 55.03,106.94 55.03,107.28 55.12,107.36 56.75,107.36 57.5,108.12 57.5,110.16 57.81,110.47 62.48,110.47 v1(62.8,110.15)
  BOTTOM w0.102: v1(27.87,28.05) 29.4,28.05 29.91,28.56 29.91,31.13 29.45,31.58 28.41,31.58 27.7,32.29 27.7,35.47 v1(28.13,35.9) ; PR6016.1 147.97,27.95 147.25,27.24 145.22,27.24 144.61,27.85 143.57,27.85 142.89,27.16 141.79,27.16 141.55,27.41 139.83,27.41 139.36,26.94 v2(139.36,26.86) ; v2(179.44,16.42) 178.95,15.94 175.63,15.94 175.25,16.32 175.25,17.89 174.84,18.3 169.28,18.3 168.9,18.69 v2(168.9,19.37)
MAINON_ON_G: length 36.2
  TOP w0.254: v1(26.22,39.61) 26.44,39.83 PQ16.3 27.84,39.36 28.64,39.36 29.17,38.82 29.17,37.77 PR116.2 28.51,36.82 29.02,36.31 29.02,35.54 PR118.1 28.68,34.48 28.68,34.06 v1(28.33,33.72) 28.2,33.58 PQ6.2
  BOTTOM w0.254: PQ19.2 16.84,29.56 16.22,30.19 16.22,32.47 16.61,32.86 v1(16.98,32.86) 18.14,32.86 PQ14.2 18.22,32.95 18.22,33.64 17.84,34.02 16.75,34.02 16.57,34.2 16.57,35.87 16.91,36.22 PQ9050.2 PQ12.2 18.54,39.86 18.92,40.25 21.14,40.25 22.08,41.18 23.33,41.18 24.57,39.94 25.89,39.94 v1(26.22,39.61)
MBCLK: length 135.7
  TOP w0.102: R361.1 192.75,31.94 192.75,31.25 192.05,30.55 U37.110 192.05,29.08 190.43,27.47 190.43,27.16 189.72,26.45 188.95,26.45 188.68,26.19 188.68,25.15 188.8,25.03 189.48,25.03 189.58,24.93 190.09,24.93 190.48,25.32 192.58,25.32 193.01,24.89 193.01,24.16 194.3,22.87 194.3,20.23 194.64,19.89 194.64,19.5 194.26,19.13 v2(194.23,19.13) ; PD4.1 PC11.1 PR12.2 102.7,15.78 v1(102.7,16.98) ; v2(135.18,19.93) 135.32,20.06 135.32,22.58 134.96,22.94 134.96,23.92 135.11,24.07 135.11,24.42 135.67,24.98 136.12,24.98 139.3,28.17 139.3,29.17 v2(139,29.48)
  IN2 w0.089: v2(194.23,19.13) 194.04,19.32 193.36,19.32 192.78,18.73 191.96,18.73 190.77,19.92 187.29,19.92 187.06,20.15 186.72,20.15 186.49,19.92 184.18,19.92 183.91,19.65 181.91,19.65 181.43,20.12 180.77,20.12 180.49,20.4 180.24,20.4 179.74,20.9 177.32,20.9 176.27,19.85 167.24,19.85 167.04,20.05 165.38,20.05 164.98,19.65 161.38,19.65 155.02,19.65 154.92,19.75 136.97,19.75 136.66,20.05 136.13,20.05 135.85,19.77 135.34,19.77 v2(135.18,19.93) 134.95,19.7 132.89,19.7 132.03,18.83 130.72,18.83 129.84,19.71 126.95,19.71 126.26,20.4 122.22,20.4 122.13,20.48 120.53,20.48 119.87,19.82 119.87,19.52 119.33,18.97 118.7,18.97 118.66,18.93 114.18,18.93 112.58,17.33 108.44,17.33 107.22,16.12 103.57,16.12 v1(102.7,16.98)
  BOTTOM w0.102: PR17.1 138.72,29.3 138.9,29.48 v2(139,29.48)
MBDATA: length 133.6
  TOP w0.102: v2(112.1,18.02) 112.1,17.56 113.32,16.34 113.32,14.62 112.39,13.69 110.06,13.69 109.03,14.72 PD3.1 PC10.1 107.61,15.46 PR13.2 v1(106.11,14.59) ; v2(139.58,29.63) 139.53,29.58 139.53,28.08 136.21,24.75 135.77,24.75 135.34,24.33 135.34,23.97 135.19,23.82 135.19,23.03 135.55,22.68 135.55,20.41 135.72,20.23 v2(135.72,20.2) ; v2(194.23,19.71) 194.07,19.87 194.07,22.78 192.78,24.06 192.78,24.79 192.49,25.08 190.59,25.08 190.21,24.7 189.49,24.7 189.39,24.8 188.71,24.8 188.45,25.06 188.45,26.28 188.85,26.68 189.63,26.68 190.21,27.26 190.21,27.56 191.65,29 U37.111 191.65,30.58 191.93,30.87 191.93,31.84 R369.1
  IN2 w0.089: v2(194.23,19.71) 194.02,19.51 193.28,19.51 192.7,18.92 192.04,18.92 190.85,20.11 187.42,20.11 187.19,20.34 186.64,20.34 186.42,20.11 184.05,20.11 183.99,20.05 181.77,20.05 181.51,20.31 180.86,20.31 180.58,20.59 180.32,20.59 179.8,21.11 177.22,21.11 176.16,20.05 167.4,20.05 167.19,20.26 165.31,20.26 164.9,19.84 155.1,19.84 154.98,19.96 137.06,19.96 136.74,20.28 135.8,20.28 v2(135.72,20.2) 135.52,20.2 135.42,20.31 135.03,20.31 134.62,19.9 132.81,19.9 131.95,19.04 130.83,19.04 129.89,19.98 126.99,19.98 126.29,20.67 120.39,20.67 119.65,19.92 119.65,19.56 119.25,19.16 114.64,19.16 114.29,19.52 113.03,19.52 112.3,18.79 112.3,18.22 v2(112.1,18.02)
  BOTTOM w0.102: PR19.1 139.2,30.01 v2(139.58,29.63)
MDI0+: length 15.6
  TOP w0.102: v1(41.57,107.32) 41.6,107.32 41.82,107.09 41.82,107.07 42.1,106.8 U24.1
  IN1 w0.089: v1(41.57,107.32) 41.55,107.29 38.68,107.29 37.54,106.16 31.38,106.16 30.18,104.96 v1(30.18,104.35)
  BOTTOM w0.102: U25.9 29.9,104.07 v1(30.18,104.35)
MDI0+_1: length 24.8
  IN2 w0.089: v1(29.96,109.72) 30.23,109.45 30.23,109.38 29.84,108.99 23.84,108.99 14.92,100.07 13.52,100.07 13.22,99.77 CN8.1
  BOTTOM w0.102: U25.16 29.9,110.96 30.2,110.66 30.2,109.96 v1(29.96,109.72)
MDI0-: length 15.5
  TOP w0.102: v1(41.56,106.68) 41.56,106.47 41.63,106.4 U24.2
  IN1 w0.089: v1(41.56,106.68) 41.56,106.83 41.46,106.93 38.83,106.93 37.69,105.79 31.53,105.79 30.55,104.8 30.55,104.53 30.69,104.38 v1(30.9,104.38)
  BOTTOM w0.102: v1(30.9,104.38) 30.97,104.38 31.08,104.28 31.08,104.15 30.9,103.98 U25.8
MDI0-_1: length 24.8
  IN2 w0.089: CN8.2 13.45,99.48 13.68,99.71 15.07,99.71 23.99,108.62 29.99,108.62 30.6,109.23 v1(30.6,109.72)
  BOTTOM w0.102: v1(30.6,109.72) 30.6,110.66 30.9,110.96 U25.17
MDI1+: length 19.2
  TOP w0.102: v1(40.57,105.37) 40.8,105.59 41.93,105.59 41.93,105.59 42.53,105.59 U24.4
  IN3 w0.089: v1(40.57,105.37) 40.57,104.86 40.19,104.48 39.17,104.48 38.57,103.87 37.57,103.87 37.17,103.47 28.71,103.47 28.48,103.24 27.32,103.24 26.99,103.57 v1(26.99,104.38)
  BOTTOM w0.102: U25.12 26.9,104.01 26.99,104.1 v1(26.99,104.38)
MDI1+_1: length 24.7
  TOP w0.102: CN8.3 13.7,97.73 14.67,96.76 14.98,96.76 15.31,97.09 15.31,99.56 24.85,109.1 26.94,109.1 27.1,109.27 27.1,109.59 v1(26.98,109.71)
  BOTTOM w0.102: v1(26.98,109.71) 26.98,109.74 27.12,109.88 27.12,110.74 26.9,110.96 U25.13
MDI1-: length 19.2
  TOP w0.102: v1(39.94,105.37) 39.94,105.17 40.17,104.94 40.88,104.94 41.14,105.2 41.76,105.2 41.77,105.2 U24.5
  IN3 w0.089: v1(27.9,104.38) 27.87,104.35 27.6,104.35 27.47,104.23 27.47,103.77 27.52,103.72 28.28,103.72 28.51,103.95 36.97,103.95 37.37,104.35 38.37,104.35 38.97,104.96 39.99,104.96 40.09,105.06 40.09,105.22 v1(39.94,105.37)
  BOTTOM w0.102: U25.11 27.9,103.8 27.62,104.07 27.62,104.23 27.77,104.38 v1(27.9,104.38)
MDI1-_1: length 24.6
  TOP w0.102: CN8.6 15.71,96.93 15.71,99.4 25.02,108.71 27.1,108.71 27.49,109.1 27.49,109.59 v1(27.61,109.71)
  BOTTOM w0.102: v1(27.61,109.71) 27.61,109.74 27.51,109.84 27.51,110.58 27.9,110.96 U25.14
MDI2+: length 9.5
  TOP w0.102: U24.6 41.5,104.8 41.29,104.58 40.45,104.58 39.85,103.99 v1(39.82,103.99)
  IN1 w0.089: v1(39.82,103.99) 39.82,104 39.99,104.18 39.99,104.28 39.82,104.45 39.71,104.56 38.16,104.56 37.83,104.89 36.43,104.89 36.33,104.79 36.33,104.48 36.46,104.36 v1(36.62,104.36)
  BOTTOM w0.102: U25.2 36.9,104.08 v1(36.62,104.36)
MDI2+_1: length 35.4
  IN1 w0.089: CN8.4 13.45,96.2 13.7,95.95 14.4,95.95 15.19,96.73 15.19,100.11 23.95,108.88 33.93,108.88 35.43,110.37 36.3,110.37 36.64,110.04 v1(36.64,109.36)
  BOTTOM w0.102: U25.23 36.9,110.96 36.57,110.64 36.57,109.42 v1(36.64,109.36)
MDI2-: length 9.5
  TOP w0.102: v1(40.52,104) 40.71,104.19 41.45,104.19 41.66,104.4 42.53,104.4 U24.7
  IN1 w0.089: v1(35.9,104.38) 35.96,104.44 35.96,104.94 36.28,105.26 37.98,105.26 38.31,104.93 39.86,104.93 40.52,104.27 v1(40.52,104)
  BOTTOM w0.102: U25.3 v1(35.9,104.38)
MDI2-_1: length 35.5
  IN1 w0.089: v1(36,109.36) 36.27,109.62 36.27,109.89 36.15,110.01 35.58,110.01 34.09,108.51 24.1,108.51 15.56,99.96 15.56,96.58 14.55,95.58 13.55,95.58 13.44,95.69 CN8.5
  BOTTOM w0.102: U25.22 35.9,110.96 36.18,110.68 36.18,109.56 36,109.38 v1(36,109.36)
MDI3+: length 16.9
  TOP w0.102: v1(40.13,100.93) 40.13,100.83 40.44,100.52 42.3,100.52 42.76,100.98 42.76,102.42 43.24,102.9 U24.9
  IN1 w0.089: v1(33.18,104.4) 33.35,104.58 33.35,104.86 33.77,105.27 34.38,105.27 34.81,104.84 34.81,104 35.71,103.1 37.16,103.1 38.35,101.9 39.28,101.9 39.94,101.24 39.94,101.12 v1(40.13,100.93)
  BOTTOM w0.102: v1(33.18,104.4) 32.9,104.12 U25.6
MDI3+_1: length 32.8
  IN3 w0.089: CN8.7 13.79,93.65 15.58,95.44 15.58,100.37 24.42,109.21 32.73,109.21 32.96,109.44 v1(32.96,110)
  BOTTOM w0.102: U25.19 32.9,111.09 33.15,110.84 33.15,110.19 v1(32.96,110)
MDI3-: length 16.8
  TOP w0.102: v1(39.5,100.93) 39.5,100.9 39.73,100.66 40.27,100.13 42.47,100.13 43.15,100.81 43.15,102.26 43.64,102.75 U24.10
  IN1 w0.089: v1(39.5,100.93) 39.5,101.17 39.13,101.54 38.2,101.54 37.01,102.73 35.56,102.73 34.44,103.85 34.44,104.68 34.22,104.9 33.92,104.9 33.72,104.7 33.72,104.58 33.9,104.4 v1(33.9,104.38)
  BOTTOM w0.102: v1(33.9,104.38) U25.5
MDI3-_1: length 32.8
  IN3 w0.089: v1(33.6,110) 33.44,109.85 33.44,109.24 32.93,108.72 24.62,108.72 16.06,100.17 16.06,95.24 CN8.8
  BOTTOM w0.102: U25.20 33.9,111.12 33.54,110.76 33.54,110.06 v1(33.6,110)
ME_WR#: length 164.3
  TOP w0.102: R118.1 62.91,46.37 63.18,46.65 v1(63.18,46.72) ; v2(191.93,28.38) 191.93,28.54 192.45,29.05 U37.109
  IN2 w0.089: v2(191.93,28.38) 191.63,28.38 191.53,28.29 189.15,28.29 188.75,28.69 187.72,28.69 187.27,29.14 186.52,29.14 185.99,29.67 185.5,29.67 185.15,30.03 183.32,30.03 183.08,29.79 179.88,29.79 179.55,30.12 175.48,30.12 174.94,30.66 173.53,30.66 173.51,30.68 164.76,30.68 164.17,31.27 161.91,31.27 161.37,31.81 156.79,31.81 156.26,32.34 147.39,32.34 146.57,33.15 145.29,33.15 144.81,33.64 144.81,34.18 144.46,34.53 143.57,34.53 143.4,34.36 142.87,34.36 141.81,35.42 136.71,35.42 136.64,35.5 134.58,35.5 134.4,35.32 133.49,35.32 133.31,35.5 128.44,35.5 126.75,33.8 123.6,33.8 123.46,33.65 119.78,33.65 117.82,31.69 109.69,31.69 109.05,31.05 107.98,31.05 107.54,31.49 98.97,31.49 98.53,31.93 97.88,31.93 97.41,31.46 95.05,31.46 93.84,32.68 89.19,32.68 89.06,32.81 89.06,33.86 88.57,34.35 87.82,34.35 87.47,34.7 86.91,34.7 86.31,35.29 81.31,35.29 79.6,33.58 79.6,33.09 79.01,32.5 78.55,32.5 78.4,32.65 73.23,32.65 72.98,32.9 70.04,32.9 69.86,32.73 68.92,32.73 68.73,32.92 67.43,32.92 66.59,32.08 63.55,32.08 61.83,30.36 61.55,30.36 60.93,29.74 v2(60.8,29.74)
  BOTTOM w0.102: v2(60.8,29.74) 60.97,29.74 61.38,30.15 61.38,46.47 61.89,46.98 v1(62.52,46.98) 62.93,46.98 v1(63.18,46.72)
MEM_VREF_CTL_QA: length 3.4
  TOP w0.381: R25283.1 134.82,102.2 v1(134.76,102.14) 134.31,101.7 R411.1 Q20.3
MIC2-VREFO: length 15.2
  TOP w0.381: v1(212.25,44.03) 212.53,43.75 212.81,43.75
  IN2 w0.381: v1(212.25,44.03) 211.26,43.04 207.71,43.04 203.36,38.7 203.36,36.99 203.74,36.61 v2(203.95,36.61)
  BOTTOM w0.203: U20.29 204.06,36.5 v2(203.95,36.61)
  vias: v1(212.66,43.12)
MINICAR_PME#: length 4.8
  BOTTOM w0.102: R651.1 180.6,15.2 181.14,15.73 v1(181.14,16.12) 181.14,16.72 181.27,16.86 Q33.1 181.76,17.63 CN17.55
MODEM_CLKREQ: length 83.9
  TOP w0.102: R679.2 145.79,18.4 U36.1 145.66,19.72 145.4,19.98 145.4,23.33 145.65,23.58 145.65,24.42 145.21,24.87 144.67,24.87 143.39,26.14 v2(143.39,26.4) ; R679.2 146.44,18.65 U36.2 ; R679.2 v1(145.99,17.31)
  IN1 w0.089: v2(79.36,38.24) 79.89,38.24 80.46,37.67 81.47,37.67 82.48,36.66 82.74,36.66 84.29,35.11 85.5,35.11 87.26,33.35 88.24,33.35 88.83,32.76 94.02,32.76 94.5,32.28 94.5,32.22 95.48,31.24 95.63,31.24 96.54,30.34 98.62,30.34 100.04,28.92 105.41,28.92 106.77,27.55 110.9,27.55 111.09,27.74 125.64,27.74 127.38,26 128.85,26 129.79,26.94 132.66,26.94 133.02,27.3 134.24,27.3 135.09,26.45 137.74,26.45 138.43,25.77 143.17,25.77 143.39,26 v2(143.39,26.4)
  BOTTOM w0.079: v2(79.36,38.24) 79.36,38.44 U1.CH29
MODEM_CLKREQ_L: length 52.9
  TOP w0.102: v2(147.64,26.62) 147.64,26.2 148.25,25.59 148.25,25.03 148.08,24.87 148.08,23.78 R678.1 148.23,23.54 v1(147.48,22.8) 147.09,22.4 U36.4
  IN3 w0.089: v2(189.11,26.05) 188.88,25.81 186.58,25.81 186.18,26.21 183.08,26.21 182.39,26.9 181.16,26.9 180.59,26.33 171.77,26.33 171.06,25.61 168.67,25.61 168,24.95 165,24.95 164.57,25.38 153.96,25.38 153.49,25.85 147.99,25.85 147.64,26.2 v2(147.64,26.62)
  BOTTOM w0.102: v2(189.11,26.05) 189.7,26.05 189.82,26.17 189.82,27.67 190.03,27.88 CN17.14
MX0: length 65.2
  TOP w0.102: U37.58 194.85,14.85 195.13,15.14 195.13,16.65 v2(195.06,16.72) ; C725.1 168.16,21.31 v2(167.89,21.58)
  IN3 w0.089: v2(195.06,16.72) 194.58,17.21 193.94,17.21 193.21,17.94 192.58,17.94 192.26,18.25 192.26,18.64 190.18,20.72 188.08,20.72 187.5,21.3 186.38,21.3 185.84,21.84 183.62,21.84 182.86,21.07 180.9,21.07 180.5,21.47 177.2,21.47 176.99,21.68 176.41,21.68 175.49,20.77 168.7,20.77 v2(167.89,21.58) 167.46,21.14 165.1,21.14 163.87,22.37 158.44,22.37 157.5,23.31 152.74,23.31 152.72,23.29 146.16,23.29 145.71,23.74 145.71,24.42 145.48,24.65 144.69,24.65 144.59,24.75 144.59,26.15 v2(144.54,26.2)
  BOTTOM w0.102: v1(144.21,26.78) 144.54,26.45 v2(144.54,26.2) 144.4,26.06 CN19.10 ; v2(167.89,21.58) 166.71,21.58 166,20.86 CN18.10
MX1: length 62.4
  TOP w0.102: U37.59 195.25,14.85 195.36,14.97 195.36,16.45 195.49,16.57 195.49,16.9 195.26,17.13 194.78,17.13 v2(194.39,16.74) ; C727.1 167.45,20.06 166.94,19.55 v2(166.94,19.42)
  IN3 w0.089: v2(194.39,16.74) 194.13,16.74 193.13,17.75 192.46,17.75 192.07,18.13 192.07,18.56 190.1,20.53 188,20.53 187.42,21.11 186.3,21.11 185.76,21.65 183.7,21.65 182.94,20.88 180.82,20.88 180.42,21.28 177.12,21.28 176.91,21.49 176.48,21.49 175.57,20.58 168.44,20.58 167.28,19.42 v2(166.94,19.42) 166.84,19.42 165.82,20.44 164.29,20.44 162.55,22.18 158.36,22.18 157.42,23.12 152.82,23.12 152.8,23.1 146.08,23.1 145.22,23.95 145.22,24.19 v2(145.25,24.22)
  BOTTOM w0.102: CN19.9 145.4,24.42 145.25,24.27 v2(145.25,24.22) ; CN18.9 167,19.53 166.94,19.47 v2(166.94,19.42)
MX2: length 61
  TOP w0.102: v2(168.49,21.58) 168.87,21.2 C723.1 ; v2(195.9,16.59) 195.59,16.29 195.59,14.98 195.65,14.93 U37.60
  IN3 w0.089: v2(195.9,16.59) 195.72,16.59 194.91,17.4 194.02,17.4 193.62,17.8 193.62,18.36 193.27,18.71 192.49,18.71 190.29,20.91 188.46,20.91 187.89,21.49 186.46,21.49 185.92,22.03 181.65,22.03 181.55,22.13 180.28,22.13 180.01,21.86 177.36,21.86 177.15,22.06 176.1,22.06 175.89,21.86 175.38,21.86 174.49,20.96 169.11,20.96 v2(168.49,21.58) 168.42,21.58 168.05,21.95 164.56,21.95 163.95,22.56 158.52,22.56 157.58,23.5 152.66,23.5 152.64,23.48 147.56,23.48 v2(146.8,24.24)
  BOTTOM w0.102: v2(168.49,21.58) 168,21.09 CN18.8 ; v1(145.93,26.63) 146.4,26.16 CN19.8 146.4,24.64 v2(146.8,24.24)
MX3: length 61.6
  TOP w0.102: U37.61 196.05,14.85 195.82,15.08 195.82,15.81 v2(196.02,16.01) ; C722.1 169.58,21.5 v2(169.66,21.58)
  IN3 w0.089: v2(148.49,24.24) 148.49,24.23 149.05,23.67 152.56,23.67 152.58,23.69 157.66,23.69 158.6,22.75 164.03,22.75 164.62,22.17 169.07,22.17 v2(169.66,21.58) 169.68,21.58 170.06,21.2 174.45,21.2 175.3,22.05 175.81,22.05 176.02,22.26 177.23,22.26 177.44,22.05 179.93,22.05 180.2,22.32 181.63,22.32 181.73,22.22 186,22.22 186.54,21.68 187.96,21.68 188.54,21.1 190.37,21.1 192.57,18.9 193.34,18.9 193.81,18.43 193.81,17.88 194.1,17.59 194.99,17.59 195.61,16.97 196.05,16.97 196.27,16.75 196.27,16.26 v2(196.02,16.01)
  BOTTOM w0.102: v2(169.66,21.58) 169,20.92 CN18.7 ; v1(148.17,27.27) 147.69,27.27 147.19,26.77 147.19,26.14 147.4,25.94 CN19.7 147.4,24.88 147.63,24.65 147.86,24.65 148.27,24.24 v2(148.49,24.24)
MX4: length 60.6
  TOP w0.102: C720.1 170.29,21.53 v2(170.24,21.58) ; v2(196.23,15.45) 196.23,15.12 196.45,14.9 U37.62
  IN3 w0.089: v2(149.3,24.22) 149.3,24.2 149.64,23.86 152.48,23.86 152.5,23.88 157.74,23.88 158.68,22.94 164.11,22.94 164.7,22.36 169.46,22.36 v2(170.24,21.58) 170.43,21.39 172.66,21.39 173.3,22.02 173.68,22.02 174.56,22.9 175.62,22.9 176.07,22.45 177.2,22.45 177.7,22.95 178.2,22.95 178.64,22.51 181.71,22.51 181.81,22.41 186.37,22.41 186.42,22.46 187.45,22.46 188.62,21.29 190.44,21.29 192.65,19.09 193.42,19.09 194,18.51 194,17.96 194.18,17.78 195.07,17.78 195.69,17.16 196.13,17.16 196.46,16.83 196.46,15.69 v2(196.23,15.45)
  BOTTOM w0.102: v1(149.44,27.19) 149.44,26.94 148.4,25.9 CN19.6 148.4,25 149.19,24.22 v2(149.3,24.22) ; v2(170.24,21.58) 170,21.33 CN18.6
MX5: length 63.3
  TOP w0.102: v2(196.99,17.15) 196.84,16.99 196.67,16.99 196.43,16.75 196.43,15.84 196.63,15.64 196.63,15.06 196.85,14.85 U37.63 ; v2(171.46,22.27) 171.45,22.27 171.18,22.01 171.18,21.58 171,21.4 C726.1
  IN3 w0.089: v2(150.52,24.24) 150.52,24.26 151.26,25 153.14,25 153.69,24.45 157.98,24.45 158.92,23.51 164.35,23.51 164.93,22.93 170.18,22.93 170.8,22.31 171.42,22.31 v2(171.46,22.27) 171.46,22.31 172.05,22.9 173.75,22.9 174.47,23.62 178.33,23.62 178.86,23.1 181.93,23.1 182.05,22.98 185.27,22.98 185.85,23.56 186.6,23.56 187.06,23.11 187.61,23.11 188.83,21.89 190.66,21.89 192.4,20.14 193.35,20.14 193.56,19.93 193.84,19.93 194.07,20.15 194.32,20.15 194.68,19.79 194.68,18.91 195.02,18.58 195.02,18.4 195.88,17.54 196.65,17.54 196.99,17.2 v2(196.99,17.15)
  BOTTOM w0.102: CN18.5 171,21.27 171.46,21.73 v2(171.46,22.27) ; v2(150.52,24.24) 149.97,24.24 149.4,24.82 CN19.5 149.4,25.88 150.13,26.61 v1(150.66,26.61)
MX6: length 58.8
  TOP w0.102: C721.1 171.72,21.53 172.07,21.88 172.07,22.25 v2(172.05,22.27) ; U37.64 197.25,14.85 196.86,15.23 196.86,16.56 v2(196.84,16.59)
  IN3 w0.089: v2(196.84,16.59) 196.65,16.77 196.65,16.91 196.21,17.35 195.8,17.35 194.52,18.63 194.2,18.63 192.88,19.95 192.32,19.95 190.6,21.68 188.77,21.68 187.54,22.92 186.98,22.92 186.52,23.37 185.98,23.37 185.4,22.79 181.97,22.79 181.85,22.91 178.78,22.91 178.36,23.33 177.54,23.33 177.04,22.83 176.23,22.83 175.78,23.28 174.4,23.28 173.81,22.69 172.43,22.69 172.05,22.31 v2(172.05,22.27) 172.05,21.96 171.85,21.77 171,21.77 170.03,22.74 164.85,22.74 164.27,23.32 158.84,23.32 157.9,24.26 153.61,24.26 153.06,24.81 151.64,24.81 151.1,24.27 v2(151.1,24.24)
  BOTTOM w0.102: v2(172.05,22.27) 172.05,22.27 172.05,21.45 172,21.4 CN18.4 ; CN19.4 150.4,24.95 v2(151.1,24.24)
MX7: length 58.3
  TOP w0.102: v2(172.63,22.27) 172.59,22.27 172.48,22.16 172.48,21.75 172.43,21.7 C724.1 ; U37.65 198.18,15.78 197.69,16.26 197.69,17.45 197.36,17.78 196.73,17.78 196.51,17.56 195.57,17.56 195.29,17.84 194.2,17.84 192.72,19.32 v2(192.72,19.54)
  IN3 w0.089: v2(192.72,19.54) 192.7,19.52 192.49,19.52 190.52,21.48 188.7,21.48 187.53,22.65 186.35,22.65 186.29,22.6 181.89,22.6 181.77,22.72 178.7,22.72 178.28,23.14 177.62,23.14 177.12,22.64 176.15,22.64 175.7,23.09 174.48,23.09 173.75,22.36 172.72,22.36 v2(172.63,22.27) 172.63,21.88 172.32,21.58 170.86,21.58 169.89,22.55 164.77,22.55 164.19,23.13 158.76,23.13 157.82,24.07 153.53,24.07 152.98,24.62 152.06,24.62 v2(151.69,24.24)
  BOTTOM w0.102: CN19.3 151.4,24.8 151.69,24.51 v2(151.69,24.24) ; v2(172.63,22.27) 172.63,21.58 173,21.21 CN18.3
MY0: length 69.5
  TOP w0.102: U37.36 186.05,15.23 186.04,15.24 186.04,16.06 v2(185.99,16.12) ; C719.1 v1(150.81,19.57) v2(151.57,18.81)
  IN3 w0.089: v2(129.22,23.99) 129.33,23.99 130.26,23.06 130.26,22.69 131.51,21.43 142.89,21.43 146.18,18.15 148.88,18.15 149.54,18.81 v2(151.57,18.81) 152.14,18.24 152.77,18.24 153.5,17.51 158.24,17.51 159.98,15.77 181.89,15.77 182.49,16.36 185.16,16.36 185.41,16.12 v2(185.99,16.12)
  BOTTOM w0.102: v2(129.22,23.99) 129.02,23.99 128.4,24.61 CN19.26 ; CN18.26 150,19.85 151.04,18.81 v2(151.57,18.81)
