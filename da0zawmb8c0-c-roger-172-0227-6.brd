# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N24507691: length 8.7
  TOP w0.102: PR284.2 167.5,25.48 v2(167.42,25.56)
  BOTTOM w0.102: PU3003.5 161.14,23.25 161.86,23.98 162.08,23.98 162.96,24.85 163.67,24.85 163.93,25.11 163.93,25.46 164.39,25.92 167.17,25.92 167.42,25.67 v2(167.42,25.56)
N24515156: length 1
  BOTTOM w0.203: PC7018.1 PR7056.1
N24602110: length 23.1
  IN3 w0.203: v2(143.95,50.68) 143.39,50.13 141.54,50.13 140.93,50.74 139.79,50.74 138.03,52.49 138.03,52.87 137.37,53.53 136.31,53.53 135.62,54.21 135.62,56.09 134.94,56.78 134.44,56.78 132.45,58.78 132.45,60.08 131.79,60.74 131.48,60.74 131.03,60.29 v2(131.01,60.29)
  BOTTOM w0.203: v2(143.95,50.68) 144.03,50.61 144.36,50.61 144.5,50.46 PR7013.2 144.45,50.23 143.45,50.23 PR7014.1 ; PR7007.2 131.17,60.45 v2(131.01,60.29)
N24622727: length 45
  TOP w0.203: PR7099.2 133.11,56.19 133.11,56.18 PR7100.1 132.59,56.18 131.94,56.83 131.94,59.14 v1(132.14,59.35) 133.64,60.84 133.84,60.84 134.12,61.12 134.26,61.12 136.92,63.78 v2(136.92,63.89)
  IN1 w0.203: v2(136.92,63.89) 136.92,63.92 136.21,64.63 136.21,66.35 131.96,70.59 131.96,72.33 130.03,74.26 128.92,74.26 127.5,75.68 124.78,75.68 120.25,80.21 117.43,80.21 114.3,83.33 v1(114.3,83.61)
  BOTTOM w0.203: v1(114.3,83.61) 114.3,83.48 PR7101.1
N24679794: length 4.4
  TOP w0.508: L3.1 90.36,31.35 90.36,30.57 90.19,30.4 R213.1 90.19,29.92 90.38,29.73 v1(90.38,29.32) 90.38,29.02 89.91,28.55 C243.2 R212.1
N24742093: length 3.9
  BOTTOM w0.508: 69.15,106.03 69.15,107.25 69.91,108.01 69.91,109.47 PR9073.1
  vias: v1(71.23,100.27)
N24742096: length 16.6
  IN1 w0.089: v2(74.97,98.79) v2(75.93,98.79)
  BOTTOM w0.102: v2(74.97,98.79) 74.97,98.77 74.76,98.56 74.59,98.56 74.21,98.18 73.83,98.18 PR9075.2 73.6,98.04 73.09,97.52 PD9001.2 ; PQ9011.3 70.39,107.3 71.18,107.3 71.51,106.97 72.15,106.97 72.93,106.18 v1(73.01,106.18) 73.06,106.13 73.06,103.06 73.19,102.93 73.19,101.15 74.53,99.81 75.17,99.81 75.93,99.05 v2(75.93,98.79)
N24742104: length 11.1
  BOTTOM w0.102: PQ9011.2 72.05,107.83 72.91,106.97 74.23,106.97 v1(74.33,106.87) 74.43,106.97 75.31,106.97 PR9074.2 PR9077.1 ; PR9077.1 76.41,105.78 76.62,105.78 77.38,105.02 PQ9010.3 ; PR9077.1 75.77,105.97 75.27,105.47 75.27,104.48 75.46,104.29 PQ9009.2
N24742107:
  vias: v1(21.27,95.77)
N24742118: length 1.4
  BOTTOM w0.102: PR9078.1 76.39,101.71 76.83,101.27 PU9003.3
N24742123: length 10.6
  BOTTOM w0.102: v1(68.46,110.7) 69.12,111.36 PR9073.2 70.51,111.36 70.65,111.21 70.65,109.08 70.52,108.95 70.52,108.47 71.56,107.43 72.07,107.43 72.76,106.74 73.72,106.74 74.51,105.95 PQ9009.3
N24742126: length 9.4
  BOTTOM w0.102: PU9003.4 76.83,98.4 77.93,99.5 v1(77.93,100.44) 77.93,103.13 PQ9010.2
  BOTTOM w0.254: PU9003.4 76.83,97.07 76.55,96.8 75.91,96.8 PC9073.1 PR9079.1
N24742146: length 2.2
  BOTTOM w0.102: v1(74.56,93.41) 74.48,93.49 PC9071.1
  BOTTOM w0.254: PC9071.1 74.36,94.34 PR9080.2
N24742173: length 5
  TOP w0.102: PR9069.2 23.68,88.77 23.68,90.03 23.18,90.54 PC9059.1 22.67,91.05 22.67,91.81 22.54,91.93 PU9002.4
N24742207: length 1.9
  TOP w0.102: PU9002.10 22.94,95.26 23.56,95.87 PC9063.1
N24742208: length 1.8
  TOP w0.102: PU9002.12 22.14,95.84 PC9062.1
N24742222: length 5.6
  TOP w0.102: PU9002.5 22.94,91.8 PC9060.1 25.08,89.66 v1(25.08,89.24) 25.08,89.15 PR9070.1
N24742230: length 4.8
  TOP w0.102: PR9072.2 22.67,88.77 22.67,90.04 PC9064.1 22.14,90.56 v1(22.14,91.53) PU9002.3
N24995566: length 3.3
  BOTTOM w0.102: PR3020.2 102.92,27.17 103.08,27.02 PC6228.1 103.31,27.8 v1(103.34,27.82) 103.36,27.85 103.87,27.85 104.01,27.71 PU3002.5
N24995570: length 2.3
  BOTTOM w0.102: v1(108.47,29.12) PR3021.1 107.94,27.71 PU3002.1
N24995581: length 1.2
  BOTTOM w0.102: PU3002.3 107.85,25.81 108.03,25.99 PR3022.1
N25365001: length 5
  TOP w0.102: PQ9084.3 v1(125.37,119.02)
  TOP w0.508: PQ9084.3 123.76,119.47 123.25,119.98 121.62,119.98 PR9103.2
N25369936: length 3
  TOP w0.102: Q27.1 71.63,17.41 71.87,17.65 71.87,18.1 71.49,18.48 R561.1 R560.2
N25369945: length 3.6
  TOP w0.102: Q27.4 74.14,15.9 74.97,16.72 R558.2 R557.1
N25430953: length 6.4
  BOTTOM w0.102: PQ14.3 19.11,30.36 18.86,30.11 v1(17.23,30.11)
  BOTTOM w0.254: PR111.2 21.91,31.76 21.5,32.17 20.48,32.17 19.2,30.89 PQ14.3
N25430988: length 3.3
  BOTTOM w0.254: PR106.2 21.46,37.97 20.63,37.14 v1(20.46,37.14) 20,37.59 PQ12.3
N25430994: length 3.4
  BOTTOM w0.254: PQ19.3 19.53,27.56 v1(20,27.09) 20.47,27.56 20.65,27.56 21.23,28.14 PR126.2
N25431520: length 5.8
  BOTTOM w0.102: PQ9050.3 19.49,34.68 18.83,35.34 v1(17.44,35.34)
  BOTTOM w0.254: PR9227.2 20.52,34.67 20.07,34.22 PQ9050.3
N25804343: length 2.3
  BOTTOM w0.102: PR9027.2 69.67,114.12 69.23,114.57 v1(69.12,114.57)
  BOTTOM w0.254: PR9030.2 70.24,114.91 PR9027.2
N25817818: length 2.7
  TOP w0.381: PR9099.2 v1(137.27,79.31) 136.8,78.84 PQ9085.3
N25817820: length 5.1
  TOP w0.102: v1(133.62,80) PR9100.2
  TOP w0.381: PQ9086.3 133.51,77.82 PR9101.1 133.54,78.97 PR9100.2 133.89,79.06 134.09,78.86 PQ9085.2
N25821251: length 1.5
  BOTTOM w0.508: PR9092.2 PC9088.1
N27752748: length 2.6
  BOTTOM w0.203: R450.2 197.37,34.73 197.09,35.01 R736.1 196.69,35.24 R737.1
N28053888: length 20.8
  IN3 w0.203: v2(131.61,60.26) 131.71,60.26 132.14,59.83 132.14,58.61 134.28,56.48 134.81,56.48 135.32,55.97 135.32,54.09 136.18,53.22 137.25,53.22 137.73,52.74 137.73,52.36 139.66,50.43 140.8,50.43 141.52,49.71 v2(143.96,49.71)
  BOTTOM w0.203: v2(143.96,49.71) 143.97,49.71 143.98,49.73 143.99,49.73 PR7006.1 ; PR7007.1 131.95,60.6 v2(131.61,60.26)
N28054550: length 2.3
  BOTTOM w0.203: PR7077.2 132.72,50.85 132.36,50.49 v1(132.36,50.28) PU7001.5
N28087213:
  vias: v1(22.82,110.55) v1(25.59,112.38) v1(25.59,111.75) v1(26.63,112.13)
N28088374: length 2.5
  TOP w0.102: PC7004.1 143.96,58 v1(144.64,58.69)
  TOP w0.203: 143.96,57.33 PC7004.1
  TOP w0.254: 143.96,57.33 143.62,56.99 PR7008.2
N28089786: length 2
  TOP w0.203: PR7035.1 139.69,51.68 139.38,51.98 v1(139.22,51.98) 139,51.98 138.7,51.68 PR7040.1
N28089833: length 1.7
  TOP w0.203: PR7036.2 v1(139.22,50.71) PR7041.2
N28092561: length 14.5
  BOTTOM w0.079: U1.W4 95.61,68.55 95.92,68.24 96.26,68.24 96.28,68.26 96.52,68.26 96.54,68.24 96.73,68.24 96.94,68.03 99.36,68.03 100.67,69.34 100.67,69.68 100.86,69.86 100.86,70.63 101.1,70.88 101.38,70.88 101.61,71.11 101.61,71.41 102.04,71.84
  BOTTOM w0.102: v1(105.57,72.53) 105.25,72.86 R83.2 103.41,73.37 103.34,73.29 102.7,73.29 102.42,73.01 102.42,72.22 102.04,71.84
N28100067: length 8.7
  BOTTOM w0.102: R572.1 75.75,23.51 75.12,23.51 74.92,23.71 73.9,23.71 73.7,23.51 70.6,23.51 v1(70.04,22.95) 70.04,22.34 69.32,21.62 CN33.8
N28107941: length 1.9
  BOTTOM w0.508: PR7095.1 114.85,73.71 v1(114.92,73.77) 115.33,74.19 PC7096.2
N28108994: length 47.5
  TOP w0.254: v1(134.25,60.57) 134.33,60.49 v1(135.06,60.49) 135.43,60.85 PR7098.1
  IN3 w0.203: v1(134.25,60.57) 134.22,60.54 133.74,60.54 133.13,61.15 133.13,67.37 132.14,68.36 129.06,68.36 128.55,68.87 124.2,68.87 123.06,70.01 119.9,70.01 117.71,67.83 117.71,66.58 117.26,66.13 116.65,66.13 115.7,67.08 115.7,73.01 114.63,74.08 114.63,75.64 113.37,76.9 111.77,76.9 111.69,76.97 v1(111.69,77.38)
  BOTTOM w0.203: v1(111.69,77.38) 111.69,78.7 112.03,79.03 PR7096.2
N28123718: length 1
  BOTTOM w0.203: PR7033.1 137.22,46.98 137.2,47 PR7030.2
N28123995: length 2.5
  TOP w0.102: v1(132.9,52.44) 133.54,53.07 PR7031.2
  TOP w0.203: PR7034.1 132.58,54.2 132.99,53.8 132.99,53.79 133.35,53.42 PR7031.2
N28124269: length 2.6
  TOP w0.203: PR7010.2 131.18,54.67 v1(131.33,54.52) 131.86,54.52 132.5,55.15 PR7017.1
N28124298: length 1
  BOTTOM w0.203: PR7009.2 136.26,46.98 136.23,47 PR7016.1
N28127437: length 6
  TOP w0.203: PR7003.1 139.99,59.69 PR7002.1 PR7001.1 138.52,59.69 138.21,59.69 138.18,59.66 138.17,59.66 137.76,59.25 PR7102.1 138.27,58.74 138.8,58.74 v1(138.95,58.58) 139.28,58.25 139.28,58.11 139.36,58.02 PC7001.1
N28129355: length 1.3
  TOP w0.254: PR7027.1 143.5,50.2 144.63,50.2 PR7022.1
N28129385: length 1.4
  TOP w0.254: PR7028.1 143.61,49.11 144.48,49.11 PR7023.1
N28129414: length 1
  TOP w0.203: PR7024.1 140.08,49.39 PR7029.1
N28159674: length 26.2
  TOP w0.203: PR7092.1 141.81,60.71 v1(142.05,60.95) 142.4,60.95 v2(142.68,60.67)
  TOP w0.254: PR7091.1 141.81,59.12 PR7092.1
  IN2 w0.203: v2(133.16,44.11) 133.16,44.73 133.84,45.42 133.84,45.76 137.4,49.31 137.4,59.01 138.78,60.39 142.4,60.39 v2(142.68,60.67)
  BOTTOM w0.203: v2(133.16,44.11) 133.36,44.11 133.55,43.92 PR7093.1
N28160119: length 2.4
  BOTTOM w0.102: v1(137.26,44.65) 136.93,44.32 PR7087.1
  BOTTOM w0.508: PC7078.2 PR7087.1
N28160139: length 32
  IN2 w0.203: v2(132.78,42.84) 133.23,43.29 133.54,43.29 134.17,43.93 134.17,44.56 134.68,45.07 134.68,45.41 138.24,48.97 138.24,58.66 139.13,59.55 141.77,59.55 142.15,59.17 v1(143.78,59.17)
  BOTTOM w0.203: v2(132.78,42.84) 130.08,40.14 130.08,39.18 130.39,38.87 PR7088.2
  BOTTOM w0.254: v1(143.78,59.17) 143.1,59.17 PR7090.2
N28379472: length 5.2
  BOTTOM w0.102: PC9025.1 v1(75.35,113.05)
  BOTTOM w0.254: PR9021.2 72.18,112.27 73.13,112.27 73.14,112.27 PR9023.1 73.63,112.27 74.41,113.05 PC9025.1 74.48,113.32 74.16,113.65 73.8,113.65 73.45,114 PR9024.1
N28379477: length 2.3
  TOP w0.102: v1(84.31,107.84) PR9019.1
  TOP w0.508: PR9019.1 83.25,106.6 PC9024.1
N28380796: length 1
  TOP w0.254: PR9017.1 71.18,114.16 70.93,113.91 TP9000.1
N28380828: length 3.6
  TOP w0.254: PC9004.1 68.41,114.59 v1(67.91,114.08) 68.18,113.8 PR9002.2
  BOTTOM w0.254: PR9000.2 68.41,115.07 67.91,114.57 v1(67.91,114.08)
N28414264: length 3
  TOP w0.254: v2(72.1,108.95) 72.1,108.93 72.22,108.81 PU9000.13
  BOTTOM w0.102: PR9033.1 v1(72.35,110.37)
  BOTTOM w0.254: v2(72.1,108.95) 71.63,109.42 PR9274.1 71.66,109.57 PR9033.1
N28607521: length 1.4
  TOP w0.254: PU9000.22 76.97,111.03 77.01,111.07 PR9034.1
N29093947: length 5.2
  TOP w0.102: Q16.3 86.55,92.95 86.12,93.38 v1(86.12,93.51) 85.79,93.84 R386.1 86.21,94.34 86.6,93.96 87.6,93.96 Q14.2
N30319022:
  vias: v1(137.43,76.34) v1(137.4,75.65) v1(137.37,74.84) v1(137.98,76.67) v1(137.98,76.03) v1(137.98,75.4) v1(138.62,76.47) v1(138.62,75.83) v1(139.28,76.47) v1(139.28,75.83) v1(139.91,76.47) v1(139.91,75.83) v1(140.63,76.47) v1(140.63,75.83) v1(141.57,76.62)
N30319317: length 19.7
  TOP w0.203: PR9263.2 140.93,78.14 141.34,78.55 v1(143.17,78.55)
  IN2 w0.203: v1(143.17,78.55) 143.29,78.42 143.29,64.38 v1(142.86,63.94)
  BOTTOM w0.254: PC9089.2 PR9094.1 142.15,63.89 142.2,63.94 v1(142.86,63.94)
N30319351: length 2.2
  BOTTOM w0.508: PR9089.1 139.43,71.96 138.35,70.88 PC9079.2
N30442035:
  vias: v1(20.25,24.55)
N30442060: length 4.2
  TOP w0.102: PU6002.4 24.67,27.42 PC6051.1 25.3,28.05 26.48,28.05 26.94,27.6 PR6023.1
N30442062: length 1.6
  TOP w0.203: PU6002.12 20.39,27.02 20.13,26.76 PC6056.1
N30442063: length 1.5
  TOP w0.102: PU6002.10 19.83,27.82 PC6057.1
N30442080: length 4.6
  TOP w0.102: PU6002.5 23.64,27.82 23.71,27.75 24.29,27.75 24.84,28.3 PC6053.1 25.28,28.99 26.55,28.99 26.99,28.56 PR6028.2
N30442084: length 4.4
  TOP w0.102: PR6027.2 26.55,27.16 25.38,27.16 PC6052.1 24.46,27.02 PU6002.3
N30568314: length 5.5
  TOP w0.203: PC6024.2 147.42,34.95 146.32,33.84 v2(146.32,33.72) 146.22,33.62 PR6010.1 146.82,32.88 v1(147.08,32.63) 147.08,32.18 PR6014.2
  BOTTOM w0.203: PU6000.12 146.4,33.68 146.34,33.74 146.34,33.74 v2(146.32,33.72)
N30568326: length 2
  TOP w0.102: PC6024.1 148.06,35.73 v1(148.4,35.39)
  TOP w0.508: PR6011.1 PC6024.1
N30568424: length 5.5
  BOTTOM w0.102: PC6059.2 v1(44.77,13.52)
  BOTTOM w0.229: PU6003.9 44.23,17.8 44.77,17.25 PR6030.1 PR6031.2 44.77,15.86 45.02,15.62 45.02,14.71 44.77,14.46 PC6059.2
N30568429: length 2
  BOTTOM w0.102: v1(43,13.52) PR6029.1
  BOTTOM w0.229: PR6029.1 43.48,14.44 43.5,14.46 43.92,14.46 PC6059.1
N30568472: length 6.2
  TOP w0.102: v1(45.12,17.87) 44.67,17.42 PC6054.1
  TOP w0.508: v1(41.7,17.37) PR6025.1 43.31,17.42 PC6054.1
  BOTTOM w0.203: PU6003.12 42.88,18.17 42.08,17.37 v1(41.7,17.37)
N30568498: length 3.3
  TOP w0.254: v1(46.72,13.75) 47.13,13.75 47.67,14.3 PQ6001.3
  BOTTOM w0.102: v1(46.72,13.75) 46.57,13.6 v1(46.09,13.6)
  BOTTOM w0.254: v1(46.72,13.75) 47.14,14.18 PR6021.1
N30568535: length 7.9
  BOTTOM w0.102: PR6003.2 145.32,38.21 v1(145.6,38.49)
  BOTTOM w0.203: PR6005.2 PR6004.1 143.35,33.82 143.65,34.12 143.65,35.75 144.33,36.44 144.33,37.45 144.72,37.84 PR6003.2 144.72,38.98 PR6007.1
N31069510:
  vias: v1(157.11,24.95)
N31161958: length 2.8
  TOP w0.203: v2(154.82,28.61) 154.85,28.59 PU6001.4
  BOTTOM w0.203: v2(154.82,28.61) 154.82,28.51 155.31,28.03 PC6025.1 PR6013.2
N31161974: length 3
  TOP w0.203: PC6028.1 155.46,23.94 v1(155.75,24.23) 155.25,24.73 PU6001.12
N31161976: length 3
  TOP w0.203: PC6029.1 154.62,23.24 154.62,24.07 v1(154.47,24.22) 154.62,24.37 154.62,25.01 154.45,25.18 PU6001.10
N31162017: length 3
  TOP w0.203: PU6001.5 154.45,28.2 154.24,28.41 v2(154.24,28.61)
  BOTTOM w0.203: v2(154.24,28.61) 154.1,28.61 PC6027.1 152.94,27.88 152.87,27.95 PR6016.2
N31162025: length 2.9
  TOP w0.203: v2(155.41,28.61) 155.41,28.51 155.25,28.35 PU6001.3
  BOTTOM w0.203: v2(155.41,28.61) 155.54,28.61 PC6026.1 156.4,28.01 PR6015.1
N31297467: length 10.1
  TOP w0.203: PR9252.2 PR9251.2 30.67,25.24 PR184.1 31.14,24.77 PC9093.1
  TOP w0.254: PR9252.2 31.43,25.94 31.84,25.54 32.55,25.54 33.65,26.64 v2(33.65,27)
  BOTTOM w0.254: v2(33.65,27) 33.65,26.51 32.68,25.54 32.68,25.13 32.42,24.88 PU14.2
N31297491:
  vias: v1(23.58,23.3) v1(23.56,22.67) v1(26.86,22.69)
N31297495: length 4.6
  TOP w0.254: v2(23.63,24.24) v1(24.37,24.24) 24.83,24.7 PR224.1 25.22,24.67 PR222.1
  BOTTOM w0.254: PU14.7 23.86,24.88 23.63,24.65 v2(23.63,24.24)
N31297650: length 5.3
  TOP w0.102: PR9253.2 v1(36.41,22.46)
  TOP w0.254: PR9253.2 PC185.1 33.84,22.46 v1(33.59,22.21)
  BOTTOM w0.254: PU14.4 33.46,22.34 v1(33.59,22.21)
N31353058:
  vias: v1(34.43,28.61)
N31353100: length 2.7
  TOP w0.102: v1(39.79,33.01) 39.63,32.84 PR551.2
  TOP w0.508: PC551.2 PR551.2
N31375926:
  vias: v1(110.2,45.4)
N33618596: length 1.9
  TOP w0.203: R653.2 v1(26.51,7.35) 26.51,7.69 Q34.3
N33652665: length 3.6
  BOTTOM w0.102: R655.2 EC12.1 194.46,20.13 194.04,20.13 193.61,19.7 v1(193.61,19.24)
N33712295: length 3.3
  BOTTOM w0.079: 100.39,77.2 98.46,77.2
  BOTTOM w0.089: 98.46,77.2 98.35,77.09 97.38,77.09 U1.E1
  BOTTOM w0.102: R85.2 100.39,77.2
N33761123: length 4.1
  TOP w0.102: R645.1 31.21,3.06 31.04,2.9 R2660.1 30.26,2.65 v1(30.19,2.73) 30.16,2.75 30.16,2.98 v1(30.6,3.42)
  BOTTOM w0.102: v1(30.6,3.42) CN16.38
N33761125: length 2.1
  TOP w0.102: R648.1 28.23,3.54 28.08,3.39 v1(28.05,3.39)
  BOTTOM w0.102: CN16.50 27.6,2.94 v1(28.05,3.39)
N33761127: length 8.8
  TOP w0.102: TP81.1 19.4,5.56 20.16,5.56 20.62,6.02 v1(20.62,6.13)
  BOTTOM w0.102: CN16.68 23.1,2.58 23.25,2.73 23.84,2.73 23.99,2.88 23.99,4.05 22.32,5.71 20.93,5.71 20.62,6.02 v1(20.62,6.13)
N33764822: length 2.3
  TOP w0.102: TP26.1 104.79,67.68 104.79,68.59 105.17,68.97 R216.2
N33764826: length 1.9
  TOP w0.102: R217.2 101.51,75.29 101.92,74.89 102.68,74.89 TP32.1
N34044006: length 1.8
  BOTTOM w0.254: PR7109.2 126.53,78.46 v1(126.53,78.32) 127,78.32 127.25,78.57 PU7003.5
N34044116: length 1.9
  TOP w0.508: v1(126.27,76.21) 126.35,76.29 PC7101.2
  BOTTOM w0.254: v1(126.27,76.21) 126.47,76.41 PU7003.4
N34044137: length 2.4
  BOTTOM w0.254: PU7003.3 127.75,75.72 127.41,75.37
  BOTTOM w0.508: 127.41,75.37 126.78,75.37 PR7110.1
N34045443: length 1.3
  BOTTOM w0.254: PR7113.2 140.61,42.9 140.87,43.16 PU7004.5
N34045547: length 2.6
  TOP w0.508: PC7103.2 140.18,40.9 v1(140.78,40.3)
  BOTTOM w0.102: PU7004.4 v1(140.12,41.18)
  BOTTOM w0.254: v1(140.78,40.3) 140.78,40.54 140.87,40.63 PU7004.4
N34045574: length 2.6
  BOTTOM w0.178: PR7114.1 141.48,39.58 v1(142.45,39.58)
  BOTTOM w0.254: PU7004.3 141.37,40.35 141.38,40.34 PR7114.1
N34047546: length 1.5
  TOP w0.254: v1(120.1,68.24) 120.05,68.19 PR7105.2
  BOTTOM w0.254: v1(120.1,68.24) 119.87,68 PU7002.5
N34047656: length 3
  TOP w0.508: v1(119.98,71.08) 120.43,70.62 v1(120.43,70.34) 120.38,70.29 PC7105.2
  BOTTOM w0.254: v1(119.98,71.08) 119.98,70.77 PU7002.4
N34047677: length 6.4
  IN3 w0.508: v1(119.14,71.12) 119.14,71.61 119.52,72 120.28,72 120.61,71.66 122.26,71.66 v1(122.59,72)
  BOTTOM w0.254: PU7002.3 118.96,70.92 119.14,71.11 v1(119.14,71.12)
  BOTTOM w0.508: v1(122.59,72) 123.35,72 PR7106.1
N36446693: length 2.2
  TOP w0.102: R512.2 44.77,111.23 C639.1 44.77,112.14 Y4.3
N36953746:
  vias: v1(51.73,21.6)
N36954805: length 3.2
  TOP w0.102: R589.2 63.02,21.96 U32.7
N36977514: length 7.5
  BOTTOM w0.102: Q30.2 195.23,16.23 195.49,16.5 195.49,16.85 195.69,17.05 195.69,17.69 195.49,17.89 195.49,18.66 196.12,19.29 R579.2 196.12,19.38 196.4,19.65 197.05,19.65 197.58,20.17 198.05,20.17 198.13,20.26 198.13,20.94 Q31.3
N37139396: length 1.1
  TOP w0.102: D22.2 130.47,20 130.56,20.09 R600.1
N37139525: length 2.8
  TOP w0.102: U33.24 122.85,18.46 122.85,17.31 122.49,16.95 R598.2
N37139527: length 1.3
  TOP w0.102: U33.21 122.51,20.21 122.07,20.65 R597.2
N37139529: length 4.1
  TOP w0.102: U33.19 122.58,21.21 122.41,21.37 122.41,21.63 122.19,21.86 122.19,22.7 121.66,23.23 121.01,23.23 R596.2
N37139539: length 2.7
  TOP w0.102: R593.2 121.8,23.51 121.8,23.41 122.42,22.79 122.42,21.95 122.66,21.71 U33.18
N37139543: length 3.1
  TOP w0.102: R599.2 121.55,22.85 121.96,22.43 121.96,21.76 122.19,21.54 122.19,21.2 122.67,20.71 U33.20
N37139545: length 1.7
  TOP w0.102: R592.2 125.92,16.44 126.1,16.62 126.1,17.21 125.94,17.36 U33.29
N37162665: length 5.5
  TOP w0.381: v1(212.28,34.38) 212.73,33.93 R448.2
  BOTTOM w0.381: v1(212.28,34.38) 212.15,34.25 L28.1 211.35,34.41 210.91,34.86 v1(210.91,35.27) 211.43,35.79 R449.2
N37162929: length 1
  TOP w0.102: TP9023.1 209.31,27.37 R454.1
N37164012: length 3.9
  BOTTOM w0.203: C843.1 198.72,32.32 v1(199.41,31.63) U20.16
N37164724: length 2.2
  BOTTOM w0.102: R735.2 196.78,33.49 196.78,33.01 196.41,32.63 R25371.2
N37190310: length 10.3
  TOP w0.508: HE1.2 35.85,123.2 36.08,122.97 36.08,122.16 35.88,121.96 35.88,121.3 v1(35.9,121.27)
  BOTTOM w0.508: R25519.2 42.26,121.02 41.25,120.01 D13092.2 39.22,120.01 C842.1 39.19,120.23 38.81,120.61 38.68,120.61 38.68,120.61 36.76,120.61 36.1,121.27 v1(35.9,121.27)
N37349239: length 2.3
  BOTTOM w0.102: v1(132.41,64.14) PR7072.1
  BOTTOM w0.508: PR7072.1 131.24,64.25 PC7046.2
N37349425: length 1.9
  BOTTOM w0.508: PC7064.2 v1(131.38,52.28) PR7081.1
N37352433: length 2.6
  TOP w0.102: PR9004.1 76.93,117.39 v1(76.44,116.9)
  TOP w0.508: PC9012.1 75.76,117.97 PR9004.1
N37598035: length 2.7
  TOP w0.102: R507.1 20.98,83.42 21.52,82.87 v1(21.52,82.49) U23.4
N37994586: length 1.9
  TOP w0.102: R266.2 R265.2 28.88,89.38 C6559.2
N38517581: length 5.3
  TOP w0.381: R25338.2 19.37,8.87 18.52,9.72 D6542.1 v1(16.19,10.02) 15.78,10.43 R25339.1
N38517589: length 2.5
  TOP w0.102: v1(18.35,7.78) 18.35,7.86 18.6,8.1 R25338.1
  TOP w0.381: Q6518.2 17.79,8.62 R25338.1
N38517597: length 5.8
  TOP w0.508: v1(16.06,8.14) 16.06,7.39 Q6518.3
  IN2 w0.508: v1(16.44,12.69) 16.44,8.52 v1(16.06,8.14)
  vias: v1(15.68,12.61)
N38517605: length 6.4
  TOP w0.356: R25341.1 17.8,12.18 19.62,12.18 19.87,12.43 20.89,12.43 21.02,12.31 21.52,12.31 21.87,12.65 v1(21.87,13.37) Q6519.3
N38517627: length 2.7
  TOP w0.102: v1(12,9.04) R25342.2
  TOP w0.381: R25342.2 13.14,8.44 12.79,8.09 Q6515.3
N38517632: length 1.2
  TOP w0.102: 21.47,17.3 21.75,17.59 22.36,17.59 v1(22.49,17.46)
N38517638: length 2.4
  TOP w0.381: Q6515.2 11.84,5.03 11.62,4.81 C6583.2 12.12,4.31 12.13,4.3 R25337.2
N38521997: length 35.8
  TOP w0.102: R720.1 148.88,18.93 148.98,18.83 v2(148.98,18.78) 148.98,18.73 148.91,18.66 D33.1 147.95,17.86 v1(147.89,17.92)
  BOTTOM w0.102: v2(148.98,18.78) 149.08,18.78 149.57,18.3 149.57,16.65 150.56,15.66 162.39,15.66 165.26,18.53 167.17,18.53 167.4,18.76 167.4,19.7 167.53,19.83 169.07,19.83 169.3,19.59 169.3,18.6 169.38,18.53 173.57,18.53 175,19.96 CN18.1
N38673982: length 3.7
  TOP w0.102: R821.2 140.22,35.67 v1(139.69,35.14) 139.69,34.73 139.96,34.46 Q85.1 139.36,33.59 R825.2
N38674074: length 4.4
  TOP w0.102: R821.1 141.69,35.67 142.23,36.21 v1(142.23,36.51) 142.23,37.98 142.78,38.53 Q86.2
N38674948: length 28.4
  IN3 w0.203: v2(129.62,57.14) 129.91,57.14 131.02,56.02 131.02,54.47 132.66,52.83 132.66,51.29 134.89,49.07 134.89,44.94 135.6,44.23 138.82,44.23 v1(139.33,44.74)
  BOTTOM w0.203: v2(129.62,57.14) 129.31,57.44 126.48,57.44 125.92,56.88 125.92,55.36 126.3,54.98 PR7082.2 ; v1(139.33,44.74) 139.33,45.05 139.15,45.22 PR7084.1
N38680042: length 4.4
  BOTTOM w0.102: D6543.1 194.7,35.29 v1(195.29,35.88) ; D6543.1 195.1,34.56 195.64,34.02 R735.1 ; D6543.1 D11.1
N38680880: length 5.2
  TOP w0.102: Q6523.2 175.92,30.96 175.37,30.41 175.37,29.75 175.11,29.5 174.97,29.5 v1(174.97,29.5) 174.85,29.5 173.86,28.51 R576.1
N38756671: length 1.7
  TOP w0.203: 200.09,15.48 200.09,15.89 199.79,16.18 U37.66
  vias: v1(198.59,12.48)
N38756738: length 6.8
  TOP w0.102: U37.82 199.64,22.58 199.84,22.78 200.86,22.78 201.01,22.93 201.01,23.47 C1208.2 201.57,23.94 202,24.37 203.11,24.37 203.41,24.67 v1(203.69,24.67) 203.77,24.6 203.77,24.29 203.6,24.12 R960.1
N38756749: length 2.1
  TOP w0.102: U37.87 199.62,24.58 199.91,24.88 200.7,24.88 TP9037.1
N38756787: length 4
  TOP w0.102: U37.98 196.85,30.78 197.12,31.05 C6580.2 ; R895.1 196.57,32.02 C6580.2 ; C6580.2 197.46,31.47 v1(198,32.02)
N38756834: length 28.7
  TOP w0.102: v1(24.95,45.2) 25.26,44.89 25.26,43.62 25.01,43.38 Q81.3
  IN2 w0.089: v1(24.8,50.58) 24.59,50.58 23.8,49.79 23.8,48.03 24.29,47.53 24.29,46.33 24.95,45.67 v1(24.95,45.2)
  BOTTOM w0.102: v1(24.8,50.58) 24.19,51.19 24.19,56.25 23.6,56.84 21.43,56.84 v1(21.22,56.63) 21.01,56.84 19.41,56.84 19.23,57.02 R25321.1 18.98,57.52 18.73,57.52 16.95,59.3 SW2.3 SW2.4
N38756945: length 1.6
  TOP w0.102: U37.83 199.71,22.98 199.74,23.01 200.15,23.01 TP9035.1
N38757016: length 1.4
  TOP w0.102: U37.20 181.83,20.58 TP9038.1
N38757336: length 4.9
  TOP w0.102: U37.128 184.85,30.67 184.75,30.77 184.29,30.77 184.06,31 183.34,31 C6563.1 182.99,31.43 183.48,31.91 184.08,31.91 184.13,31.96 R25308.1
N38757406: length 106.8
  TOP w0.102: v1(29.02,65.39) 28.81,65.39 27.01,63.59 27.01,62.07 27.47,61.61 v1(27.47,60.16) 27.47,55.41 27.37,55.31 27.37,47.46 25.54,45.63 24.72,45.63 24.52,45.43 24.52,44.54 24.34,44.36 24.34,42.48 23.56,41.69 23.56,41.52 23.36,41.32 Q81.2 22.32,41.32 22.23,41.23 C1044.1 ; R25310.2 65.86,102.59 v1(66.1,102.35)
  IN2 w0.089: v1(29.02,65.39) 29.65,66.03 29.65,68.31 29.27,68.7 29.27,74.16 29,74.43 29,79.99 30.29,81.28 30.29,90.79 32.83,93.33 32.83,94.35 33.38,94.9 48.21,94.9 48.75,95.43 49.89,95.43 51.52,97.06 52.64,97.06 52.77,97.19 52.77,97.78 53.97,98.98 56.51,98.98 57.08,99.55 57.08,101.71 58.02,102.65 60.43,102.65 61,103.21 65.24,103.21 v1(66.1,102.35)
  BOTTOM w0.102: SW3.4 66.7,99.08 66.23,99.55 66.23,102.22 v1(66.1,102.35) 66.1,102.5 66.7,103.1 SW3.3
N38758998: length 2
  TOP w0.102: R402.1 179.12,23.58 C6562.2 178.46,24.31 v1(178.37,24.4)
N38759178: length 3.8
  TOP w0.102: C1190.1 179.67,23.94 179.94,23.66 181.11,23.66 181.23,23.78 U37.12
N38763467: length 13.2
  BOTTOM w0.079: U1.CP6 94.28,35.19 94.75,34.71 94.75,34.28 94.78,34.25 94.78,33.41 95.36,32.83 95.36,31.99
  BOTTOM w0.102: 95.36,31.99 95.36,28.61 95.82,28.15 95.97,28.15 96.38,27.75 96.38,27.44 96.61,27.21 v1(98.18,27.21) 98.58,26.82 98.58,25.99 99.21,25.35 R25448.1
N39168858: length 16.8
  TOP w0.254: v1(13.4,73.39) 13.39,73.4 R713.2 R712.2 R711.2 R710.2 R709.2 R708.2 R707.2 R706.2
  BOTTOM w0.254: v1(13.4,73.39) 13.52,73.52 15.56,73.52 15.82,73.79 16.28,73.79 16.39,73.9 18.1,73.9 19.62,75.42 v1(19.85,75.42) 20.38,75.42 20.68,75.13 Q6533.3
N39687060:
  vias: v1(66.79,114.97)
N39687062: length 1.3
  TOP w0.508: PR262.2 64.71,115.85 PC301.1
N39687064: length 7
  TOP w0.102: PC301.2 63.32,116.63 v1(62.9,116.22)
  TOP w0.254: PC301.2 63.71,117 63.83,117.11 63.83,119.44 PU26.32
  TOP w0.508: PR9264.2 57.52,118.01 57.52,119.82
N39687102: length 13.5
  TOP w0.198: PU26.30 66.38,121.3 66.47,121.39 66.47,121.63 66.27,121.84 v1(66.07,121.84)
  IN3 w0.508: v1(54.7,119.62) 55.56,120.48 63.41,120.48 64.76,121.84 v1(66.07,121.84)
  vias: v1(51.04,120.28) v1(51.22,121.42) v1(51.52,120.76) v1(51.98,121.25) v1(51.98,120.28) v1(52.16,119.65) v1(52.79,119.65) v1(52.79,119.01) v1(53.43,119.65) v1(53.43,119.01) v1(53.55,120.81) v1(54.06,119.65) v1(54.06,119.01) v1(54.7,118.96) v1(55.28,119.29)
N39687293: length 1.9
  TOP w0.508: PR9264.1 v1(59.03,116.33) 59.12,116.33 59.24,116.45 PC300.2
N39687315: length 24.4
  TOP w0.102: v1(68.97,122.46) 68.82,122.31 PR263.2
  TOP w0.203: PR263.2 PC267.2 68.17,123.4 v1(67.63,123.94)
  TOP w0.254: PR9266.2 49.04,122.44 v2(49.11,122.52)
  IN3 w0.254: v2(49.11,122.52) 51.32,124.73 51.32,125.51 51.55,125.74 60.95,125.74 61.58,125.11 63.84,125.11 64.02,124.93 66.64,124.93 v1(67.63,123.94)
N39687335: length 5.4
  TOP w0.203: PC283.1 66.86,124.45 PR265.1 66.18,124.2 65.74,123.76 64.32,123.76 63.94,123.38 63.94,122.77 63.87,122.7 PU26.4
N39687341: length 3.6
  TOP w0.198: PU26.8 61.74,121.3 61.56,121.48 61.56,121.91
  TOP w0.457: PR261.2 v1(61.56,122.87) 61.56,121.91
N39687373: length 4.4
  TOP w0.203: PR9273.1 64.84,124.42 64.81,124.44 PR266.1 64.76,124.95 PC276.1 63.61,123.8 63.61,123.05 63.47,122.91 PU26.5
N39687445: length 4.6
  TOP w0.203: PU26.1 65.47,122.2 65.99,122.72 66.05,122.72 v1(66.53,123.2) 66.61,123.28 PC267.1 PR263.1 PR253.2
N39687482:
  vias: v1(65.21,123.2) v1(65.85,123.2) v1(66.36,123.71) v1(69.15,121.78) v1(69.15,121.12) v1(69.81,121.27)
N39687516: length 4.1
  TOP w0.203: v1(66.58,122.26) 66.58,122.06 66.86,121.78 66.86,121.25 66.51,120.9 PU26.29
  BOTTOM w0.203: PC298.1 67.64,121.76 67.63,121.78 PR254.1 67.15,122.28 67.13,122.26 v1(66.58,122.26)
N39688806: length 2.2
  TOP w0.203: v1(62.62,122.72) 62.87,122.72 63.07,122.52 PU26.6
  BOTTOM w0.203: PR267.1 62.37,123.23 62.57,123.02 62.57,122.77 v1(62.62,122.72)
N39782161: length 9.9
  TOP w0.102: v2(69.91,38.39) 69.58,38.72 TP9044.1
  BOTTOM w0.079: v2(69.91,38.39) 70.19,38.39 71.96,40.16 71.96,41.57 73.88,43.5 75.5,43.5 U1.BW35
N39782179: length 10.3
  TOP w0.102: TP9042.1 70.17,38.92 v2(70.16,38.92)
  BOTTOM w0.079: U1.BW34 76.44,44.02 75.91,44.02 75.84,43.99 75.6,43.99 75.5,44.03 75.3,44.03 75.17,43.98 74.96,43.98 74.79,44.06 74.21,44.06 71.79,41.64 71.79,40.25 70.47,38.92 v2(70.16,38.92)
N39782191: length 9.4
  TOP w0.102: TP9043.1 70.44,37.98 69.77,37.98 69.74,38 v2(69.47,38)
  BOTTOM w0.079: 70.44,38.32 70.78,38.66 70.78,38.72 72.13,40.07 72.13,41.5 73.17,42.55 U1.CA37
  BOTTOM w0.102: 70.44,38.32 70.08,37.96 69.51,37.96 v2(69.47,38)
N39785725: length 4.5
  BOTTOM w0.102: R25483.1 211.84,14.44 211.97,14.57 R25485.1 212.28,15.23 v1(212.28,16.5) 212.53,16.75 213.04,16.75 213.47,16.32 HD1.1
N40437801: length 10.5
  BOTTOM w0.102: U8.V7 98.79,107.43 98.11,107.43 97.98,107.3 97.98,106.79 97.85,106.67 95.77,106.67 95.52,106.41 95.52,105.14 95.31,104.94 92.11,104.94 91.65,105.4 TP9033.1
N40437812: length 10.2
  BOTTOM w0.102: TP9032.1 92.42,108.29 98.73,108.29 U8.W7
N40437815: length 7.6
  BOTTOM w0.102: U8.W6 98.07,107.85 97.7,107.48 91.68,107.48 TP9031.1
N40437818: length 11.7
  BOTTOM w0.102: TP9030.1 90.1,111.37 91.31,110.16 91.69,110.16 92.01,110.48 92.01,110.82 92.45,111.26 93.44,111.26 93.91,110.79 93.91,110.17 94.14,109.94 97.75,109.94 97.98,109.71 97.98,109.21 98.37,108.81 U8.Y6
N40911013: length 4.8
  BOTTOM w0.127: VRAM1.J13 133.41,93.21 133.03,93.59 133.03,94.22 132.4,94.86 v1(132.4,96.46) 132.4,96.88 R405.2
N40911015: length 4.5
  BOTTOM w0.102: VRAM2.J13 133.01,106.2 133.01,105.12 132.9,105.02 132.9,104.25 132.79,104.14 v1(132.79,103.16) R406.2
N41141585: length 1.6
  TOP w0.102: U37.16 182.44,22.18 182.13,22.49 TP9041.1
N43700942: length 2.6
  BOTTOM w0.102: CN29.24 55.35,106.66 55.06,106.37 55.06,106.03 55.92,105.17 55.92,105.14 55.97,105.09 R25521.2
N43737419: length 1.8
  BOTTOM w0.102: CN29.29 57.85,105.98 58.05,105.78 R25522.2
N47271970:
  vias: v1(95.03,88.12)
N48434117: length 6.1
  TOP w0.102: v1(103.97,97.24) C386.2
  TOP w0.381: L4.2 104.96,99.18 104.96,98.74 105.18,98.52 C380.2 104.71,98.31 104.62,98.22 C386.2 103.4,98.22 103.33,98.15 C375.2 102.78,97.67 v2(102.93,97.52)
  BOTTOM w0.381: U8.F11 102.93,97.45 v2(102.93,97.52)
N48587681: length 1.3
  TOP w0.254: v2(97.97,103.29) 98.53,103.29 R329.1
  BOTTOM w0.254: U8.N6 98.36,102.89 v2(97.97,103.29)
N48650493: length 4.8
  TOP w0.102: R384.1 101.4,124.57 100.64,124.57 R382.1 99.76,124.44 Q15.2
N49263752: length 7.4
  BOTTOM w0.203: R342.2 103.3,88.51 104.13,87.69 105.52,87.69 105.86,88.04 ; R339.1 R343.2 107.64,88.4 107.28,88.04 105.86,88.04 ; 105.86,88.04 R341.2
N60242660: length 2
  TOP w0.102: R267.1 55.04,98.67 v1(55.41,98.31)
  TOP w0.508: C299.2 R267.1
N414891010: length 2.6
  TOP w0.102: TP9039.1 181.37,16.88 181.86,16.88 182.26,16.48 182.26,16.4 182.48,16.18 U37.31
N4148946975: length 2.1
  TOP w0.102: TP9040.1 190.26,12.64 190.85,13.22 U37.48

## Copper pours and planes (outline as drawn)
1V8_AON_S on TOP (solid shape): 25.46,98.33 25.46,94.21 25.46,94.18 25.38,94.09 25.36,93.99 25.35,93.89 25.34,93.84 25.35,93.8 25.35,93.75 25.35,93.72 25.21,93.59 24.57,93.59 24.06,94.09 23.98,94.09 23.96,94.1 23.9,94.16 23.84,94.17 23.69,94.17 23.65,94.18 23.64,94.22 23.64,94.94 23.44,94.94 23.44,94.22 23.43,94.18 23.39,94.17 23.29,94.17 23.25,94.18 23.24,94.22 23.24,94.94 23.23,94.94 23.19,94.96 23.18,94.99 23.18,95.24 24.19,96.25 24.19,98.61 24.34,98.77 25.03,98.77
+1.2VSUS on TOP (solid shape): 47.74,96.35 47.74,95.44 47.36,95.06 45.43,95.06 45.38,95.11 44.94,95.11 44.44,95.62 44.44,96.2 44.64,96.4 47.69,96.4
+1.2VSUS on TOP (solid shape): 66.86,118.88 67.52,118.88 67.6,118.81 67.6,118.3 67.93,117.97 67.93,117.26 67.83,117.16 66.81,117.16 66.76,117.21 66.76,118.58 66.53,118.81 65.72,118.81 65.69,118.82 65.67,118.86 65.67,118.91 65.69,118.94 65.72,118.96 66.78,118.96
+1.2VSUS on TOP (solid shape): outline of 13166 points within 33.97,46.21 78.93,95.87
+1.2VSUS on BOTTOM (solid shape): 54.32,117.69 54.32,117.38 54.54,117.16 54.54,114.41 54.04,113.91 48.22,113.91 48.22,115.14 47.56,115.8 47.56,117.84 47.81,118.1 53.91,118.1
+1.2VSUS on BOTTOM (solid shape): 70.3,97.13 70.3,93.97 68.17,92.31 67.36,89.73 67.36,89.61 67.37,89.5 66.63,88.76 63.69,88.76 63.18,89.27 63.18,91.85 62.8,92.23 62.8,94.62 63.18,95 64.97,95 65.34,95.36 66.1,95.36 68.26,97.52 69.91,97.52
+1.2VSUS on BOTTOM (solid shape): outline of 108 points within 61.4,68.57 64.6,75.68
+1.2VSUS on BOTTOM (solid shape): outline of 15189 points within 20,34.5 49.08,101.46
+1.2VSUS on SVCC (solid shape): 51.62,121.28 51.62,108.17 47.91,104.46 47.79,104.38 47.71,104.26 45.36,101.9 45.3,101.91 45.25,101.92 45,101.81 44.89,101.56 44.9,101.51 44.91,101.45 44.48,101.02 44.37,101.08 44.26,101.1 44.02,101.01 43.93,100.77 43.95,100.66 44.01,100.55 43.01,99.55 28.26,99.55 28.16,99.53 28.08,99.48 22.56,93.97 18.46,93.97 18.35,94.07 18.35,99.01 25.63,106.28 37.15,106.28 37.54,106.36 37.87,106.59 39.89,108.61 40.11,108.94 40.19,109.33 40.19,113.52 40.19,113.59 40.18,113.66 42.79,116.27 42.89,116.23 42.99,116.22 43.24,116.32 43.34,116.57 43.33,116.67 43.29,116.77 43.93,117.41 43.98,117.49 44,117.59 44,123.07 44.31,123.38 48.36,123.38 48.59,123.39 48.82,123.43 49.47,123.43
+1.2VSUS on IN3 (solid shape): outline of 160 points within 48.37,113.88 67.96,119.14
+1.5V on TOP (solid shape): 172.49,26.73 172.53,26.72 172.54,26.68 172.54,22.87 171.36,22.87 171.36,26.63 171.35,26.67 171.35,26.73
+1.05V_DEEP_SUS on TOP (solid shape): 101.66,44.44 102.41,44.44 102.41,43.8 102.42,43.8 102.42,43.59 102.41,43.59 102.41,42.84 102.42,42.84 102.42,42.63 102.41,42.63 102.41,42.13 102.16,41.88 102.16,38.99 102.4,38.75 102.4,36.21 102.78,35.83 104.05,35.83 104.48,36.26 104.48,36.31 104.63,36.46 105.09,36.46 106.23,37.6 106.23,38.06 106.46,38.29 106.46,41.08 107.15,41.77 107.63,41.77 108.44,42.58 110.27,42.58 110.42,42.43 110.42,41.01 109.82,40.4 109.82,35.91 109.51,35.59 106.06,35.59 105.97,35.56 105.93,35.47 105.93,35.24 105.88,35.19 105.88,34.33 105.78,34.23 104.91,34.23 104.46,34.68 103.85,34.68 103.39,35.14 103.1,35.14 103.09,35.13 102.63,35.13 101.84,35.93 101.84,37.71 101.28,38.26 101.28,41.39 100.52,42.15 100.52,42.53 100.65,42.66 101.15,42.66 101.28,42.79 101.28,43.42 100.75,43.95 100.75,44.11 100.79,44.11 100.79,44.76 100.85,44.82 101.28,44.82
+1.05V_DEEP_SUS on BOTTOM (solid shape): 87.87,42.81 88.02,42.81 88.02,42.61 87.56,42.15 87.31,42.15 87.16,42.3 86.85,42.3 86.68,42.12 86.52,42.12 86.35,42.3 85.91,42.3 85.74,42.12 85.53,42.12 85.1,42.56 85.1,42.71 85.25,42.86 86.17,42.86 86.4,42.63 86.7,42.63 86.79,42.72 86.83,42.75 86.86,42.8 87.29,43.22 87.46,43.22
+1.05V_DEEP_SUS on BOTTOM (solid shape): 88.7,45.44 88.71,45.43 88.75,45.36 88.81,45.31 88.81,44.54 88.7,44.44 86.12,44.44 85.69,44 85.48,44 84.9,43.42 84.77,43.42 84.26,43.93 84.26,45.33 84.35,45.42 84.39,45.43 84.43,45.42 84.64,45.2 85.01,45.2 85.03,45.18 85.04,45.17 85.27,45.01 85.51,45.17 85.52,45.18 85.54,45.2 85.83,45.2 85.86,45.19 85.88,45.17 86.11,45.01 86.35,45.17 86.35,45.18 86.38,45.2 86.67,45.2 86.7,45.19 86.72,45.17 86.95,45.01 87.19,45.17 87.19,45.18 87.22,45.2 87.53,45.2 87.55,45.18 87.56,45.17 87.79,45.01 88.03,45.17 88.03,45.18 88.06,45.2 88.33,45.2 88.42,45.29 88.43,45.3 88.51,45.35 88.56,45.43 88.57,45.44 88.59,45.45 88.68,45.45
+1.05V_DEEP_SUS on BOTTOM (solid shape): outline of 490 points within 101.18,28.78 107.45,41.09
+1.05V_DEEP_SUS on SVCC (solid shape): outline of 115 points within 84.14,32.12 106.36,45.58
+1.05V_LAN on TOP (solid shape): 41.59,113.78 41.21,113.4 40.32,113.4 40.19,113.52 40.19,113.85 39.94,114.11 39.94,114.29 39.43,114.79 39.43,115.94 39.5,116 41.59,116
+1.05V_LAN on TOP (solid shape): 49.47,108.06 49.72,108.06 49.83,107.95 49.83,107.4 49.46,107.03 49.46,106.29 49.21,106.03 49.06,106.03 48.91,106 48.79,105.9 48.61,105.72 47.53,105.72 47.35,105.9 46.24,105.9 46.24,106.04 46.24,106.07 46.26,106.1 46.61,106.1 46.61,106.09 47.95,106.09 48.63,106.77 48.63,107.99 48.7,108.06 49.46,108.06
+1.05V_LAN on TOP (solid shape): 40.65,106.18 40.75,106.18 40.93,106.13 41.11,106.18 41.96,106.18 42.04,106.1 43.02,106.1 43.03,106.09 43.03,105.91 43.02,105.9 41.88,105.9 41.73,105.75 38.95,105.75 38.77,105.57 38.77,103.01 38.97,102.81 40.85,102.81 42.01,103.97 42.01,104.06 42.05,104.1 43.03,104.1 43.08,104.05 43.08,103.88 43.05,103.86 43.01,103.86 42.75,103.6 42.75,103.27 41.44,101.96 38.64,101.96 38.12,101.96 37.68,102.4 37.68,106.06 37.91,106.29 39.61,106.29 39.74,106.41 40.42,106.41
+1.05V_LAN on BOTTOM (solid shape): outline of 715 points within 37.65,102.09 49.18,115.58
+1.05V_LAN_REGOUT on TOP (solid shape): 47.6,108.86 47.64,108.86 47.76,108.74 47.76,107 47.46,106.7 46.25,106.7 46.23,106.73 46.23,106.87 46.45,107.09 47.04,107.09 47.23,107.28 47.23,107.86 47.31,108.09 47.23,108.32 47.23,108.38 47.18,108.44 47.18,108.71 47.34,108.88 47.58,108.88
+1.05V_LAN_REGOUT on TOP (solid shape): 42.7,116.32 42.83,116.22 42.99,116.19 43.04,116.19 43.1,116.21 43.37,115.94 43.37,115.68 43.67,115.38 44.94,115.38 45.15,115.18 45.15,114.29 45.03,114.17 42.34,114.17 42.1,114.41 42.1,115.94 42.48,116.32
+1.05V_LAN_REGOUT on IN1 (solid shape): outline of 298 points within 42.52,108.43 48.18,115.03
+1.8V on IN3 (solid shape): outline of 88 points within 122.79,16.54 124.62,18.02
+1.8V_DEEP_SUS on TOP (solid shape): 146.42,24.5 146.42,23.99 146.57,23.84 146.57,21.37 146.82,21.12 146.82,21.06 146.86,20.97 146.95,20.93 147.42,20.93 147.97,20.38 147.97,18.55 147.92,18.5 147.56,18.5 147.4,18.66 147.4,19.84 147.38,19.86 147.38,20.26 147.3,20.34 145.8,20.34 145.71,20.43 145.71,23 146.01,23.3 146.01,24.04 146,24.05 146,24.48 146.09,24.57 146.34,24.57
+1.8V_DEEP_SUS on TOP (solid shape): 99.1,28.21 99.1,25.94 98.69,25.54 98.69,25.46 98.68,25.41 98.68,24.6 98.69,24.55 98.69,24.37 98.49,24.17 97.93,24.17 97.72,24.37 97.72,24.95 97.7,24.98 97.7,25.08 97.62,25.15 97.62,26.3 97.64,26.34 97.93,26.47 98.03,26.73 97.92,27 97.65,27.11 97.54,27.1 97.44,27.05 97.4,27.03 97.27,27.17 97.27,28.39 97.29,28.41 98.89,28.41
+1.8V_DEEP_SUS on BOTTOM (solid shape): 98,30.77 98,28.74 98.41,28.33 98.41,27.82 98.26,27.68 97.32,27.68 97.27,27.73 97.27,28.5 97.22,28.56 97.22,29.19 97.35,29.32 97.4,29.5 97.35,29.68 97.22,29.81 97.22,30.72 97.34,30.85 97.93,30.85
+1.8V_S5 on TOP (solid shape): 28.99,31.86 30.54,31.86 30.67,31.74 30.67,28.13 30.62,28.08 28.28,28.08 28.25,28.1 28.21,28.23 28.13,28.34 28.13,28.56 27.42,29.27 27.42,31.58 27.93,32.09 28.76,32.09
+1.8V_S5 on TOP (solid shape): 25.46,92.44 25.46,91.68 25.59,91.55 25.59,90.51 25.44,90.36 25.13,90.36 24.45,91.05 24.19,91.05 23.25,91.99 23.25,92.71 23.24,92.72 23.24,92.95 23.25,92.99 23.29,93 23.39,93 23.43,92.99 23.44,92.95 23.44,92.23 23.64,92.23 23.64,92.95 23.65,92.99 23.69,93 23.84,93 23.9,93.01 23.94,93.06 23.98,93.08 24.83,93.08
+1.8V_S5 on TOP (solid shape): 21.14,93.06 21.15,93.05 21.19,93.01 21.25,93 21.39,93 21.43,92.99 21.44,92.95 21.44,92.23 21.64,92.23 21.64,92.95 21.65,92.99 21.69,93 21.79,93 21.83,92.99 21.84,92.95 21.84,92.72 21.84,92.71 21.84,91.76 21.78,91.65 21.76,91.53 21.78,91.41 21.84,91.3 21.84,90.83 21.8,90.76 21.78,90.69 21.78,90.54 21.52,90.28 18.98,90.28 18.35,90.92 18.35,92.7 18.73,93.08 21.1,93.08
+1.8V_S5 on TOP (solid shape): 100.09,25.69 100.16,25.66 100.19,25.58 100.19,25.56 100.54,25.21 100.9,25.56 100.9,25.58 100.93,25.66 101,25.69 101.26,25.69 101.46,25.49 101.46,24.4 101.3,24.24 99.3,24.24 99.1,24.45 99.1,25.46 99.35,25.46 99.36,25.45 99.44,25.42 99.53,25.41 99.74,25.48 99.87,25.66 99.88,25.69
+1.8V_S5 on BOTTOM (solid shape): outline of 122 points within 20.56,25.69 28.64,30.49
+1.8V_S5 on IN1 (solid shape): 24.95,92.06 24.95,91.17 23.81,90.03 19.87,90.03 19.49,90.41 19.49,91.05 20.64,92.19 24.83,92.19
+1.8V_S5 on SVCC (solid shape): outline of 113 points within 27.88,23.99 102.68,36.43
+1.8V_S5 on IN3 (solid shape): outline of 3368 points within 14.92,28.56 31.3,92.57
+1.8V_SW on BOTTOM (solid shape): 15.94,26.45 15.94,25.51 15.81,25.39 15.35,25.39 15.17,25.21 15.17,24.75 15,24.57 14.67,24.57 14.62,24.62 14.62,25.79 14.92,26.1 14.92,26.33 15.17,26.58 15.81,26.58
+1.8V_SW on BOTTOM (solid shape): 19.79,26.67 20.12,26.67 20.24,26.54 20.24,26.24 20.46,26.02 20.46,25.61 20.33,25.49 20.25,25.49 19.98,25.77 19.34,25.77 19.19,25.92 19.19,26.73 19.32,26.86 19.59,26.86
+1.35V_GFX on TOP (solid shape): outline of 84 points within 110.3,103.53 111.82,107.68
+1.35V_GFX on TOP (solid shape): outline of 1051 points within 109.52,96.32 132.57,106.41
+1.35V_GFX on TOP (solid shape): outline of 2619 points within 129.35,78.42 142.94,117.98
+1.35V_GFX on BOTTOM (solid shape): outline of 211 points within 103.39,96.4 111.95,108.19
+1.35V_GFX on BOTTOM (solid shape): outline of 7099 points within 118.43,79.04 142.94,120.31
+1.35V_GFX on IN1 (solid shape): outline of 1896 points within 124.52,80.38 142.97,88.12
+1.35V_GFX on IN2 (solid shape): outline of 14870 points within 103.06,80.86 142.81,119.87
+1.35V_GFX on IN3 (solid shape): outline of 324 points within 127.06,104.94 131.76,109.36
+1.35V_GFX on IN3 (solid shape): outline of 5353 points within 104.3,80.15 142.94,120.77
+1V8_AON on TOP (solid shape): 102.42,98.54 102.42,98.42 102.41,98.4 102.36,98.28 102.33,98.15 102.33,97.49 102.42,97.4 102.42,97.4 102.04,97.01 101.15,97.01 101.03,96.89 100.26,96.89 100.14,97.01 100.14,98.05 100.14,98.28 100.39,98.54 101.79,98.54 101.92,98.67 102.3,98.67
+1V8_AON on TOP (solid shape): 26.73,98.67 26.73,97.85 26.81,97.78 26.99,97.78 27.11,97.65 27.11,95.87 26.91,95.67 25.92,95.67 25.72,95.87 25.72,96.15 25.73,96.19 25.84,96.24 25.88,96.33 25.88,97.68 25.88,97.69 25.88,98.42 26.2,98.74 26.66,98.74
+1V8_AON on BOTTOM (solid shape): 99.45,122.97 99.45,122.77 99.34,122.64 99.3,122.46 99.41,122.19 99.68,122.08 99.77,122.09 99.86,122.13 99.96,122.13 100.01,122.04 100.01,120.1 99.73,119.82 99.02,119.82 98.66,120.18 98.66,120.79 98.36,121.09 98.36,121.7 98.16,121.91 97.85,121.91 97.72,122.03 97.72,122.31 98,122.59 98,123.68 98.74,123.68
+1V8_AON on BOTTOM (solid shape): outline of 92 points within 83.42,85.43 98.44,98.03
+1V8_AON on IN1 (solid shape): 27.43,96.95 27.43,95.81 27.11,95.49 25.97,95.49 25.59,95.87 25.59,96.89 25.84,97.14 27.24,97.14
+1V8_AON on IN1 (solid shape): 84.64,96.87 84.64,95.74 84.52,95.62 82.36,95.62 82.1,95.87 82.1,97.04 83.17,97.04 83.17,96.98 83.19,96.93 83.21,96.88 83.23,96.83 83.27,96.78 83.31,96.75 83.35,96.71 83.4,96.69 83.46,96.67 83.51,96.66 83.57,96.66 83.62,96.66 83.68,96.68 83.73,96.7 83.77,96.73 83.82,96.76 83.85,96.81 83.89,96.85 83.91,96.9 83.92,96.96 83.93,97.01 83.93,97.07 83.92,97.12 83.91,97.18 83.89,97.23 83.85,97.27 83.82,97.31 83.77,97.35 83.73,97.38 83.68,97.4 83.62,97.42 83.57,97.42 83.51,97.42 83.46,97.41 83.4,97.39 83.35,97.37 83.31,97.33 83.27,97.29 83.23,97.25 83.21,97.2 83.19,97.15 83.17,97.1 83.17,97.04 82.1,97.04 82.1,97.14 82.48,97.52 83.99,97.52
+1V8_AON on IN1 (solid shape): outline of 273 points within 49.74,98.48 63.69,101.23
+1V8_AON on IN1 (solid shape): outline of 1190 points within 97.69,83.27 108.37,99.71
+1V8_GFX_MAIN on TOP (solid shape): 24.6,103.59 24.6,103.06 22.31,100.77 22.19,100.77 21.28,101.68 21.25,101.71 21.25,101.92 23.05,103.72 23.05,103.75 23.43,104.13 24.06,104.13
+1V8_GFX_MAIN on TOP (solid shape): outline of 171 points within 89.22,98.03 99.88,105.52
+1V8_GFX_MAIN on TOP (solid shape): outline of 354 points within 111.57,111.24 120.46,121.27
+1V8_GFX_MAIN on BOTTOM (solid shape): 120.58,117.97 120.58,115.56 120.46,115.43 118.04,115.43 117.66,115.81 117.66,117.84 117.92,118.1 120.46,118.1
+1V8_GFX_MAIN on BOTTOM (solid shape): 101.15,98.54 101.15,97.93 101.02,97.79 100.97,97.74 100.94,97.68 100.92,97.66 100.89,97.65 100.01,97.65 99.38,98.28 99.25,98.28 98.87,98.67 98.87,99.05 98.99,99.17 100.52,99.17
+1V8_GFX_MAIN on IN1 (solid shape): outline of 1033 points within 101.76,109.16 120.28,119.06
+1V8_GFX_MAIN on IN3 (solid shape): 24.05,104.49 24.05,104.47 24.18,104.28 24.4,104.2 24.51,104.22 24.61,104.28 24.65,104.29 24.68,104.27 24.7,104.25 24.7,103.24 24.32,102.86 23.11,102.86 22.99,102.98 22.99,103.62 23.87,104.51 24.02,104.51
+1V8_GFX_MAIN on IN3 (solid shape): outline of 498 points within 53.02,112.13 75.5,117.84
+1V8_GFX_MAIN on IN3 (solid shape): outline of 1688 points within 98.84,97.73 119.85,119.04
+1V_SUS on TOP (solid shape): outline of 224 points within 111.49,41.31 120.79,49.8
+2.5V_SUS on TOP (solid shape): 36,34.15 36,32.88 35.62,32.5 33.84,32.5 33.46,32.88 33.46,34.53 33.72,34.78 35.37,34.78
+2.5V_SUS on TOP (solid shape): 70.8,118.86 70.8,116.83 70.67,116.7 69.91,116.7 69.66,116.95 69.66,117.31 69.28,117.69 69.28,118.86 69.4,118.99 70.67,118.99
+2.5V_SUS on TOP (solid shape): 68.01,103.36 68.01,101.99 68,101.97 67.99,101.95 67.88,101.84 67.5,101.46 67.24,101.46 66.48,102.22 66.48,102.37 66.48,103.44 66.79,103.75 67.63,103.75
+2.5V_SUS on TOP (solid shape): 30.03,27.69 30.03,26.25 30.03,24.65 30.03,24.42 30.03,24.42 30.03,23.94 30.03,23.4 29.96,23.33 28.46,23.33 28.34,23.44 28.34,24.07 28.37,24.16 28.38,24.24 28.37,24.32 28.34,24.41 28.34,26.33 28.45,26.33 28.83,26.7 28.84,26.7 29.06,27.22 28.52,27.39 28.44,27.38 28.38,27.44 28.34,27.51 28.34,27.66 28.49,27.8 29.93,27.8
+2.5V_SUS on TOP (solid shape): 51.37,98.22 51.4,98.21 51.67,98.06 51.97,98 52.97,98 53.01,97.99 53.02,97.95 53.02,96.28 52.67,95.92 51.77,95.92 51.67,95.99 51.71,96.1 51.79,96.62 51.27,96.73 51.17,96.73 51.12,96.82 51.12,98.03 51.2,98.12 51.27,98.16 51.34,98.21
+2.5V_SUS on TOP (solid shape): 53.07,31.74 53.09,31.73 53.11,31.72 53.36,31.62 53.62,31.72 53.64,31.73 53.66,31.74 54.29,31.74 55.09,30.94 55.1,30.91 55.09,30.87 55.05,30.78 55.03,30.68 55.01,30.61 55,30.54 55.04,30.37 55.17,30.22 55.18,30.19 55.18,29.96 55.03,29.8 55.03,29.68 54.93,29.58 54.93,29.34 54.88,29.25 54.78,29.25 54.25,29.35 53.76,29.14 53.68,29.11 53.61,29.16 53.47,29.28 53.29,29.32 53.05,29.24 52.92,29.01 52.89,28.99 52.89,28.08 52.74,27.93 52.46,27.93 52.37,28.02 52.37,30.09 52.5,30.21 52.89,30.21 53.02,30.34 53.02,30.85 52.89,30.97 52.7,30.97 52.6,31.02 52.49,31.04 52.44,31.03 52.39,31.02 52.3,31.04 52.26,31.12 52.26,31.61 52.32,31.67 52.36,31.68 52.38,31.66 52.49,31.6 52.61,31.58 52.77,31.62 52.92,31.73 52.94,31.74
+2.5V_SUS on BOTTOM (solid shape): 34.91,33.84 34.91,33.39 34.78,33.26 33.59,33.26 33.46,33.39 33.46,34.86 33.56,34.96 33.79,34.96
+2.5V_SUS on BOTTOM (solid shape): 53.02,98.03 53.02,97.27 52.77,97.01 51.37,97.01 51.12,97.27 51.12,98.16 51.24,98.28 52.77,98.28
+2.5V_SUS on BOTTOM (solid shape): outline of 401 points within 48.78,26.33 59.2,30.33
+2.5V_SUS on BOTTOM (solid shape): outline of 460 points within 18.35,86.98 31.24,102.86
+2.5V_SUS on IN1 (solid shape): outline of 383 points within 64.48,102.7 70.55,119.52
+2.5V_SUS on IN2 (solid shape): outline of 416 points within 32.52,24.85 50.86,33.74
+2.5V_SUS on IN3 (solid shape): outline of 137 points within 28.23,26.71 34.86,34.65
+3V on TOP (solid shape): 59.5,102.6 59.5,101.97 59.37,101.84 59.04,101.84 58.91,101.97 58.48,101.97 58.35,102.09 58.35,102.6 58.63,102.88 59.22,102.88
+3V on TOP (solid shape): 26.52,6.23 26.89,6.23 27.42,5.7 27.42,2.83 26.86,2.27 25.33,2.27 25.21,2.4 25.21,3.67 24.95,3.92 24.95,6.02 25.17,6.23 26.52,6.23
+3V on TOP (solid shape): 51.87,105.96 52.53,105.96 53.02,105.47 53.02,105.18 53.02,105.17 53.02,104.62 53.02,104.61 53.02,104.13 52.89,104 51.62,104 51.5,104.13 51.5,106.03 51.62,106.16 51.68,106.16
+3V on TOP (solid shape): 18.1,88 18.1,85.97 17.94,85.81 17.94,84.97 18.35,84.57 19.37,84.57 19.49,84.7 19.55,84.7 20.03,84.22 20.03,83.86 19.98,83.81 18.53,83.81 18.4,83.93 17.57,83.93 17.47,84.03 17.47,84.94 16.79,85.62 16.75,85.69 16.7,85.74 16.7,87.87 16.96,88.12 17.97,88.12
+3V on TOP (solid shape): 26.35,84.19 26.35,83.68 26.22,83.55 25.84,83.55 25.72,83.43 25.72,82.54 25.59,82.41 24.57,82.41 24.45,82.54 24.45,82.92 24.32,83.04 23.68,83.04 23.56,82.92 23.56,81.77 23.68,81.65 23.68,80.73 23.52,80.57 22.91,80.57 22.88,80.6 22.88,81.78 22.79,81.87 22.79,84.06 23.05,84.31 26.22,84.31
+3V on TOP (solid shape): 24.32,76.26 24.32,75.3 25.21,74.41 25.97,74.41 26.1,74.28 26.1,73.01 25.93,72.85 25.87,72.81 25.81,72.76 24.31,72.76 24.17,72.9 23.71,72.9 23.67,72.86 23.56,72.86 22.88,73.54 22.88,74.2 22.54,74.54 22.16,74.54 21.91,74.79 21.91,75.3 21.98,75.37 23.25,75.37 23.43,75.55 23.43,76.06 23.65,76.27 24.31,76.27
+3V on TOP (solid shape): 151.54,29.61 151.54,28.31 151.32,28.08 151.32,27.17 151.22,27.07 151.22,26.7 151.22,26.68 151.53,26.37 151.55,26.26 151.46,26.2 151.41,26.2 151.32,26.16 151.28,26.07 151.28,24.75 149.29,24.75 149.03,25.01 149.03,26.99 148.65,27.37 148.65,29.15 148.52,29.27 148.52,29.58 148.65,29.7 151.45,29.7
+3V on TOP (solid shape): 203.21,13.23 203.21,12.74 204.23,11.72 204.23,11.42 204.64,11.01 205.26,11.01 205.34,10.93 205.34,10.7 205.75,10.3 207.53,10.3 207.63,10.2 207.63,9.74 207.58,9.69 204.66,9.69 203.91,10.44 203.91,10.55 203.52,10.94 203.52,11.8 203.12,12.2 202.83,12.2 202.8,12.23 202.58,12.23 202.5,12.31 202.5,13.24 203.13,13.24 203.16,13.25
+3V on TOP (solid shape): 205.45,27.37 205.49,27.35 205.5,27.32 205.5,27.22 205.57,27.06 205.73,26.99 205.93,26.99 206.06,26.86 206.06,26.4 206.05,26.37 206.03,26.36 205.94,26.28 205.88,26.18 205.86,26.16 205.83,26.15 205.47,26.15 205.29,26.33 204.58,26.33 204.55,26.34 204.53,26.38 204.53,26.5 204.56,26.53 204.56,27.29 204.62,27.35 204.84,27.35 204.9,27.35 204.97,27.37
+3V on TOP (solid shape): 65.87,39.58 65.87,33.35 65.97,33.24 65.93,33.16 65.84,33.15 65.78,33.16 65.72,33.17 65.34,32.79 65.72,32.4 65.78,32.41 65.84,32.43 65.93,32.41 65.97,32.33 65.97,31.35 65.77,31.14 65.77,28.16 65.31,27.7 65.09,27.7 65.07,27.72 65.03,27.82 64.96,27.89 64.96,30.62 64.83,30.75 64.83,31.56 64.63,31.76 64.63,35.04 65.31,35.72 65.31,37.52 64.32,38.51 64.32,39.23 64.37,39.28 64.83,39.28 64.91,39.35 65.02,39.35 65.02,39.66 65.8,39.66
+3V on TOP (solid shape): outline of 178 points within 132.14,17.89 136.92,27.21
+3V on BOTTOM (solid shape): 59.62,104.38 59.62,102.22 59.24,101.84 58.42,101.84 57.59,102.67 57.59,103.47 57.82,103.47 58.86,104.51 59.5,104.51
+3V on BOTTOM (solid shape): 24.83,75.93 24.83,74.41 24.57,74.15 22.41,74.15 22.16,74.41 22.16,75.79 22.29,75.92 23.43,75.92 23.7,76.19 24.57,76.19
+3V on BOTTOM (solid shape): 198.32,27.3 198.32,26.87 198.51,26.68 198.51,25.87 198.49,25.84 198.23,25.84 197.67,26.4 197.67,26.47 197.52,26.63 197.52,26.96 197.92,27.36 197.93,27.37 198.26,27.37
+3V on BOTTOM (solid shape): 212.79,26.78 212.79,25.89 211.9,25.01 211.62,25.01 211.58,25.02 211.57,25.06 211.57,25.77 212.15,26.35 212.15,26.39 212.18,26.45 212.18,26.51 212.18,26.79 212.36,26.96 212.61,26.96
+3V on BOTTOM (solid shape): 102.17,123.56 102.17,123.18 101.92,122.92 101.92,122.01 101.9,121.97 101.87,121.96 100.72,121.96 100.71,121.97 100.71,122.35 100.7,122.4 100.66,122.44 100.65,122.47 100.65,122.8 100.78,122.93 100.8,122.93 100.96,122.99 101.02,123.15 101.02,123.17 101.53,123.68 102.04,123.68
+3V on BOTTOM (solid shape): 216.27,33.62 216.27,31.28 216.22,31.23 215.58,31.23 215.45,31.36 215.45,31.89 214.59,32.75 214.34,32.75 214.29,32.8 212.56,32.8 212.46,32.9 212.46,33.25 212.9,33.25 212.9,33.05 214.2,33.05 214.2,33.25 212.9,33.25 212.9,33.25 212.46,33.25 212.46,33.75 212.9,33.75 212.9,33.55 214.2,33.55 214.2,33.75 212.9,33.75 212.9,33.75 212.46,33.75 212.46,33.87 212.64,34.05 214.1,34.05 214.39,34.05 214.49,34.15 215.73,34.15
+3V on BOTTOM (solid shape): 195.08,29.88 195.08,29.27 195.26,29.09 195.26,29.07 195.34,28.99 195.36,28.99 195.46,28.89 196.33,28.89 196.53,28.69 196.53,28.66 196.05,28.18 195.96,28.04 195.92,27.88 196,27.63 196.2,27.47 196.21,27.47 196.25,27.44 196.25,27.41 196.2,27.37 195.31,27.37 195.26,27.42 195.19,27.42 194.58,28.03 194.37,28.03 194.3,28.06 194.27,28.13 194.25,28.24 194.19,28.35 194.17,28.41 194.19,28.47 194.25,28.58 194.27,28.7 194.27,29.75 194.43,29.91 195.06,29.91
+3V on BOTTOM (solid shape): outline of 167 points within 81.6,96.76 91.5,100
+3V on BOTTOM (solid shape): outline of 222 points within 16.7,81.9 26.1,88.38
