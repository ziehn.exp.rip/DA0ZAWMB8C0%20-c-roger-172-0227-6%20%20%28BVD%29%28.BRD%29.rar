# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V3A_BOOT: length 2.5
  BOTTOM w0.508: 147.06,32.43 147.06,33.12 147.2,33.26 v1(147.2,33.54) 147.2,33.69 146.92,33.97 146.92,34.49 PR6000.2
V3A_BOOT_R: length 2.5
  BOTTOM w0.102: PC6001.1 148.02,36.26 148.14,36.38 v1(148.14,36.89)
  BOTTOM w0.508: PC6001.1 147.13,35.81 147.04,35.89 PR6000.1
V3A_EN: length 3.8
  TOP w0.203: v1(142.94,32.13) 143.27,31.8 PR6006.2 PC6007.2 144.71,32.02 144.26,32.47 PR6002.1
  BOTTOM w0.203: v1(142.94,32.13) 143.01,32.05 PU6000.6
V3A_PWRGD: length 1.2
  BOTTOM w0.203: PU6000.7 143.81,32.93 143.71,32.83 PR6005.1
V3A_VBYP: length 5.9
  TOP w0.203: PC6023.1 145.49,36.81 145.29,36.61 145.29,36.27 PR6009.2 145.55,36.01 v2(145.55,34.48)
  BOTTOM w0.203: PR6017.1 145.55,35.33 v2(145.55,34.48) 145.83,34.2 145.83,33.52 145.95,33.4 PU6000.11
V3A_VOUT: length 20.4
  TOP w0.203: PC6017.2 145.73,32.59 PR6010.2 145.44,33.36 145.38,33.42 v2(145.38,33.87) 145.71,33.87 146.57,34.73 PR6011.2
  IN3 w0.203: v2(158.66,36.66) 158.66,36.56 158.56,36.46 156.92,36.46 155.78,35.32 153.49,35.32 153.12,35.69 149.15,35.69 149.05,35.6 147.28,35.6 145.58,33.89 145.4,33.89 v2(145.38,33.87)
  BOTTOM w0.203: v2(158.66,36.66) 158.83,36.84 PR6008.2 ; PU6000.10 145.5,33.47 145.38,33.59 v2(145.38,33.87)
V5P5A_BOOT: length 3.4
  TOP w0.102: v1(42.43,17.99) 42.15,18.27 v2(41.72,18.27)
  TOP w0.508: PR6018.2 41.68,18.31 v2(41.72,18.27)
  BOTTOM w0.229: PU6003.1 41.97,19.43 41.72,19.18 v2(41.72,18.27)
V5P5A_BOOT_R: length 2.4
  TOP w0.102: PC6035.1 v1(38.29,18.52)
  TOP w0.508: PC6035.1 39.97,18.52 PR6018.1
V5P5A_EN: length 7.4
  BOTTOM w0.102: PU6003.6 45.92,19.43 46.57,18.78 PR6020.1 v1(46.57,17.89) 46.57,17.36 47.18,16.75 47.18,15.08 PR6021.2 48.03,14.24 PC6039.2
V5P5A_PWRGD: length 1.8
  BOTTOM w0.229: PR6022.1 45.13,18.01 PU6003.7
V5P5A_VOUT: length 7.8
  BOTTOM w0.229: PR6026.1 v1(40.73,13.7) 41.74,13.7 42.22,14.18 PR6029.2 42.22,14.81 42.95,15.54 PC6055.2 42.95,15.77 44,16.82 PR6030.2 44,17.44 43.78,17.66 PU6003.10
VCC1_CORE:
  vias: v1(115.89,67.78)
VCC2_CORE: length 3.7
  BOTTOM w0.102: v1(133.97,50.35) 133.97,49.76 133.86,49.64 PU7001.8
  BOTTOM w0.254: PR7080.2 135.04,48.65 134.81,48.88 PC7063.2 134.32,49.28 134.16,49.12 PU7001.8
VCC_SA: length 3.4
  BOTTOM w0.102: v1(144.35,43.58) PC7104.2
  BOTTOM w0.254: PC7104.2 143.29,43.43 PU7004.8
  BOTTOM w0.508: PC7104.2 143.44,44.05 143.59,44.2 PR7116.2
VCCA_19P2_1P05: length 17.2
  TOP w0.381: v1(103.57,42.58) 103.57,42.59 R1271.1
  IN2 w0.254: v2(90.8,46.89) 91.7,47.8 96.27,47.8 96.71,47.36 96.71,46.72 97.09,46.34 98.61,46.34 101.79,43.17 102.98,43.17 v1(103.57,42.58)
  BOTTOM w0.254: v2(90.8,46.89) 90.79,46.89 90.78,46.87 90.69,46.87 90.38,46.56 U1.BR12
VCCA_OC_1P05: length 18.9
  TOP w0.254: R1265.1 103.54,44.18 v1(103.57,44.16)
  IN2 w0.254: v2(89.04,47.48) 88.91,47.61 88.91,48.32 89.37,48.78 96.18,48.78 97.32,47.64 98.31,47.64 99.15,46.8 99.15,46.7 101.66,44.18 103.54,44.18 v1(103.57,44.16)
  BOTTOM w0.254: U1.BP14 89.2,47.48 v2(89.04,47.48)
VCCA_SRC_1P05: length 16.3
  TOP w0.381: v1(102.75,41.62) 102.75,41.72 102.94,41.9 R1266.1
  IN2 w0.254: v1(102.75,41.62) 102.58,41.62 98.49,45.71 96.4,45.71 95.29,46.82 91.6,46.82 90.99,46.21 v2(90.71,46.21)
  BOTTOM w0.254: U1.BU12 90.71,45.67 v2(90.71,46.21)
VCCA_XTAL_1P05: length 10.4
  TOP w0.254: v1(99.88,27.55) R1267.1 99.88,28.44 C227.2 99.6,29.22 99.31,29.51 99.31,29.77 98.61,30.47 98.61,31.74 98.33,32.02 97.52,32.02 97.19,32.35 97.19,32.63 95.83,34 v2(95.21,34)
  BOTTOM w0.254: v2(95.21,34) 95.11,34.1 95.11,34.33 95.03,34.4 95.03,34.87 U1.CP5
VCCAMPHYPLL_1P05: length 1.1
  BOTTOM w0.152: v2(98.13,44.64) 98.11,44.64 97.95,44.8 97.41,44.8 U1.BV2
  vias: v1(99.38,45.02)
VCCAPLL_1.05V: length 2.8
  BOTTOM w0.254: U1.BR15 88.78,46.56 v2(89.06,46.85) 89.35,46.56 U1.BR14 89.57,46.56 89.83,46.82 89.83,46.88 v2(89.84,46.9) ; U1.BU14 89.47,45.3 89.76,45.59 v2(89.95,45.59) 89.95,45.65 90.22,45.91 U1.BT12
  vias: v1(98.06,43.29)
VCCDPHY_1P24:
  vias: v1(81.88,29.68)
VCCDSW_1P05: length 1.1
  TOP w0.203: v2(83.24,46.24) 83.26,46.26 C229.2
  BOTTOM w0.191: v2(83.24,46.24) 82.91,45.91 U1.BT24
VCCDSW_3P32: length 16.6
  TOP w0.254: R1270.1 85.43,32.1 85.43,33.36 85.77,33.7 85.77,34.06 83.98,35.85 83.98,37.35 83.76,37.58 83.76,40.63 83.5,40.88 83.5,41.13 82.76,41.87 82.76,45.35 83,45.59 v2(83.24,45.59)
  BOTTOM w0.254: v2(83.24,45.59) 83.27,45.59 U1.BT23
VCCDSW_GPIO: length 16.9
  TOP w0.508: 84.14,31.61 84.14,31.74 84.31,31.91 84.31,33.01 84.64,33.34 84.64,34.29 83.42,35.51 83.42,37.15 83.24,37.33 83.24,40.4 81.7,41.95 81.7,43.88 82.08,44.26 82.08,45.81 82.28,46.01 v2(82.28,46.25)
  BOTTOM w0.254: v2(82.28,46.25) 82.44,46.25 U1.BR24
VCCDUSB_1P05: length 4.6
  IN2 w0.508: 100.39,38.47 101.03,38.47 102.8,36.69 v2(103.8,36.69)
  BOTTOM w0.254: U1.CC12 90.28,41.36 v2(89.95,41.04)
VCCGT_SENSE: length 7.8
  TOP w0.102: PR7051.1 102.19,78.75 101.78,78.75 PR7050.1 101.53,78.85 101.28,78.6 v1(100.9,78.6)
  BOTTOM w0.102: v1(100.9,78.6) 100.52,78.22 97.74,78.22 97.59,78.07 97.06,78.07 96.9,77.9 96.53,77.9 96.35,77.72 96.35,77.37 U1.E3
VCCHDA: length 0.5
  BOTTOM w0.254: U1.BT20 85.56,45.63 85.58,45.63 85.63,45.58 v2(85.64,45.58)
  vias: v1(87.67,34.61)
VCCIO_VCCSENSE: length 1.4
  TOP w0.203: v2(80.61,46.47) 80.43,46.65 R72.1
  BOTTOM w0.203: U1.BP28 80.58,46.74 80.58,46.49 v2(80.61,46.47)
VCCIO_VSSSENSE: length 1.5
  TOP w0.203: v2(79.97,46.49) 79.97,46.54 79.46,47.04 R74.1
  BOTTOM w0.203: v2(79.97,46.49) 79.69,46.76 U1.BP29
VCCMPHYGTAON_1P05:
  vias: v1(100.98,37.53) v1(103.8,30.03) v1(104.43,30.03) v2(89.84,44.28) v2(89.84,43.65) v2(90.79,44.29) v2(90.79,43.63)
VCCPRIM_1P05: length 5
  BOTTOM w0.254: U1.BU18 86.97,45.26 v2(87.3,45.59) 86.98,45.91 U1.BT18 ; v2(85.64,46.24) 85.62,46.24 85.3,46.56 U1.BR20 ; v2(88.97,42.34) 89,42.34 89.01,42.35 89.16,42.35 U1.CA14 ; v2(84.89,46.24) 84.56,45.91 U1.BT22 ; U1.BU19 86.44,45.59 v2(86.59,45.59) 86.27,45.91 U1.BT19 ; U1.BP20 85.57,47.51 85.62,47.51 v2(85.64,47.53) ; v2(84.89,47.53) 84.74,47.53 84.43,47.23 U1.BP22
  vias: v1(99.48,40.75) v1(99.76,40.12) v1(100.11,40.78) v1(100.39,40.14) v2(85.64,43.65) v2(86.59,43.64) v2(87.39,43.67)
VCCPRIM_1P8: length 7.2
  TOP w0.203: v1(96.58,32.52) 96.58,32.12 96.86,31.84 C224.2
  IN2 w0.508: v2(87.23,34.15) 86.68,34.15 86.17,34.66 84.52,34.66 83.86,34 v2(83.7,34)
  BOTTOM w0.152: U1.CP23 83.54,34.16 v2(83.7,34)
  BOTTOM w0.203: U1.CP17 87.32,34.26 87.23,34.17 v2(87.23,34.15)
  vias: v1(95.95,32.52) v1(96.84,27.7) v2(86.54,41.04) v2(86.52,40.44) v2(87.36,41.06) v2(87.36,40.45)
VCCPRIM_3P3: length 3.4
  BOTTOM w0.254: U1.CP29 79.99,34.87 79.99,34.43 80.59,33.84 80.59,32.53 v2(80.28,32.22)
  vias: v1(85.94,33.06) v1(85.94,32.42) v1(86.5,31) v1(86.57,33.03) v1(86.57,32.4) v2(84.01,41.62) v2(84.01,41.03)
VCCPRIM_3P33: length 1.4
  TOP w0.102: v1(98.64,37.58) 98.86,37.35 C219.2
  BOTTOM w0.254: v2(87.41,41.71) 87.49,41.71 U1.CB16
  vias: v1(99.35,36.51)
VCCSA_SENSE: length 35.3
  TOP w0.102: v2(93.74,51.88) 93.74,51.93 93.23,52.44 93.23,53.12 93.43,53.33 94.73,53.33 95.64,54.24 97.73,54.24 97.86,54.37 105.07,54.37 v1(105.34,54.09) ; PR7058.1 116.82,44.08 v1(116.5,44.08) 115.97,43.55 PR7057.1
  IN1 w0.089: v1(105.34,54.09) 107.25,54.09 107.71,53.63 111.24,53.63 112.58,52.28 112.58,49.92 114.97,47.54 116.34,47.54 116.93,46.95 116.93,44.51 v1(116.5,44.08)
  BOTTOM w0.203: v2(93.74,51.88) 93.74,51.78 93.42,51.46 U1.BG7
VCCSPI: length 7.3
  TOP w0.508: R1276.2 87.21,31.64 v1(87.21,32.96) 87.21,33.31 86.63,33.9 86.63,34.12 84.77,35.98 84.77,37.2
  BOTTOM w0.254: U1.BV23 83.56,44.61 83.24,44.29 v2(83.24,44.29)
VSSGT_SENSE: length 8.3
  TOP w0.102: PR7053.1 102.54,78.28 102.42,78.4 101.88,78.4 PR7052.1 101.37,78.22 101.15,78.22 v1(100.9,77.96)
  BOTTOM w0.102: U1.D2 96.54,77.42 96.54,77.17 96.61,77.1 96.94,77.1 97.27,77.43 97.57,77.43 97.68,77.33 98.23,77.33 98.41,77.51 98.41,77.81 98.56,77.96 98.75,77.96 98.86,77.86 98.86,77.61 98.96,77.51 99.16,77.51 99.26,77.61 99.26,77.86 99.36,77.96 v1(100.9,77.96)
VSSSA_SENSE: length 32.4
  TOP w0.102: v2(93.69,52.83) 93.69,52.83 93.7,52.83 94.19,52.34 94.6,52.34 94.65,52.39 95.29,52.39 95.64,52.74 95.64,53.55 96,53.91 97.87,53.91 98,54.04 104.66,54.04 105.34,53.35 v1(105.37,53.35) ; PR7062.1 117.07,45.48 v1(116.48,45.48) 115.99,45.96 PR7061.1
  IN1 w0.089: v1(105.37,53.35) 105.8,53.78 107.12,53.78 107.58,53.33 111.11,53.33 112.28,52.16 112.28,49.8 114.84,47.23 116.22,47.23 116.63,46.82 116.63,45.63 v1(116.48,45.48)
  BOTTOM w0.203: v2(93.69,52.83) 93.68,52.83 93.67,52.83 93.38,52.53 U1.BE7
1.03_GFX_PGD: length 102.4
  IN1 w0.089: v1(142.38,65.39) 142.38,65.39 142.38,65.42 142.72,65.76 142.72,77.16 139.98,79.9 129.22,79.9 128.41,80.72 117.97,80.72 115.72,82.97 115.72,84.09 114.78,85.03 112.69,85.03 v1(110.55,82.89)
  IN2 w0.089: v1(75.91,105.42) 75.91,105.27 76.36,104.82 77.25,104.82 77.76,104.31 81.43,104.31 83.75,101.99 89.04,101.99 90.87,100.16 90.87,99.17 92.19,97.85 92.19,92.46 95.53,89.11 98,89.11 98.54,88.57 102.24,88.57 105.43,85.39 105.43,85.2 107.17,83.46 109.99,83.46 v1(110.55,82.89)
  BOTTOM w0.102: v1(75.91,105.42) 75.91,105.19 75.86,105.14 75.86,104.28 76.26,103.87 77.02,103.87 77.28,103.62 77.28,102.45 PR9076.1 PR9078.2
  BOTTOM w0.254: PR9096.1 142.35,66.01 142.35,65.42 v1(142.38,65.39)
2ND_MBCLK: length 136.9
  TOP w0.102: v2(174.34,30.15) 174.34,29.68 173.73,29.07 172.17,29.07 171.94,29.3 171.94,29.7 172.17,29.93 172.17,30.62 172.27,30.72 Q13.3 ; R383.1 190.69,31.75 190.74,31.7 v2(190.74,31.57) 190.74,31.46 190.05,30.77 U37.115
  IN1 w0.089: v2(190.74,31.57) 190.74,31.7 ; 190.74,31.7 190.5,31.94 190,31.94 188.81,30.75 188.15,30.75 188.03,30.86 186.95,30.86 186.92,30.83 185.65,30.83 185.58,30.75 183.22,30.75 183.1,30.88 177.18,30.88 176.85,30.55 174.75,30.55 v2(174.34,30.15) ; 190.74,31.7 190.74,31.79 191.58,32.63 194.13,32.63 195.2,31.55 195.2,27.61 195.48,27.33 195.83,27.33 v2(196.44,27.94)
  IN2 w0.089: v2(89.17,29.41) 89.17,29.38 89.55,29 91.96,29 92.12,28.84 95.53,28.84 96.81,27.57 98.16,27.57 98.77,26.96 98.77,25.66 100.34,24.09 102.47,24.09 102.68,24.29 109.56,24.29 110.79,25.52 112.13,25.52 113.17,26.55 125.23,26.55 125.88,25.9 135.76,25.9 137.83,23.84 149.45,23.84 149.77,24.16 149.77,24.6 150.18,25 152.88,25 153.52,24.36 158.58,24.36 158.94,24.01 164.54,24.01 164.83,24.29 165.43,24.29 165.79,24.65 167.7,24.65 168.06,25.01 173.55,25.01 173.71,25.16 174.95,25.16 175.18,25.39 v2(175.18,25.49)
  BOTTOM w0.102: v2(196.44,27.94) 196.78,28.28 198.15,28.28 R740.2 ; v2(89.17,29.41) 89.47,29.72 R25449.1 ; v2(174.34,30.15) 174.34,29.89 175.16,29.07 175.16,25.51 v2(175.18,25.49)
2ND_MBDATA: length 140.7
  TOP w0.102: U37.116 189.65,31.05 v2(190.16,31.56) 190.18,31.56 190.3,31.69 190.3,31.94 190.2,32.04 R25304.1 ; Q13.6 175.05,32.39 175.32,32.12 175.32,31.05 174.88,30.61 174.88,30.18 v2(174.93,30.13)
  IN1 w0.089: v2(201.17,25.81) 200.88,25.81 200.22,25.14 199.45,25.14 198.31,26.28 197.6,26.28 197.3,26.58 195.75,26.58 194.86,27.47 194.86,31.4 194,32.27 191.73,32.27 191.15,31.69 191.15,31.43 190.87,31.16 190.38,31.16 190.16,31.38 v2(190.16,31.56) 188.93,30.34 183.08,30.34 182.88,30.54 177.32,30.54 177,30.21 175.02,30.21 v2(174.93,30.13)
  IN2 w0.089: v2(175.76,25.49) 175.08,24.81 173.84,24.81 173.69,24.66 168.2,24.66 167.83,24.29 165.91,24.29 165.57,23.95 164.97,23.95 164.69,23.67 158.8,23.67 158.44,24.02 153.37,24.02 152.73,24.66 150.32,24.66 150.13,24.47 150.13,24.03 149.6,23.5 146.97,23.5 146.77,23.3 144.64,23.3 144.46,23.48 137.25,23.48 135.71,25.02 126.28,25.02 125.36,25.94 113.14,25.94 112.37,25.17 110.93,25.17 109.46,23.71 100.2,23.71 98.42,25.48 98.42,26.8 98.06,27.16 96.73,27.16 95.44,28.45 91.87,28.45 91.71,28.61 89.35,28.61 v2(88.56,29.41)
  BOTTOM w0.102: v2(201.17,25.81) 201.28,25.92 201.28,26.85 R739.2 ; v2(88.56,29.41) 88.59,29.41 88.83,29.65 88.83,29.86 R25450.1 ; v2(174.93,30.13) 174.93,29.81 175.52,29.22 175.52,25.73 v2(175.76,25.49)
27M_XTAL_IN: length 10.2
  BOTTOM w0.102: Y3.3 101.87,86.14 100.77,87.24 100.77,88.25 101.03,88.51 101.15,88.51 C463.1 101.2,89.21 101.2,90.04 102.2,91.03 102.2,92.64 102.26,92.71 102.26,93.65 102.17,93.74 102.17,94.25 U8.C11
27M_XTAL_OUT: length 7.3
  BOTTOM w0.102: U8.B10 102.05,93.49 102.05,92.83 101.66,92.44 101.66,91.18 100.7,90.22 100.7,89.05 C464.1 100.53,88.77 arc(100.53,88.77) 100.53,88.77 99.67,87.91 arc(99.67,87.91) 99.67,87.91 Y3.1
3602_ALERT#: length 2.2
  BOTTOM w0.102: PU7000.33 v1(139.75,58.89) 139.75,59.28 139.86,59.39 PR7020.1
3602_CLK: length 2.5
  BOTTOM w0.102: PR7015.2 140.68,59.7 140.3,59.32 140.3,58.72 140.15,58.57 PU7000.34
3602_DRON: length 72.3
  TOP w0.254: v1(134.81,44.18) 135.38,43.61 142.77,43.61 144.11,42.28 v1(144.11,42.18)
  IN2 w0.203: v1(134.81,44.18) 134.81,44.77 134.99,44.94 134.99,45.28 138.7,48.99 138.7,50.48 140.09,51.88 140.09,58.38 v1(140.75,59.04)
  IN3 w0.203: 130.91,72.73 130.91,73.89 131.41,74.38 131.41,75.68 v1(131.33,75.75) ; 130.91,72.73 131.58,72.06 131.58,70.85 133.77,68.67 139.2,68.67 139.71,68.16 139.71,64.43 140.07,64.07 140.07,62.19 140.98,61.28 140.98,59.27 v1(140.75,59.04) ; 130.91,72.73 127.67,72.73 124.57,72.73 124.19,73.11 118.1,73.11 117.71,72.73 v1(117.71,71.14)
  BOTTOM w0.203: PR7111.1 130.85,76.24 v1(131.33,75.75) ; PU7000.35 140.55,58.3 140.75,58.51 v1(140.75,59.04) ; v1(117.71,71.14) 117.59,71.14 117.38,70.94 117.38,70.91 PR7107.1
  BOTTOM w0.254: v1(134.81,44.18) 135.06,44.44 PR7079.1 ; v1(144.11,42.18) 143.76,41.83 PR7115.1
3602_PSYS: length 4.2
  TOP w0.203: PR7039.2 PC7006.1 142.15,53.27 PR7042.2 142.56,53.32 142.56,52.95 142.76,52.74 v1(142.99,52.74)
  BOTTOM w0.203: PU7000.46 142.66,53.07 v1(142.99,52.74)
3602_SET1: length 4.2
  TOP w0.203: PR7035.2 v1(141.46,51.06) 141.46,50.97 v1(141.87,50.56) 142.17,50.25 PR7027.2
  BOTTOM w0.203: v1(141.46,51.06) 141.46,50.96 141.14,50.65 140.73,50.65 140.55,50.83 PU7000.2
3602_SET2: length 5.7
  TOP w0.203: 140.84,50.7 140.84,50.23 140.5,49.9 v1(139.81,49.9) ; 140.84,50.7 141.64,49.9 142.04,49.9 PR7028.2 ; 140.84,50.7 PR7036.1
  BOTTOM w0.203: v1(139.81,49.9) 139.81,50.1 139.35,50.57 PU7000.5
3602_SET3: length 3.2
  TOP w0.203: v1(139.18,49.9) 139.18,49.27 PR7029.2 PR7037.1
  BOTTOM w0.203: v1(139.18,49.9) 138.95,50.13 PU7000.6
3602_TSENSE_CORE: length 33.9
  IN2 w0.203: v1(135.7,50.71) 135.7,56.88 136.33,57.52 136.33,59.78 135.7,60.41 135.7,62.83 135.37,63.16 133.95,63.16 133.51,63.59 133.51,68.19 129.07,72.63 127.37,72.63 126.81,73.19 126.81,73.95 127.01,74.15 v1(127.21,74.15)
  BOTTOM w0.203: PR7032.1 126.71,73.95 126.91,74.15 v1(127.21,74.15) ; PU7000.11 136.95,50.83 136.76,50.65 136.37,50.65 135.77,50.05 PR7026.2 135.7,50.06 v1(135.7,50.71)
3602_TSENSE_GT: length 36.6
  TOP w0.203: PR7018.2 135.32,57.09 135.16,56.93 v1(134.81,56.93) 134.43,57.31 v1(134.43,57.44)
  IN2 w0.203: v1(124,81.56) 123.86,81.42 123.86,80.22 124.7,79.39 126.53,79.39 127.75,78.17 127.75,77.08 127.37,76.69 127.37,75.47 126.2,74.31 126.2,72.48 130.16,68.52 132.32,68.52 132.9,67.93 132.9,62.98 133.63,62.25 133.63,60.42 133.97,60.08 133.97,57.9 v1(134.43,57.44)
  BOTTOM w0.203: PR7021.1 124,80.87 v1(124,81.56) ; v1(134.43,57.44) 134.62,57.24 134.62,56.75 135.11,56.27 PU7000.23
3602_VCC: length 5
  TOP w0.508: v1(134.5,52.95) 134.3,52.74 v1(134.3,52.16) 134.74,52.16 PC7026.1 135.14,53.23 PR7064.2
  BOTTOM w0.203: v1(134.5,52.95) 134.48,52.92 134.48,52.67 134.88,52.27 PU7000.13
3602_VDIO: length 2.3
  BOTTOM w0.102: PR7019.2 139.3,59.28 139.3,58.23 139.35,58.19 PU7000.32
3602_VIN: length 4.6
  TOP w0.203: PC7000.2 135,51.45 134.78,51.45 134.5,51.17 v1(134.4,51.17) 132.47,51.17 v1(132.35,51.04) 132.23,50.93 PR7000.1
3602_VREF: length 54.2
  TOP w0.203: PR7024.2 141.79,49.39 142.21,48.97 142.21,47.7 v2(142.3,47.61) ; v2(131.89,55.99) 131.75,56.13 PR7010.1 131.18,56.81 v1(131.39,57.02) 131.61,57.24 131.61,59.24 131.63,59.27 131.63,59.64 v2(131.61,59.67) ; v1(141.77,57.19) 141.77,57.69 PR7005.1
  TOP w0.254: v1(143.65,55.18) 143.65,55.78 PR7008.1 ; PR7023.2 145.6,49.29 v2(146.06,49.74) 145.55,50.25 PR7022.2
  IN1 w0.203: v1(141.77,57.19) 141.74,57.19 141.67,57.26 137.98,57.26 137.6,56.88 137.6,55.99 137.32,55.71 135.49,55.71 135.22,55.43 132.83,55.43 132.27,55.99 v2(131.89,55.99)
  IN2 w0.254: v1(141.77,57.19) 141.79,57.16 142.05,57.16 143.65,55.56 v1(143.65,55.18) 143.65,52.16 v2(146.06,49.74) 146.06,49.57 144.11,47.61 v2(142.3,47.61) 141.9,47.61 140.45,46.16 136.87,46.16 136,45.3 v1(136,45.12)
  BOTTOM w0.203: v2(131.61,59.67) 131.69,59.67 132.5,60.48 132.5,61.05 134.05,62.6 134.55,62.6 135.95,61.2 PR7004.1 ; PU7000.42 143.26,54.67
  BOTTOM w0.254: v1(136,45.12) 136.26,45.38 PR7009.1 ; 143.26,54.67 143.65,55.05 v1(143.65,55.18) ; v2(146.06,49.74) 145.58,49.26 PR7006.2 145.23,50.23 PR7013.1
3602_VRHOT: length 4.9
  BOTTOM w0.102: PU7000.31 138.95,58.84 137.25,60.54 PR7011.1 137.55,60.97 137.68,61.1 PR7012.1
5213EN_1.8V: length 3.2
  TOP w0.102: PU3004.7 39.49,29.25 39.43,29.2 39.43,28.43 38.95,27.95 PC581.1 PR566.1
5213FB_1.8V: length 5.2
  TOP w0.254: PC574.2 PR568.2 PR567.2 40.98,26.44 v1(40.98,27.34) 40.98,27.72 42.01,28.75 PU3004.1
5213FB_1.8V_S: length 4.7
  TOP w0.254: PR569.1 36.26,26.99 v1(36.74,26.5) 36.97,26.28 37.8,26.28 38.54,25.53 PC574.1 PR568.1
5213LX_1.8V:
  vias: v1(39.74,31.71)
5213PG_1.8V: length 2.7
  TOP w0.102: PR9256.2 42.91,27.9 v1(42.94,27.93) 43.01,28 43.01,29.09 42.86,29.25 PU3004.2
5416_VCC: length 5.6
  TOP w0.198: PU26.7 62.29,121.9 62.09,122.1
  TOP w0.254: PC268.2 62.09,124.91 62.09,122.1
  TOP w0.508: PR256.1 62.51,125.46 PC268.2
5447_CC1_CON: length 25.5
  TOP w0.102: C691.2 10.98,18.87 11.36,19.26 v1(11.36,19.32)
  TOP w0.508: C691.2 10.98,18.27 10.55,17.84 v1(10.48,17.84)
  IN1 w0.508: v2(13.52,12.05) 13.65,11.93 16.83,11.93 19.24,14.34 21.14,14.34 21.62,13.86 v1(22.49,13.86)
  IN3 w0.508: v1(10.48,17.84) 10.48,15.73 10.09,15.35 9.95,15.35 9.46,14.86 ; 9.46,14.86 v1(9.03,14.86) ; 9.46,14.86 9.71,14.61 9.71,14.08 10.09,13.7 11.82,13.7 13.47,12.05 v2(13.52,12.05)
  BOTTOM w0.178: CN10.A5 7.48,15.15 7.73,15.4 7.94,15.4
  BOTTOM w0.203: v1(9.03,14.86) 8.86,14.86 8.32,15.4 7.94,15.4 ; U6503.11 23.04,14.36 22.55,13.86 v1(22.49,13.86)
  BOTTOM w0.508: D16.2 10.48,17.88 v1(10.48,17.84)
5447_CC2_CON: length 27.3
  IN1 w0.508: v1(22.49,15.15) 17.89,15.15 15.56,12.81 12.71,12.81 11.75,13.78 11.75,14.21 v1(11.49,14.46)
  IN2 w0.102: CN10.B5 5.66,17.18 5.66,17.42 6.07,17.83
  IN2 w0.127: 6.07,17.83 6.67,18.43 9.03,18.43 9.23,18.63 9.33,18.63 v2(9.36,18.6)
  IN3 w0.508: v1(11.49,14.46) 11.49,17.77 10.73,18.53 9.38,18.53 9.36,18.55 v2(9.36,18.6)
  BOTTOM w0.203: U6503.13 22.7,15.36 v1(22.49,15.15)
  BOTTOM w0.254: v1(11.23,12.99) D17.2
  BOTTOM w0.508: C692.2 11.22,13.84 D17.2 11.23,14.2 v1(11.49,14.46)
8813BOOT1:
  vias: v1(76.52,113.47)
8813BOOT2:
  vias: v1(76.57,108.34)
8813EN: length 6.6
  TOP w0.254: PR9012.1 74.99,116.94 74.99,116.57 75.49,116.07 PD9000.2 74.87,115.04 PR9085.2 ; PR9085.2 74.23,114.54 74.1,114.41 v1(74.1,114.24) 74.23,114.11 PU9000.3 ; PR9085.2 PC9013.1
8813ILIM: length 4.3
  TOP w0.254: v1(71.55,108.61) 71.51,108.64 71.51,109.41 71.63,109.53 PU9000.12
  BOTTOM w0.254: v1(71.55,108.61) 71.68,108.47 72.68,108.47 72.92,108.23 PC9030.1 74.31,108.23 PR9032.2
8813ISEN1: length 4.6
  TOP w0.203: PU9000.15 73.73,107.99 v1(73.47,107.73) 73.75,107.45 73.75,106.71 73.16,106.12 PR9013.2 73.01,106.12 72.08,107.06 PC9014.2
8813ISEN2: length 3
  TOP w0.203: PU9000.14 73.23,108.39 72.99,108.16 72.22,108.16 v1(71.92,107.86) 71.51,107.86 71.15,107.5 PR9025.2
8813LGAT1: length 7.9
  TOP w0.508: 77.79,112 78.04,112 78.72,112.68 78.72,112.84 79.56,113.68 v1(79.56,115.66) 79.56,116.27 v3(79.65,116.36)
  BOTTOM w0.508: 77.23,116.93 79.08,116.93 v3(79.65,116.36)
  vias: v1(76.08,116.22)
8813LGAT2: length 7.9
  TOP w0.508: 77.15,109.84 77.15,109.84 v1(82.15,109.84) 83.55,109.84 v3(83.68,109.97)
  BOTTOM w0.508: PQ9001.8 v3(83.68,109.97)
8813PG: length 3
  TOP w0.203: PU9000.16 74.23,107.96 74.13,107.86 PR9008.2 74.13,106.49 73.87,106.23 73.87,105.91 PR9009.2
8813PHASE1: length 6.8
  TOP w0.635: PC9008.1 77.85,112.95 78.8,113.91 v1(78.8,114.31) 78.8,116.78 79.23,117.21 v3(79.23,117.77) 79.03,117.97 PR9004.2
8813PHASE2: length 11
  TOP w0.635: v3(84.64,109.04) PR9019.2 83.21,109.08 v1(80.28,109.08) 79.51,109.08 79.47,109.04 PC9020.1
  BOTTOM w0.508: v3(84.64,109.04) 84.75,109.15 84.75,110.37 83.63,111.49 82.38,111.49
  vias: v1(79.69,112.23)
8813PSI: length 7.2
  TOP w0.102: v1(71.49,117.28) 71.31,117.11 PR9018.2
  TOP w0.254: PR9016.2 70.54,116.25 70.64,116.15 PR9018.2 71.45,116.15 72.17,115.43 72.21,115.43 PR9022.2 72.71,114.94 72.71,114.54 73.1,114.15 73.44,114.15 73.73,113.87 PU9000.4
8813PVCC: length 7
  TOP w0.102: v1(79.94,111.01) 79.66,110.72 PC9000.1
  TOP w0.254: v1(77.51,110.49) 77,110.49 76.94,110.55 76.65,110.55 76.62,110.53 PU9000.21
  TOP w0.381: v1(77.51,110.49) 78.83,110.49 PC9000.1
  BOTTOM w0.508: v1(77.51,110.49) 77.27,110.73 76.93,110.73 76.55,110.35 76.55,109.63 76.86,109.32 PR9001.2
8813REFADJ: length 2.3
  TOP w0.254: PU9000.6 72.23,112.76 72.15,112.84 v1(72.02,112.84)
  BOTTOM w0.254: PR9023.2 72.67,113.05 v1(72.66,113.07) 72.43,112.84 v1(72.02,112.84)
8813REFIN: length 5.8
  TOP w0.254: PU9000.7 71.66,112.03 71.39,112.3 v1(71.39,112.81)
  BOTTOM w0.102: v1(69.07,113.3) 69.12,113.34 PR9027.1
  BOTTOM w0.254: PR9024.2 72.43,114.01 71.86,113.44 PC9026.1 ; PC9026.1 71.56,113.27 71.39,113.09 v1(71.39,112.81) ; PC9026.1 70.34,113.44 PR9027.1
8813RGN: length 3.5
  TOP w0.203: PC9029.1 69.62,111.35 69.76,111.49 PR9029.1
  TOP w0.254: PU9000.10 71.38,110.53 71.07,110.84 PC9028.2 70.18,110.84 70.09,110.93 PC9029.1
8813TON: length 5.5
  TOP w0.102: v1(69.4,114.62) 69.31,114.52 PR9002.1
  TOP w0.254: PU9000.9 71.51,111.03 70.85,111.7 70.44,111.7 70.14,111.99 70.14,113.37 69.71,113.8 PR9002.1
8813UGATE1: length 0.5
  TOP w0.559: 74.84,113.93 v3(74.84,114.39)
  vias: v1(74.26,114.92)
8813UGATE1_1:
  vias: v1(70.22,116.75)
8813UGATE2:
  vias: v1(76.62,106.23)
8813UGATE2_1: length 6.4
  TOP w0.508: v3(84.34,104.38) 84.31,104.41 84.19,104.41 83.75,104.84 v1(83.75,105.45) 83.3,105.9 PR9014.2
9336ADJ: length 6.1
  BOTTOM w0.254: PU9003.5 75.88,98.16 75.45,98.59 75.45,99.1 75.12,99.43 74.48,99.43 73.71,100.2 PR9082.2 72.85,100.2 v1(72.48,100.57) 72.48,100.82 72.68,101.03 PR9081.2
9336DRV: length 5.8
  BOTTOM w0.254: PU9003.6 74.93,97.08 74.36,96.51 PR9080.1 73.86,96.26 73.09,95.49 PD9001.1 72.21,94.97 72.16,95.02 v1(71.92,95.02) PQ9008.4
24780_ACDET: length 6.2
  TOP w0.102: PQ17.3 137.26,35.43 v2(136.82,34.99)
  BOTTOM w0.102: PR211.2 136.64,33.62 136.16,34.1 136.16,34.78 136.36,34.99 v2(136.82,34.99)
  BOTTOM w0.178: 135.02,32.55 PU1.6
  BOTTOM w0.203: 135.02,32.55 135.09,32.62 135.09,32.64 135.67,33.22 PR31.2 PR211.2
24780_ACDRV: length 1.9
  BOTTOM w0.178: 134.22,32.6 PU1.4
  BOTTOM w0.203: 134.22,32.6 134.16,32.66 134.16,33.06 134.59,33.48 PR29.2
24780_ACN: length 149.7
  TOP w0.203: PC35.1 132.22,32.93 131.62,33.52 v2(131.62,34) ; PR2.2 52.26,113.27 52.64,112.89 54.54,112.89 55.35,112.09 v2(55.35,111.25)
  IN3 w0.203: v2(131.62,34) 131.62,33.79 131.24,33.41 126.91,33.41 123.3,37.03 122.53,37.03 120.61,38.95 120.61,43.65 119.44,44.82 118.76,44.82 116.8,46.77 115.83,46.77 113.17,49.44 113.17,52.12 115.94,54.89 115.94,61.12 116.39,61.58 116.39,63.94 114.17,66.17 114.17,72.38 113.09,73.45 arc(113.05,73.51) 113.04,73.58 113.04,74.97 arc(113.04,74.97) 113.04,74.97 112.81,75.2 109.03,75.2 108.6,75.63 108.6,76.62 107.7,77.51 107.7,80.61 107.38,80.94 107.38,83.12 104.79,85.71 104.79,88.87 103.4,90.26 102.53,90.26 102.11,90.68 101.41,90.68 100.82,91.27 99.99,91.27 99.6,91.65 99.6,92.29 99.15,92.75 98.82,92.75 97.93,93.64 97.54,93.64 95.76,95.41 95.76,96.85 94.79,97.83 94.55,97.83 94.11,98.27 93.49,98.27 93.07,98.69 93.07,99.93 91.68,101.33 91.68,103.62 88.33,106.97 83.37,106.97 82.66,106.26 79.54,106.26 79.13,106.67 79.13,107.45 78.34,108.24 74.05,108.24 73.01,107.2 72.48,107.2 71.94,107.73 69.73,107.73 69.45,108.01 68.9,108.01 68.36,108.55 68.36,108.95 66.28,111.03 55.56,111.03 v2(55.35,111.25)
  BOTTOM w0.178: 132.88,32.5 133.02,32.35 PU1.1
  BOTTOM w0.203: v2(131.62,34) 131.62,33.97 131.59,33.93 131.59,33.35 PC25.2 132.29,32.65 132.73,32.65 132.88,32.5
24780_ACP: length 151.6
  TOP w0.203: v2(54.85,110.83) 54.85,111.95 54.29,112.51 52.54,112.51 PR1.2 ; PC36.2 133.56,32.73 133.26,33.03 132.75,33.03 132.18,33.6 132.18,33.97 v2(132.21,34)
  IN3 w0.203: v2(54.85,110.83) 54.95,110.73 66.15,110.73 68.06,108.83 68.06,108.39 68.77,107.68 69.35,107.68 69.61,107.43 71.74,107.43 72.27,106.89 73.14,106.89 74.18,107.94 78.19,107.94 78.83,107.3 78.83,106.54 79.41,105.95 82.79,105.95 83.5,106.67 88.2,106.67 91.37,103.5 91.37,101.2 92.77,99.81 92.77,98.56 93.36,97.96 93.98,97.96 94.42,97.52 94.66,97.52 95.46,96.72 95.46,95.29 97.41,93.33 97.8,93.33 98.69,92.44 99.02,92.44 99.3,92.16 99.3,91.53 99.86,90.97 100.69,90.97 101.29,90.37 101.98,90.37 102.4,89.95 103.27,89.95 104.46,88.77 104.46,85.61 107.07,82.99 107.07,80.81 107.4,80.48 107.4,77.39 108.29,76.49 108.29,75.5 108.9,74.89 112.58,74.89 112.71,74.76 arc(112.71,74.75) 112.71,74.75 112.71,73.41 arc(112.71,73.4) 112.71,73.4 113.87,72.25 113.87,66.04 116.09,63.82 116.09,61.71 115.63,61.25 115.63,55.02 112.86,52.25 112.86,49.31 115.71,46.47 116.67,46.47 118.71,44.44 119.24,44.44 120.31,43.37 120.31,38.72 122.3,36.72 123.09,36.72 126.71,33.11 131.76,33.11 132.21,33.55 v2(132.21,34)
  BOTTOM w0.178: PU1.2 133.42,32.51
  BOTTOM w0.203: 133.42,32.51 132.73,33.21 PC25.1 132.18,33.53 132.18,33.97 v2(132.21,34)
24780_BATDRV: length 3.9
  TOP w0.508: v1(133.08,26.5) 133.03,26.45 v1(132.45,26.45) 132.18,26.45 PR4.2
  BOTTOM w0.178: PU1.18 134.22,27.4
  BOTTOM w0.203: v1(133.08,26.5) 133.33,26.5 134.22,27.4
24780_BATSRC: length 4.8
  TOP w0.508: v1(133.99,26.48) 133.15,25.64 131.98,25.64 PR7.2
  BOTTOM w0.178: PU1.17 134.62,27.33
  BOTTOM w0.203: 134.62,27.33 133.99,26.7 v1(133.99,26.48)
24780_BM#: length 3.6
  BOTTOM w0.178: PR9.1 136.91,27.55 136.84,27.62 135.96,27.62 135.52,27.19 135.52,27.09 v1(135.27,26.83) 135.02,27.08 PU1.16
24780_CMPIN: length 3.2
  TOP w0.178: v2(137.55,28.74) 137.73,28.92 137.73,29.27 v1(137.65,29.35) 137.43,29.35 137.02,29.75 PR207.1
  BOTTOM w0.178: v2(137.55,28.74) 137.53,28.74 137.5,28.76 137.19,28.76 136.85,29.11 PU1.13
24780_CMPOUT: length 3.5
  BOTTOM w0.102: PR15.1 138.53,27.55 138.97,28 v1(139.08,28)
  BOTTOM w0.178: PR15.1 137.61,28.18 137.32,28.18 136.8,28.71 PU1.14
24780_CMSRC: length 1.5
  BOTTOM w0.178: 133.82,32.72 PU1.3
  BOTTOM w0.203: PR28.2 133.74,32.8 133.82,32.72
24780_DH: length 10.4
  IN3 w0.508: v1(131.23,30.36) 129.25,30.36 128.69,30.92 123.22,30.92 122.66,31.49 v1(122.66,31.9)
  BOTTOM w0.508: PQ30.4 122.9,31.45 122.66,31.7 v1(122.66,31.9)
24780_DL: length 5.7
  IN3 w0.508: v1(131.28,28.82) 131.25,28.79 131.25,28.76 130.67,28.18 128.1,28.18 127.89,27.97 126.73,27.97 126.71,27.99 v1(126.71,28.02)
  BOTTOM w0.508: v1(126.71,28.02) 126.71,27.99 126.68,27.97 PQ29.4
24780_ILIM: length 4.4
  TOP w0.127: PR204.1 134.14,27.29 134.12,27.31 PC8.2 PR206.1 132.7,27.31 132.33,27.68 132.33,27.69 v1(131.89,28.13)
  BOTTOM w0.178: v1(131.89,28.13) 132.35,28.13 132.57,27.91 PU1.21
24780_LX: length 5.7
  BOTTOM w0.508: 130.38,31.36 129.61,32.13 126.54,32.13 125.87,31.45 PQ30.1
24780_SRN: length 12.5
  BOTTOM w0.203: PR6.2 130.87,26.71 130.67,26.91 130.67,27.37 130.41,27.63 PC4.2 129.8,27.63 PC3.1 128.83,27.04 128.53,27.04 127.72,26.22 126.02,26.22 124.9,25.11 121.96,25.11 121.44,24.59 120.87,24.59 PR208.1
24780_SRP: length 12.9
  BOTTOM w0.203: PR5.2 131,28.02 v1(130.8,28.23) 130.09,28.23 PC6.2 129.74,28.35 PC3.2 128.66,27.63 127.58,26.55 125.88,26.55 124.77,25.44 121.79,25.44 121.27,24.92 120.87,24.92 PR210.1
24780_VCC: length 2.6
  TOP w0.406: PR16.1 129.86,30.47 131.2,31.81 v1(131.53,31.81)
25810_AUO#: length 2.9
  BOTTOM w0.203: R6508.2 23.86,19.01 v1(23.94,18.93) 23.94,18.91 23.95,18.9 U6503.17
25810_DBG#: length 2.7
  BOTTOM w0.102: v1(22.9,18.2) 22.29,18.2 22.09,18 R6510.2
  BOTTOM w0.203: R6510.2 22.42,17.38 22.67,17.38 23.2,16.86 U6503.16
25810_FAULT#: length 2
  BOTTOM w0.203: U6503.1 26.2,16.86 v1(26.94,17.59) 26.98,17.63 R6504.2
25810_LD_DET#: length 3.2
  BOTTOM w0.203: U6503.20 25.45,18.08 25.87,18.5 v1(26,18.5) 26.1,18.5 26.5,18.91 27.02,18.91 R6505.2
25810_POL#: length 8.8
  TOP w0.102: v2(20.74,19.65) 21.07,19.65 21.8,18.91 24.7,18.91 v1(24.95,19.16)
  BOTTOM w0.102: R9042.2 R9041.2 25.16,19.37 v1(24.95,19.16) 24.45,18.66 U6503.18 ; R25280.1 20.59,19.8 v2(20.74,19.65)
25810_REF: length 1.5
  BOTTOM w0.102: U6503.10 23.28,13.03 R6517.1
25810_REF_RTN: length 2.6
  BOTTOM w0.102: U6503.9 24.45,13.27 24.14,12.97 v1(24.14,12.46) 24.14,12.41 23.47,11.74 R6517.2
25810_UFP#: length 75.4
  TOP w0.102: R25337.1 14.01,4.3 v1(14.26,4.05)
  TOP w0.254: Q6519.2 21.22,12.91 v1(21.27,12.86) ; v1(7.05,23.1) 7.75,22.4 7.75,21.78 8.72,20.81 11.06,20.81 12.48,19.39 15.86,19.39 17.11,18.15 18.88,18.15 19.31,18.58 23.46,18.58 23.89,18.15 24.62,18.15 v1(24.95,18.47) ; v1(12.63,5.19) 12.89,5.19 13.41,4.68 R25337.1
  IN1 w0.254: v1(21.27,12.86) 20.84,12.43 18.78,12.43 17.8,11.45 13.25,11.45 12.63,10.83 v1(12.63,5.19)
  IN2 w0.254: v1(7.05,23.1) 7.55,23.1 11.11,19.54 16.19,19.54 16.57,19.16 16.57,17.77 16.17,17.36 16.17,15.38 18.35,13.19 18.35,7.81 17.25,6.71 17.25,5.69 15.86,4.3 13.78,4.3 12.89,5.19 v1(12.63,5.19)
  BOTTOM w0.203: U6503.19 v1(24.95,18.47) 25.25,18.47 26.19,19.41 R6506.2
  BOTTOM w0.254: v1(7.05,23.1) Q6505.3
+1.03_GFX: length 37.1
  TOP w0.305: C366.1 109.79,108.83 v2(109.54,109.08) ; v2(112.14,110.72) 112.06,110.72 111.53,110.19 C354.1
  IN1 w1.016: 95.18,124.19 95.18,122.57 91.98,119.37 91.56,119.37 89.37,117.18 87.41,117.18 86.85,117.74 86.85,118.27 85,120.13 81.98,120.13 80.58,118.73 72.2,118.73 71.44,117.97
  BOTTOM w0.305: v2(109.54,109.08) 111.24,109.08 U8.AA22 ; U8.AE27 115.73,112.87 v2(115.34,113.26) 114.93,112.85 U8.AE26 ; U8.AB23 v2(112.14,110.72) ; U8.AC24 113.33,111.25 v2(112.96,111.62) ; U8.AD25 v2(114.54,112.44)
  vias: v1(71.8,105.32) v1(72.43,105.32) v1(118.38,123.07) v1(118.4,119.88) v1(118.4,119.25) v1(118.53,122.21)
+601_VCC:
  vias: v1(204.07,18.45) v1(207.5,11.92) v1(207.76,12.56) v1(214.31,17.64) v1(214.69,17.11)
+AZA_VDD: length 21.9
  TOP w0.203: R478.2 210.88,27.64 v1(210.42,27.19)
  IN1 w0.508: v1(207.4,35.67) 207.38,35.67 206.49,34.78 206.49,33.54 207.2,32.83 207.2,31.86 208.6,30.47 209.84,30.47 210.22,30.08 210.22,28.69 209.82,28.28 209.82,26.94 210.2,26.55 v1(210.4,26.55)
  BOTTOM w0.203: 207.36,36.4 207.2,36.23 207,36.23 206.86,36.09 U20.36 ; U20.1 207.81,29.52 208.62,28.71 208.62,28.3 C580.1
  BOTTOM w0.381: v1(207.4,35.67) 208.09,36.36 C565.1 207.62,36.65 207.36,36.4
  BOTTOM w0.508: v1(210.4,26.55) 210.02,26.55 v1(209.59,26.99) 209.13,27.44 C580.1
+FB_PLLAVDD: length 79.8
  TOP w0.254: v1(90.33,103.97) 90.1,103.75 v1(90.1,103.36) ; v2(107.31,97.59) 106.94,97.22 C455.2
  TOP w0.305: v2(112.11,98.37) 112.02,98.28 C453.2
  TOP w0.381: C454.2 110.42,102.72 v2(110.42,103.24)
  TOP w0.508: C456.1 L6.2 90.24,101.95 L5.2 90.1,102.21 v1(90.1,103.36)
  IN1 w0.508: v1(93.36,118.48) 93.36,117.79 92.89,117.33 91.52,117.33 89.44,115.26 89.44,106.13 88.83,105.52 88.83,103.75 89.22,103.36 v1(90.1,103.36)
  IN2 w0.508: 109.56,98.77 109.56,102.37 v2(110.42,103.24) 110.17,103.49 110.17,106.54 108.95,107.76 108.95,108.39 108.9,108.44 108.9,112.64 110.27,114.01 110.68,114.01 113.65,116.98 113.65,122.64 112.18,124.12 107.86,124.12 103.36,119.62 98.41,119.62 98.03,120 94.88,120 v1(93.36,118.48)
  BOTTOM w0.305: U8.P22 111.58,103.73 111.22,103.36 110.55,103.36 v2(110.42,103.24) ; U8.H22 111.71,98.77 v2(112.11,98.37)
  BOTTOM w0.381: v2(107.31,97.59) 107.26,97.54 107.23,97.54 106.76,97.07 U8.F16
+G_SEN_PW: length 38.7
  TOP w0.203: R25355.1 63.82,21.2 64.07,20.94 64.7,20.94 64.83,21.07 ; U32.1 C6603.1 54.39,20.21 v1(54.8,19.8)
  TOP w0.305: U32.8 60.68,22.46 61.5,23.28 62.04,23.28 62.47,22.85 62.98,22.85 ; U32.14 55.06,22.46 54.42,23.1 54.05,23.1 C6608.1
  TOP w0.356: 62.98,22.85 64.35,22.85 65.23,21.97 65.23,21.46 64.83,21.07
  TOP w0.508: v1(53.4,23.74) 53.43,23.74 53.8,24.11 R582.2 C6608.1 ; 64.83,21.07 65.26,20.64 65.26,19.47 64.86,19.06 64.86,18.07 62.27,15.48 v1(61.28,15.48) 59.08,15.48 57.3,17.26 v1(56.98,17.26)
  IN1 w0.508: v1(56.98,17.26) 56.98,17.41 54.8,19.59 v1(54.8,19.8) 54.8,21.83 53.4,23.22 v1(53.4,23.74)
+SMDDR_VREF_DIMM: length 1.6
  BOTTOM w0.254: JDIM1.164 49.09,53.46 48.96,53.33 v1(48.96,53.05)
+SMDDR_VREF_DQ1_M1: length 126.5
  TOP w0.356: U7.M1 37.47,80.45 ; U4.M1 37.47,46.44 ; 40.57,93.59 38.5,93.59 U6.M1 ; U5.M1 37.47,59.59
  TOP w0.508: 40.57,93.59 41.34,93.59 42.1,94.35 v1(42.15,94.35) 43.75,94.35 43.98,94.58 43.98,96.48 44.39,96.9 R261.2 44.38,97.12 44.38,98.28 45.03,98.93 C314.1 C323.2 R264.1 C336.2 49.45,98.93 R263.2 49.98,98.91 50,98.89 R262.2 ; 37.47,80.45 39.04,82.02 C337.2 C320.2 38.04,82.54 37.4,81.9 35.62,81.9 35.24,81.52 31.94,81.52 31.61,81.19 29.83,81.19 29.14,80.5 29.14,78.09 v1(29.53,77.71) 28.89,77.08 28.89,74.28 28.26,73.65 28.26,69.71 30.37,67.6 30.37,65.47 29.38,64.48 29.38,63.97 ; 37.47,59.59 37.52,59.63 C326.2 C317.2 36.52,61.59 37.27,62.34 37.27,63.61 36.41,64.48 33.51,64.48 33.01,63.97 29.38,63.97 ; 29.38,63.97 28.41,63 28.41,54.49 28.31,54.39 v1(28.31,53.55) 28.31,47.23 28.75,46.79 32.49,46.79 32.83,47.13 35.15,47.13 35.88,47.87 C338.2 C312.1 36.88,47.37 37.47,46.78 37.47,46.44
  IN1 w0.508: v1(29.53,77.71) 29.3,77.94 29.3,80.29 29.79,80.79 29.79,91.39 32.07,93.67 32.07,94.6 32.57,95.11 41.39,95.11 v1(42.15,94.35)
+TYPEC_VBUS: length 1.5
  TOP w0.508: C676.2 10.22,14.39 v1(10.35,14.51) ; v2(9.28,19.37) 9.6,19.69 C675.2
  vias: v1(13.14,13.45) v1(13.14,12.81) v1(13.47,14.21) v1(13.78,13.45) v1(13.93,9.91) v1(14.11,14.21) v1(14.08,12.89) v1(14.41,13.45) v1(14.36,9.39) v1(14.74,14.21)
+TYPEC_VBUS_C:
  vias: v1(16.95,16.95) v1(17.46,16.8) v1(18.1,16.79) v1(18.07,16.15) v1(18.74,16.79) v1(18.71,16.15) v1(19.34,16.17) v1(19.39,16.8)
+USBPWR0: length 1.5
  TOP w0.203: v1(21.55,54.65) 21.19,54.65 20.78,54.23 U16.2
  vias: v1(18.1,51.68) v1(18.1,50.91) v1(18.6,52.06) v1(18.6,51.29) v1(19.16,51.7) v1(20.2,51.17)
+USBPWR1: length 8.5
  TOP w0.203: U17.2 v1(20.64,33.78)
  IN3 w0.508: v1(20.64,33.78) 20.06,34.36 20.06,36.54 18.83,37.77 18.83,39 v1(17.71,40.12)
  vias: v1(20.31,47.26)
+VGPU_CORE: length 69.7
  TOP w0.356: C407.2 103.96,100.6 v2(103.55,100.2) ; v2(105.34,100.19) 105.21,100.32 C369.2 ; C372.2 107.77,100.32 v2(107.5,100.06)
  TOP w0.381: v2(70.93,108.76) 70.93,108.54 PR9026.1 ; v2(101.23,100.23) 101.28,100.18 C406.2
  IN3 w0.381: v2(70.93,108.76) 70.95,108.79 70.95,109.49 72.04,110.57 72.04,111.56 72.99,112.51 76.9,112.51 78.67,114.29 79.06,114.29 81.47,116.7 v3(81.47,117.08)
  BOTTOM w0.254: U8.V10 101.18,107.73 v2(101.51,108.06) ; v2(101.23,100.23) 101.25,100.23 101.29,100.27 101.31,100.27 101.77,100.73 U8.L11 102.03,100.81 102.42,101.21 v2(102.47,101.21) 102.47,101.26 102.95,101.73 U8.M12 103.03,101.91 v2(103.47,102.35) 103.85,102.73 U8.N13 104.03,102.73 104.53,103.23 v2(104.58,103.23) 104.58,103.28 U8.P14 105.03,103.73 105.55,104.25 v2(105.78,104.25) 105.78,104.48 106.03,104.73 U8.R15 106.36,105.06 v2(106.36,105.27) 106.65,105.27 107.03,105.65 U8.T16 ; v2(106.59,101.35) 106.59,101.43 106.89,101.73 U8.M16
  BOTTOM w0.305: v2(108.37,108.16) 108.62,108.16 109.03,107.76 U8.V18 ; U8.K16 107.17,99.73 v2(107.5,100.06) 107.5,100.2 U8.L17 v2(108.64,101.34) U8.M18 ; U8.V12 v2(102.53,107.23) U8.U11 101.76,106.73 v2(101.3,106.26) 101.3,106 U8.T10 100.11,105.73 v2(100.04,105.8) ; U8.P10 101.03,104.03 v2(101.23,104.23) 101.73,104.73 U8.R11 102.03,104.83 v2(102.43,105.23) 102.53,105.23 U8.T12 103.14,105.73 103.44,106.03 v2(103.44,106.28) 103.69,106.29 104.03,106.62 U8.U13 v2(104.53,107.23) U8.V14 105.03,107.74 v2(104.58,108.19) ; v2(108.39,99.3) 108.82,99.73 U8.K18 ; v2(107.12,108.44) 107.03,108.35 U8.V16 v2(106.6,107.3) U8.U15 105.78,106.48 v2(105.78,106.23) 105.27,105.73 U8.T14 104.63,105.33 v2(104.63,105.13) 104.43,105.13 U8.R13 103.49,104.19 v2(103.49,104.18) 103.48,104.18 U8.P12 103.03,103.73 102.53,103.23 v2(102.48,103.23) 102.48,103.18 102.03,102.73 U8.N11 101.74,102.73 v2(101.26,102.25) 101.03,102.02 U8.M10 ; U8.K14 105.03,99.87 v2(105.34,100.19) 105.89,100.73 U8.L15 106.59,101.29 v2(106.59,101.35) ; U8.P18 108.82,103.53 v2(108.82,103.24) 108.54,103.24 U8.N17 108.03,102.62 107.66,102.25 v2(107.61,102.25) 107.09,101.73 U8.M16 ; U8.K12 103.06,99.73 103.53,100.2 v2(103.55,100.2) 103.55,100.23 104.03,100.7 U8.L13 104.59,101.29 v2(104.59,101.43) 104.89,101.73 U8.M14 105.52,102.22 v2(105.78,102.22) 105.78,102.48 U8.N15 106.49,103.19 v2(106.49,103.24) 106.54,103.24 107.03,103.73 U8.P16 107.36,104.06 v2(107.56,104.06) 107.56,104.26 U8.R17 108.27,104.97 108.27,104.97 108.52,105.23 v2(108.82,105.23) 108.82,105.53 U8.T18 ; v2(107.55,105.98) 108.03,106.46 U8.U17
  BOTTOM w0.356: U8.K10 101.03,100.02 v2(101.23,100.23)
  vias: v1(86.55,118.58) v1(100.04,105.09) v1(105.22,119.37) v1(105.22,118.73) v1(105.22,118.1) v1(105.5,116.06) v1(105.5,115.3) v1(106.26,116.06) v1(106.26,115.3) v1(106.89,116.06) v1(106.89,115.3) v1(107.53,116.06) v1(107.53,115.3) v1(108.29,116.06) v1(108.27,115.35) v1(108.93,116.06) v1(108.9,115.35) v1(111.11,122.8) v1(111.11,122.03) v1(111.75,122.8) v1(111.75,122.03) v1(114.69,119.7) v3(81.34,117.84) v3(82.13,118.3) v3(82.08,117.56) v3(82.69,118.86) v3(82.79,117.16) v3(82.92,117.89) v3(83.12,115.68) v3(83.25,114.92) v3(83.42,118.73) v3(83.53,117.18) v3(83.53,114.24) v3(83.55,113.5) v3(83.55,112.76) v3(83.65,117.92) v3(83.88,115.68) v3(84.01,114.92) v3(84.26,117.18) v3(84.26,114.21) v3(84.29,113.47) v3(84.29,112.74) v3(84.29,112) v3(84.39,117.92) v3(84.64,115.68) v3(84.77,114.92) v3(85,117.18) v3(85,114.21) v3(85.02,113.47) v3(85.02,112.74) v3(85.02,112) v3(85.13,117.92) v3(85.41,115.68) v3(85.38,111.34) v3(85.53,114.92) v3(85.74,114.21) v3(85.76,117.18) v3(85.76,113.47) v3(85.76,112.74) v3(85.76,112) v3(85.91,117.92) v3(86.04,110.48) v3(86.12,111.24) v3(86.17,115.68) v3(86.29,114.92) v3(86.5,114.16) v3(86.5,113.4) v3(86.5,112.64) v3(86.5,111.87) v3(86.8,110.93) v3(86.8,110.2) v3(86.93,116.17) v3(86.93,115.4) v3(87.54,110.2) v3(87.56,110.93) v3(87.67,116.17) v3(87.67,115.4) v3(88.33,110.93) v3(88.33,110.2) v3(88.4,116.17) v3(88.4,115.4)
AC_PRESENT_EC: length 171.2
  TOP w0.102: v2(196.12,25.32) 196.12,24.28 196.44,23.96 197.21,23.2 198,23.2 198.18,23.38 U37.84
  IN2 w0.089: v2(196.12,25.32) 196.1,25.35 195.35,25.35 194.19,26.5 193.1,26.5 192.4,25.8 191.6,25.8 191.32,26.08 191.32,26.41 189.83,27.91 188.93,27.91 188.3,27.27 187.05,27.27 186.82,27.5 185.99,27.5 184.63,28.86 184.05,28.86 183.25,28.05 180.81,28.05 179.31,29.55 177.64,29.55 177.45,29.35 173.98,29.35 173.23,30.1 164.53,30.1 163.93,30.7 161.67,30.7 161.14,31.23 156.27,31.23 155.77,31.74 147.18,31.74 146.33,32.58 145.06,32.58 144.43,33.2 143.76,33.2 143.19,33.77 140.96,33.77 140.82,33.91 136.52,33.91 136.41,34.02 133.72,34.02 132.89,34.85 128.94,34.85 128.66,34.57 128.66,34.04 128.39,33.77 127.69,33.77 127.15,33.23 124.82,33.23 122.9,31.31 118.25,31.31 118.06,31.12 109.92,31.12 109.29,30.48 105.97,30.48 105.7,30.75 103.77,30.75 103.17,30.14 102.32,30.14 101.76,30.7 97.73,30.7 97.54,30.89 94.62,30.89 94.15,31.36 93.52,31.36 92.82,32.07 88.23,32.07 87.95,31.79 84.64,31.79 84.46,31.61 81.36,31.61 81.19,31.43 78.86,31.43 78.17,32.12 73.01,32.12 72.78,32.35 70.39,32.35 70.19,32.14 68.62,32.14 68.41,32.35 67.66,32.35 66.29,30.97 64.2,30.97 v2(64.02,31.16)
  BOTTOM w0.079: U1.BU35 75.79,44.81 75.26,44.81 75.19,44.84 74.93,44.84 74.86,44.8 73.99,44.8 70.83,41.64
  BOTTOM w0.102: 70.83,41.64 70.67,41.64 68.9,39.86 68.77,39.86 68.03,39.13 66.46,39.13 65.95,39.64 65.95,40.02 65.82,40.14 64.87,40.14 R35.1 64.36,39.72 63.62,38.98 63.62,32.06 v1(63.84,31.84) 63.84,31.34 v2(64.02,31.16)
ACCEL_INT2: length 183.4
  TOP w0.102: D21.1 59.17,28.54 58.12,27.49 56.28,27.49 56.13,27.34 56.13,26.59 55.84,26.3 55.84,25.95 56.23,25.56 56.98,25.56 57.03,25.61 57.03,25.87 v2(57.16,26)
  IN1 w0.089: v2(200.06,17.82) 200.44,18.19 200.44,19.2 199.49,20.15 197.59,20.15 197.19,19.75 196.71,19.75 195.29,21.17 v2(195.29,21.27)
  IN2 w0.089: v2(57.16,26) 57.03,25.87 57.03,24.82 60.82,21.04 68.17,21.04 68.64,20.56 70.24,20.56 70.6,20.2 70.6,19.92 71.35,19.17 75.4,19.17 75.73,19.5 79.05,19.5 83.23,23.67 89.5,23.67 94.43,18.74 96.13,18.74 96.2,18.81 98.43,18.81 98.61,18.63 104.06,18.63 105.01,19.58 108.96,19.58 110.76,21.37 113.33,21.37 113.69,21.73 119.42,21.73 120.48,22.8 121.96,22.8 122.05,22.71 126.26,22.71 127.73,21.23 134.34,21.23 134.78,21.68 137.15,21.68 137.69,21.13 149.56,21.13 149.58,21.11 156.88,21.11 156.94,21.04 163.04,21.04 163.86,21.86 165.44,21.86 165.69,22.12 166.16,22.12 166.3,21.98 170.58,21.98 171.25,21.3 173.24,21.3 173.32,21.22 173.66,21.22 173.89,21.46 173.89,22.08 174.81,23 176.06,23 176.61,22.45 177.23,22.45 177.71,22.92 178.09,22.92 178.62,22.39 181.79,22.39 182.65,21.53 184.11,21.53 184.23,21.65 185.89,21.65 186.25,21.29 187.78,21.29 188.01,21.06 191.53,21.06 191.9,20.7 192.61,20.7 193.26,21.35 194.02,21.35 194.49,20.87 195.09,20.87 195.29,21.07 v2(195.29,21.27)
  BOTTOM w0.102: R25483.2 211.34,14.21 210.75,14.79 210.75,15.81 210.35,16.22 209.97,16.22 208.77,17.41 208.77,17.82 207.68,18.91 204.63,18.91 202.8,17.08 200.8,17.08 v2(200.06,17.82)
ACCEL_INT2_R: length 3.7
  TOP w0.102: U32.9 59.74,25.73 v1(59.9,25.89) 59.9,26.04 D21.2
ACCEL_INTA: length 75.3
  TOP w0.102: v2(55.03,26.78) 55.03,27.29 55.66,27.92 C6606.2 55.86,27.92 57.02,29.08 57.14,29.08 D20.1
  IN1 w0.089: v2(57.59,16.04) 57.59,17.58 56.05,19.12 56.05,21.66 54.75,22.97 54.75,23.4 54.83,23.49 54.83,26.59 v2(55.03,26.78)
  IN3 w0.089: v2(57.59,16.04) 57.87,16.04 58.1,15.81 71.55,15.81 72.65,16.91 77.99,16.91 83.42,22.34 89.77,22.34 90.76,21.34 94.99,21.34 95.88,22.24 95.88,23.58 95.45,24.01 94.12,24.01 93.61,24.52 91.83,24.52 91.52,24.83 v2(90.92,24.83)
  BOTTOM w0.079: U1.CR14 89.23,33.78 89.05,33.6 89.05,33.01 89.31,32.75 89.95,32.75 90.7,32 90.7,31.95
  BOTTOM w0.102: v2(90.92,24.83) 90.86,24.89 R25474.1 90.92,25.83 90.92,27 90.74,27.18 90.74,28 90.64,28.1 90.64,31.04 90.7,31.1 90.7,31.95
ACCEL_INTA_R: length 4.5
  TOP w0.102: D20.2 57.98,26.8 v1(58.15,26.63) 58.74,26.05 U32.11
ACIN: length 79.7
  TOP w0.102: PR40.1 133.45,33.48 133.41,33.51 v2(133.13,33.51) ; v2(189.92,25.34) 190.13,25.55 192.67,25.55 193.24,24.98 193.24,24.25 194.52,22.97 194.52,22.79 195.1,22.21 195.1,22.12 195.69,21.52 195.69,21.07 195.29,20.66 195.29,19.76 196.21,18.83 196.96,18.83 197.32,18.47 198.06,18.47 198.18,18.58 U37.72
  TOP w0.178: PR39.2 135.08,33.48 135.34,33.74 v1(135.57,33.74)
  TOP w0.203: PR30.1 134.15,32.43 134.15,33.07 PR40.1 PR39.2
  IN2 w0.089: v2(189.92,25.34) 189.69,25.57 189.69,26.27 189.32,26.64 188.09,26.64 187.46,26.01 185.73,26.01 184.98,26.76 183.49,26.76 182.89,27.37 180.61,27.37 179.38,28.59 177.69,28.59 177.31,28.97 172.21,28.97 171.46,29.72 164.37,29.72 164.3,29.66 162.29,29.66 162.22,29.73 161.63,29.73 161.22,30.14 161.22,30.55 161.14,30.64 156.2,30.64 155.55,31.28 147.09,31.28 146.18,32.2 144.9,32.2 144.28,32.82 143.6,32.82 143.04,33.39 140.81,33.39 140.67,33.53 133.15,33.53 v2(133.13,33.51)
ACZ_BCLK: length 13.5
  BOTTOM w0.079: U1.BN37 74.07,47.58 71.43,44.94 71.34,44.94
  BOTTOM w0.102: 71.34,44.94 69.02,44.94 68.49,45.48 67.42,45.48 67.07,45.83 v1(66.53,45.83) 65.59,45.83 65.24,45.48 64.15,45.48 63.54,46.09 R187.2
ACZ_RST#: length 18.4
  TOP w0.102: v1(62.29,49.9) 62.59,50.2 R194.2
  BOTTOM w0.079: U1.BL35 75.73,49.11 74.62,49.11 73.98,48.47 73.98,48.21 71.48,45.71 71.33,45.71
  BOTTOM w0.102: v1(62.29,49.9) 62.29,49.64 62.81,49.13 C214.2 C217.2 64.78,48.92 64.78,48.32 66.13,46.98 66.91,46.98 67.68,46.21 68.9,46.21 69.4,45.71 71.33,45.71
ACZ_SDIN0: length 14.8
  BOTTOM w0.079: 71.23,44.69 71.41,44.69 74.01,47.29 74.76,47.29 74.92,47.35 75.21,47.35 75.26,47.33 75.52,47.33 75.57,47.35 75.82,47.35 U1.BN35
  BOTTOM w0.102: R191.2 63.79,45.12 v1(63.99,44.92) 64.22,44.69 64.7,44.69 C215.2 65,44.99 65.49,44.99 65.85,45.35 67.02,45.35 67.37,44.99 68.44,44.99 68.74,44.69 71.23,44.69
ACZ_SDOUT: length 22.4
  TOP w0.102: v1(65.29,46.85) 65.29,47.13 64.43,47.99 v1(63.61,47.99) 62.57,47.99 62.44,47.87 R117.1 62.16,47.43 62.6,47 R118.2 61.09,46.82 60.87,46.6 R25374.2
  BOTTOM w0.079: U1.BN36 75.32,47.58 74.88,47.84 74.08,47.84 71.47,45.22 71.39,45.22 ; 65.21,46.22 C218.2
  BOTTOM w0.102: 71.39,45.22 69.12,45.22 68.59,45.76 67.45,45.76 66.94,46.26 65.27,46.26 C218.2 ; 65.21,46.22 64.83,46.6 64.83,46.87 64.33,47.37 C213.2 64.53,47.61 v1(65.29,46.85)
ACZ_SPKR: length 151.3
  IN2 w0.089: v2(189.42,28.66) 189.39,28.69 189.29,28.69 188.93,29.04 187.68,29.04 187.4,29.33 186.6,29.33 186.07,29.86 185.58,29.86 185.21,30.24 183.17,30.24 182.91,29.98 179.96,29.98 179.63,30.31 175.56,30.31 175.02,30.85 173.61,30.85 173.59,30.87 164.84,30.87 164.24,31.46 161.98,31.46 161.45,32 156.91,32 156.36,32.55 147.44,32.55 146.65,33.34 145.37,33.34 145,33.71 145,34.46 144.26,35.2 142.3,35.2 141.89,35.61 137.16,35.61 136.97,35.8 134.62,35.8 134.34,35.52 133.67,35.52 133.39,35.8 128.48,35.8 126.67,33.99 123.41,33.99 123.28,33.86 119.71,33.86 117.74,31.88 110.05,31.88 109.87,32.07 107.28,32.07 107.09,31.88 100.67,31.88 100.42,32.12 97.8,32.12 97.33,31.65 95.59,31.65 93.62,33.62 92.01,33.62 91.91,33.72 91.09,33.72 90.94,33.87 89.83,33.87 89.15,34.54 87.93,34.54 87.58,34.89 86.98,34.89 85.62,36.26 82.08,36.26 81.98,36.36 80.65,36.36 79.79,35.5 78.5,35.5 78.02,35.02 77.51,35.02 77.02,34.54 77.02,33.52 76.75,33.24 73.66,33.24 72.2,34.71 72.2,37.07 72.71,37.58 72.71,38.21 72.02,38.9 v2(71.99,38.9)
  BOTTOM w0.079: U1.CF35 75.88,39.86 75.71,39.86 75.47,39.75 75.34,39.75 75.24,39.8 74.95,39.8 74.84,39.76 73.85,39.76 73.16,39.08 72.99,39.08 72.81,38.9 v2(71.99,38.9)
  BOTTOM w0.102: v2(189.42,28.66) 189.42,28.79 189.52,28.89 189.52,31.83 190.07,32.37 191.27,32.37 191.79,32.88 192.18,32.88 192.8,32.26 D11.2 ; R116.2 66.51,36.51 66.71,36.71 70.12,36.71 71.54,38.14 71.54,38.44 v2(71.99,38.9)
ACZ_SYNC: length 19.9
  TOP w0.102: v1(62.29,48.63) 61.91,49.01 R188.2
  BOTTOM w0.079: 71.33,45.45 71.46,45.45 74.02,48.01 74.93,48.01 75.17,47.87 76.41,47.87 U1.BN34
  BOTTOM w0.102: v1(62.29,48.63) 61.81,49.11 R186.2 61.66,49.26 61.76,49.36 62.25,49.36 63.24,48.37 64.4,48.37 66.05,46.72 66.86,46.72 67.58,46.01 68.72,46.01 69.28,45.45 71.33,45.45
ADOGND: length 38.6
  TOP w0.254: R464.1 209.54,36.63 v1(209.54,37.32)
  TOP w0.381: v1(209.61,39.86) C586.1 ; C593.1 215.99,47.53 v2(216.44,47.08) ; v1(216.42,41.9) 216.23,41.71 C590.1 ; C599.2 198.94,32.04 198.08,32.9 v1(198.08,33.39) ; v2(201.18,29.7) 201.34,29.7 R470.1 ; v1(198.54,31.63) 198.73,31.45 C598.1 ; R463.1 210.24,37.57 209.99,37.32 v1(209.54,37.32) ; R469.1 209.82,38.85 v1(209.41,39.25) ; C591.1 216.49,43.44 v1(216.6,43.55) ; R474.2 216.29,45.22 v1(216.42,45.1) ; R475.2 215.21,49.18 214.77,49.62 v2(214.08,49.62) ; C592.1 v2(216.47,46.19)
  BOTTOM w0.203: v1(201.18,35.83) 201.28,35.73 U20.25 ; v1(198.61,37.1) 198.61,36.76 199.16,36.21 199.16,36.21 R467.1 ; v2(208.85,34.99) 208.85,34.98 208.3,34.43 U20.38
  BOTTOM w0.254: v2(216.44,47.08) 216.06,47.46 215.23,47.46 214.67,46.9 CN35.3 ; v2(214.59,48.25) 214.49,48.25 214.14,47.9 CN35.1 ; CN35.12 214.24,42.4 214.74,41.9 v1(216.42,41.9)
  BOTTOM w0.305: CN35.5 212.59,45.9 212.1,46.39 v1(212.1,46.67) 212.1,47.59 v1(212.25,47.74)
  BOTTOM w0.381: C568.2 200.1,38.09 v1(199.96,37.96) 199.68,37.96 199.24,37.52 C569.2 ; C588.1 198.19,31.63 v1(198.54,31.63) ; C563.1 203.19,40.15 v1(202.48,39.44) R447.1 ; R465.1 198.17,29.96 v1(198.69,29.96) ; v1(209.54,37.32) 209.51,37.3 C572.1 ; C564.2 202.02,38.81 v1(201.23,38.81) ; C573.2 198.11,33.41 v1(198.08,33.39)
  BOTTOM w0.508: v1(209.41,39.25) 209.61,39.05 209.71,39.05 209.93,38.83 C845.2
ADP_ID: length 192
  TOP w0.102: PR235.2 131.7,36.02 PR230.1 132.38,36.51 133.51,36.51 134.02,36 v2(134.07,36) 135.99,36 PQ17.2
  IN2 w0.089: v2(125.74,36.71) 125.61,36.71 124.39,37.93 122.38,37.93 121.47,38.84 121.47,39.72 120.78,40.41 120.78,40.9 119.8,41.89 119.8,46.52 119.19,47.13 119.19,48.96 116.8,51.34 116.8,52.67 116.14,53.33 116.14,54.09 116.36,54.31 116.36,61.21 117.06,61.91 117.06,65.79 114.44,68.41 114.44,72.5 113.6,73.34 113.6,74.85 112.9,75.55 108.55,75.55 108.29,75.81 108.29,76.41 107.63,77.08 106.23,77.08 105.83,77.48 105.83,78.27 105.27,78.83 105.27,80.62 102.84,83.04 102.4,83.04 101.19,84.26 97.51,84.26 96.35,85.42 96.35,86.95 91.34,91.96 91.34,97.21 89.67,98.89 88.61,98.89 86.35,101.15 83.61,101.15 81.34,103.41 77.43,103.41 76.73,104.12 75.92,104.12 75.33,104.71 73.11,104.71 72.78,104.39 70.92,104.39 68.11,107.19 68.11,110.19 62.34,115.96 55.06,115.96 53.73,117.28 44.46,117.28 44.26,117.08 42.78,117.08 41.82,116.11 40.75,116.11 39.38,114.74 11.57,114.74 11.28,114.45 PJ2.3
  BOTTOM w0.102: v2(125.74,36.71) 125.74,35.8 126.05,35.5 133.51,35.5 133.97,35.95 134.02,35.95 v2(134.07,36)
ALERT: length 16
  TOP w0.102: v2(99.62,97.52) 98.98,98.16 97.85,98.16 97.52,97.83 97.52,97.29 97.34,97.12 96.95,97.12 96.28,97.79 96.28,98.39 94.02,100.65 93.47,100.65 90.68,97.85 v1(90.13,97.85) 89.88,98.11 88.41,98.11 R397.1
  BOTTOM w0.102: U8.F8 v2(99.62,97.52)
AMP_MUTE#: length 14.9
  TOP w0.102: v2(191.93,27.8) 192.26,27.8 192.85,28.38 U37.108
  IN1 w0.089: v2(200.04,24.01) 199,24.01 198.27,24.75 196.51,24.75 196.34,24.93 195.69,24.93 195.5,25.13 195.5,25.58 194.07,27.01 192.72,27.01 v2(191.93,27.8)
  BOTTOM w0.102: v2(200.04,24.01) 199.91,24.01 199.45,24.47 v1(199.45,24.65) 199.78,24.98 D13.1
AP_EQ: length 3.6
  BOTTOM w0.102: U6502.9 17.5,20.32 17.18,20 R25279.2 R25273.1 17.41,18.66 v1(17.89,18.17)
BAT-V: length 11.8
  BOTTOM w0.152: PR209.2 111.21,27.01 111.43,26.8 111.43,25.14 111.43,25.14
  BOTTOM w0.203: 111.43,25.14 112.23,24.34 118.76,24.34 119.04,24.62 119.95,24.62 PR208.2
  vias: v1(108.88,24.45)
BATLED0#: length 50
  TOP w0.102: v2(192.52,21.55) 192.14,21.17 189.17,21.17 186.74,18.73 185.25,18.73 184.36,17.85 184.36,17.44 184.08,17.16 184.08,17.11 183.95,16.98 U37.29
  IN1 w0.089: v2(212.42,36.06) 212.42,35.91 213.42,34.91 214.18,34.91 215.86,33.23 215.86,32.29 215.35,31.79 215.35,30.38 213.66,28.68 213.66,26.41 211.79,24.54 209.36,24.54 208.47,25.44 207.27,25.44 206.79,25.92 v2(206.79,26.07)
  IN2 w0.089: v2(192.52,21.55) 192.88,21.91 193.64,21.91 194.13,22.41 194.86,22.41 195.21,22.05 196.05,22.05 196.79,22.79 199.5,22.79 199.57,22.87 200.92,22.87 202.88,24.83 205.55,24.83 v2(206.79,26.07)
  BOTTOM w0.102: v2(212.42,36.06) 212.54,36.06 212.88,36.4 CN35.24
