# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VGA_VSSSENSE: length 38.6
  TOP w0.102: v2(68.51,112.15) 69.2,112.84 PR9031.2 69.29,112.12 69.31,112.1 PR9029.2
  IN2 w0.089: v2(92.69,101.71) 91.12,101.71 88.33,104.51 88.33,104.84 86.6,106.56 83.27,106.56 82.87,106.16 77.74,106.16 76.88,107.02 72.31,107.02 71.87,107.45 70.21,107.45 69.78,107.88 69.78,110.55 68.95,111.39 68.95,111.72 v2(68.51,112.15)
  BOTTOM w0.102: v2(92.69,101.71) 92.22,101.25 92.22,100.74 92.56,100.4 92.56,98.75 94.02,97.29 94.17,97.29 U8.F1
VL: length 71
  TOP w0.254: v2(48.44,15.12) 48.44,15.26 46.57,17.13 v1(46.47,17.13) 46.09,16.75 44.53,16.75 44.31,16.52 43.62,16.52 43.24,16.15 43.24,15.91 42.72,15.39 PR6025.2
  IN2 w0.254: v2(80.43,15.89) 80.08,15.54 73.86,15.54 72.79,14.46 49.1,14.46 v2(48.44,15.12)
  IN3 w0.254: v2(101.71,25.77) 101.18,26.3 98.94,26.3 97.45,24.8 97.45,22.26 95.26,20.07 90.16,20.07 88.93,21.3 83.85,21.3 80.43,17.88 v2(80.43,15.89)
  BOTTOM w0.254: v2(101.71,25.77) 101.74,25.79 101.74,26.25 101.88,26.39 PR3020.1
VMA_CLK0: length 42.6
  TOP w0.102: v2(113.73,95.87) 114.16,95.44 114.67,95.44 114.89,95.22 115.78,95.22 116.01,95.46 116.01,95.61 116.51,96.11 117.79,96.11 118.13,95.77 119.64,95.77 119.98,96.11 121.63,96.11 121.84,96.33 121.84,96.47 121.94,96.57 122.25,96.57 122.35,96.47 122.35,96.31 122.56,96.1 123.03,96.1 123.24,96.31 123.24,96.47 123.34,96.57 123.65,96.57 123.75,96.47 123.75,96.33 123.96,96.11 124.63,96.11 124.84,96.33 124.84,96.47 124.94,96.57 125.42,96.57 125.64,96.79 125.64,97.72 125.74,97.82 126.04,97.82 126.14,97.72 126.14,96.79 126.36,96.57 126.82,96.57 127.03,96.79 127.03,97.94 127.14,98.04 127.44,98.04 127.54,97.94 127.54,96.79 127.75,96.57 128.22,96.57 128.43,96.79 128.43,97.94 128.53,98.04 128.84,98.04 128.94,97.94 128.94,96.79 129.15,96.57 129.61,96.57 129.83,96.79 129.83,97.94 129.93,98.04 130.23,98.04 130.34,97.94 130.34,96.79 130.55,96.57 131.34,96.57 133.27,94.64 133.27,92.87 v2(133.01,92.61)
  BOTTOM w0.079: VRAM1.J12 133.41,91.96 133.49,91.88 133.6,91.88 133.73,92.01 133.73,94.28 134.14,94.69 134.14,94.71 134.16,94.73
  BOTTOM w0.102: R25488.2 134.75,97.11 134.75,96.2 134.3,95.76 134.3,94.87 134.16,94.73 ; v2(113.73,95.87) 113.8,95.8 113.8,95.53 113.7,95.43 U8.D24 ; v2(133.01,92.61) 133.41,92.21 VRAM1.J12
VMA_CLK0#: length 42.8
  TOP w0.102: v2(133.01,91.81) 133.46,92.26 133.46,94.72 131.42,96.77 130.63,96.77 130.53,96.87 130.53,98.02 130.31,98.23 129.85,98.23 129.64,98.02 129.64,96.87 129.54,96.77 129.23,96.77 129.13,96.87 129.13,98.02 128.92,98.23 128.45,98.23 128.24,98.02 128.24,96.87 128.14,96.77 127.83,96.77 127.73,96.87 127.73,98.02 127.52,98.23 127.06,98.23 126.84,98.02 126.84,96.87 126.74,96.77 126.44,96.77 126.34,96.87 126.34,97.8 126.12,98.01 125.66,98.01 125.45,97.8 125.45,96.87 125.34,96.77 124.86,96.77 124.65,96.55 124.65,96.4 124.55,96.3 124.04,96.3 123.94,96.4 123.94,96.55 123.72,96.76 123.26,96.76 123.05,96.55 123.05,96.39 122.95,96.29 122.64,96.29 122.54,96.39 122.54,96.55 122.33,96.76 121.86,96.76 121.65,96.55 121.65,96.4 121.55,96.3 119.9,96.3 119.56,95.96 118.21,95.96 117.87,96.3 116.44,96.3 115.82,95.69 115.82,95.53 115.7,95.41 114.97,95.41 114.75,95.63 114.73,95.63 v2(114.51,95.85)
  BOTTOM w0.079: 134.29,94.59 134.28,94.58 134.26,94.58 133.89,94.21 133.89,91.94 133.67,91.72 133.49,91.72 133.41,91.64 VRAM1.J11
  BOTTOM w0.102: U8.D25 114.13,95.46 v2(114.51,95.85) ; R25488.1 134.94,97.17 134.94,96.13 134.49,95.68 134.49,94.79 134.29,94.59 ; v2(133.01,91.81) 133.01,91.8 VRAM1.J11
VMA_CLK1: length 45.6
  TOP w0.102: v2(133.01,107.81) 133.25,107.57 133.25,107.26 133.03,107.05 131.89,107.05 131.63,107.3 126.16,107.3 125.86,107 125.86,106.14 125.72,106 125.47,106 125.37,106.1 125.37,106.94 125.14,107.18 124.7,107.18 124.48,106.96 124.48,106.1 124.38,106 123.52,106 123.08,105.56 123.08,104.92 123.29,104.71 124.75,104.71 124.85,104.6 124.85,104.3 124.75,104.2 123.29,104.2 123.08,103.99 123.08,103.52 123.29,103.31 124.95,103.31 125.05,103.21 125.05,102.9 124.95,102.8 123.29,102.8 123.08,102.59 123.08,102.05 121.98,100.95 117.04,100.95 116.41,101.59 113.44,101.59 113.16,101.86 112.49,101.86 112.11,102.25 v2(112.11,102.49)
  BOTTOM w0.079: 134.75,104.6 134.75,104.62 134.76,104.64 134.76,105.22 134.53,105.45 134.53,106.81 134.43,106.92 133.93,106.92 133.73,107.12 133.73,107.65 133.65,107.73 133.57,107.73 133.41,107.57 VRAM2.J12
  BOTTOM w0.102: v2(133.01,107.81) 133.01,107.21 133.11,107.11 133.31,107.11 133.41,107.21 VRAM2.J12 ; 134.75,104.6 134.75,104.21 134.08,103.54 134.08,102.79 133.95,102.66 R25489.2
  BOTTOM w0.127: v2(112.11,102.49) 111.93,102.49 111.69,102.73 U8.N22
VMA_CLK1#: length 45.9
  TOP w0.102: v2(133.01,108.62) 133.01,108.39 133.44,107.96 133.44,107.18 133.11,106.86 131.81,106.86 131.55,107.11 126.24,107.11 126.05,106.92 126.05,106.06 125.79,105.81 125.4,105.81 125.18,106.02 125.18,106.86 125.06,106.99 124.78,106.99 124.67,106.88 124.67,106.02 124.46,105.81 123.6,105.81 123.27,105.48 123.27,105 123.37,104.9 124.83,104.9 125.04,104.68 125.04,104.22 124.83,104.01 123.37,104.01 123.27,103.91 123.27,103.6 123.37,103.5 125.03,103.5 125.25,103.29 125.25,102.82 125.03,102.61 123.37,102.61 123.27,102.51 123.27,101.97 122.06,100.76 116.97,100.76 116.33,101.4 113.36,101.4 113.08,101.67 v2(112.11,101.67)
  BOTTOM w0.079: VRAM2.J11 133.41,108.02 133.54,107.89 133.71,107.89 133.89,107.72 133.89,107.19 134,107.08 134.49,107.08 134.69,106.88 134.69,105.51 134.92,105.29 134.92,104.64 134.94,104.62 134.94,104.6
  BOTTOM w0.102: R25489.1 134.4,102.63 134.27,102.76 134.27,103.46 134.94,104.13 134.94,104.6 ; v2(133.01,108.62) 133.01,108.61 133.41,108.21 VRAM2.J11 ; U8.M22 v2(112.11,101.67)
VMA_DQ0: length 39.3
  TOP w0.102: 135.49,82.32 135.82,82.66 135.82,83.42 v2(136.21,83.81)
  TOP w0.165: v2(107.92,96.66) 108.51,96.07 108.51,95.38 108.36,95.24 108.36,94.81 109.28,93.89 109.28,93.33 109.44,93.17 109.44,91.91 111.94,89.42 122.02,89.42 v1(122.71,88.73) 125.23,86.2 125.23,85 126.66,83.57 129.61,83.57 131.03,82.15 135.31,82.15 135.49,82.32
  BOTTOM w0.165: VRAM1.E2 136.61,84.2 v2(136.21,83.81) ; v2(107.92,96.66) U8.E18
VMA_DQ1: length 37.3
  TOP w0.102: v2(135.41,83.81) 135.41,83.65 134.99,83.23 134.99,82.73 134.84,82.58
  TOP w0.165: 134.84,82.58 134.83,82.57 131.23,82.57 v1(129.81,83.99) 126.83,83.99 125.65,85.17 125.65,86.44 122.25,89.84 112.11,89.84 110.59,91.36 110.59,92.54 109.74,93.4 109.74,93.81 109.41,94.14 109.41,94.98 108.77,95.62 108.77,96.58 v2(108.72,96.63)
  BOTTOM w0.165: v2(108.72,96.63) 108.35,97.01 U8.F18 ; v2(135.41,83.81) 135.8,84.2 VRAM1.F2
VMA_DQ2: length 46.3
  TOP w0.102: 139.14,82.3 139.38,82.54 139.48,82.54 140.21,83.27 v2(140.21,83.81)
  TOP w0.165: v2(107.09,96.62) 106.7,96.23 106.7,95.7 106.66,95.67 106.66,93.58 107.5,92.74 107.5,91.17 107.83,90.84 109.28,90.84 111.54,88.58 121.54,88.58 124.39,85.73 124.39,83.99 127.07,81.31 138.16,81.31 139.14,82.3
  BOTTOM w0.102: v2(107.09,96.62) 106.68,96.23 U8.E16
  BOTTOM w0.165: v2(140.21,83.81) 139.82,84.2 VRAM1.A2
VMA_DQ3: length 44.6
  TOP w0.102: 138.83,82.58 139,82.75 139,83.3 139.41,83.71 v2(139.41,83.81)
  TOP w0.165: v2(107.88,97.52) 107.88,97.27 107.5,96.89 107.5,96.49 107.52,96.47 107.52,95.17 108.36,94.33 108.36,92.98 108.62,92.73 108.62,92.15 111.76,89 121.78,89 124.81,85.97 124.81,84.16 127.25,81.73 v4(136.61,81.73) 137.98,81.73 138.83,82.58
  BOTTOM w0.165: v2(139.41,83.81) 139.02,84.2 VRAM1.B2 ; U8.F17 107.88,97.45 v2(107.88,97.52)
VMA_DQ4: length 31.1
  TOP w0.102: 134.74,87.49 134.99,87.24 134.99,86.63 v2(135.41,86.21)
  TOP w0.165: 134.74,87.49 134.34,87.89 127.12,87.89 v1(126.78,88.22) 123.73,91.27 112.74,91.27 112.51,91.5 112.28,91.5 111.39,92.38 111.39,92.88 110.54,93.73 110.54,94.82 v2(110.38,94.98)
  BOTTOM w0.165: v2(110.38,94.98) 110.38,95.04 U8.D20 ; v2(135.41,86.21) 135.81,85.81 VRAM1.F4
VMA_DQ5: length 34.9
  TOP w0.102: 137.17,85.79 137.97,84.99 138.99,84.99 v2(139.41,85.41)
  TOP w0.165: 137.17,85.79 136.89,86.07 136.89,87.44 135.29,89.04 127.28,89.04 v1(125.4,90.91) 124.18,92.14 113.37,92.14 111.23,94.27 v2(111.23,95.03)
  BOTTOM w0.165: v2(111.23,95.03) U8.D21 ; VRAM1.B4 139.02,85.8 v2(139.41,85.41)
VMA_DQ6: length 33.4
  TOP w0.102: v2(136.21,86.21) 136.21,86.21 135.82,86.6 135.82,87.24
  TOP w0.165: 135.82,87.24 134.76,88.3 v4(130.08,88.3) 127.36,88.3 123.96,91.71 112.94,91.71 112.77,91.88 112.28,91.88 111.66,92.49 111.66,92.99 110.81,93.84 110.81,96.09 110.42,96.48 v2(110.42,96.6)
  BOTTOM w0.165: v2(110.42,96.6) 109.99,97.04 U8.F20 ; v2(136.21,86.21) 136.61,85.81 VRAM1.E4
VMA_DQ7: length 36
  TOP w0.102: v2(140.21,85.41) 140.19,85.41 139.81,85.79 137.65,85.79 137.3,86.14 137.3,86.3 ; 111.62,94.83 111.62,95.31 111.23,95.71 v2(111.23,95.83)
  TOP w0.165: 137.3,86.3 137.3,87.62 135.46,89.46 127.51,89.46 v1(124.78,92.19) 124.4,92.57 113.35,92.57 111.62,94.3 111.62,94.83
  BOTTOM w0.165: VRAM1.A4 139.82,85.8 v2(140.21,85.41) ; v2(111.23,95.83) 110.83,96.23 U8.E21
VMA_DQ8: length 43
  IN1 w0.102: v2(139.41,91.01) 139.01,91.4 139.01,92.94
  IN1 w0.152: v2(106.27,96.63) 106.27,97.82 107.12,98.67 109.68,98.67 110.38,97.96 115.13,97.96 115.5,98.33 117.04,98.33 117.85,99.15 136.37,99.15 138.54,96.97 138.54,93.41 139.01,92.94
  BOTTOM w0.165: VRAM1.B11 139.02,91.4 v2(139.41,91.01) ; v2(106.27,96.63) 106.27,96.61 105.89,96.23 U8.E15
VMA_DQ9: length 35.2
  IN1 w0.102: v2(136.21,93.41) 136.61,93.81 136.61,94.38
  IN1 w0.152: 136.61,94.38 135.26,95.73 134.4,95.73 132,98.13 121.41,98.13 120.25,96.96 115.57,96.96 114.88,96.28 112.8,96.28 112.77,96.25 111.06,96.25 111.01,96.2 109.95,96.2 109.92,96.23 107.75,96.23 107.75,96.22 106.84,96.22 106.48,95.86 v2(106.28,95.86)
  BOTTOM w0.165: U8.D15 106.28,95.84 v2(106.28,95.86) ; VRAM1.E13 136.61,93.01 v2(136.21,93.41)
VMA_DQ10: length 45.6
  IN1 w0.152: v2(140.21,92.61) 140.64,93.04 140.64,96.17 136.66,100.15 127.57,100.15 127.27,100.44 120.91,100.44 120.84,100.52 119.79,100.52 119.33,100.06 117.47,100.06 117.07,99.66 114.4,99.66 114.34,99.6 110.3,99.6 109.29,100.61 107.38,100.61 106.93,100.16 106.93,99.66 106.78,99.5 105.59,99.5 105.19,99.1 105.19,97.64 v2(105.37,97.47)
  BOTTOM w0.165: U8.F15 105.76,97.07 v2(105.37,97.47) ; v2(140.21,92.61) 139.82,93 VRAM1.A13
VMA_DQ11: length 49.4
  IN1 w0.152: v2(103.81,96.64) 104.23,97.05 104.23,98.5 105.98,100.25 105.98,100.44 106.4,100.86 110.68,100.86 111.13,100.42 117,100.42 117.11,100.52 119.14,100.52 119.6,100.98 121.03,100.98 121.1,100.9 134.89,100.9 135.06,101.08 136.38,101.08 141.1,96.36 141.1,91.89 v2(140.21,91.01)
  BOTTOM w0.165: v2(103.81,96.64) 104.19,97.01 U8.F13 ; VRAM1.A11 139.82,91.4 v2(140.21,91.01)
VMA_DQ12: length 37.7
  IN1 w0.102: v2(137.01,91.81) 136.63,92.19 136.08,92.19 135.82,92.44 135.82,92.81 135.64,93 134.38,93
  IN1 w0.152: 134.38,93 134.05,93.33 134.05,94 131.39,96.66 122.02,96.66 120.86,95.49 118.55,95.49 117.41,94.35 114.18,94.35 113.9,94.63 113.24,94.63 112.85,94.23 108.59,94.23 108.22,94.6 107.61,94.6 107.36,94.35 104.76,94.35 v2(104.65,94.23)
  BOTTOM w0.165: VRAM1.E11 136.61,91.4 v2(137.01,91.81) ; v2(104.65,94.23) 104.26,94.63 U8.C13
VMA_DQ13: length 36.6
  IN1 w0.102: 134.14,92.54 134.49,92.19 135.03,92.19 v2(135.41,91.81)
  IN1 w0.152: 134.14,92.54 133.41,93.27 133.41,93.99 131.2,96.2 122.21,96.2 121.05,95.03 118.74,95.03 117.58,93.87 113.94,93.87 113.78,93.71 112.33,93.71 112.18,93.86 108.42,93.86 108.34,93.79 105.8,93.79 105.04,93.03 104.22,93.03 v2(103.81,93.43)
  BOTTOM w0.165: v2(135.41,91.81) 135.81,91.41 VRAM1.F11 ; U8.B13 104.19,93.81 v2(103.81,93.43)
VMA_DQ14: length 44.8
  IN1 w0.102: 105.85,97.27 105.85,97.19 105.7,97.04 105.19,97.04 105.07,96.91 105.07,96.25 v2(104.65,95.83)
  IN1 w0.152: v2(139.41,92.61) 139.51,92.7 139.51,93.33 139,93.84 139,97.16 136.56,99.6 117.66,99.6 116.85,98.79 113.92,98.79 113.91,98.78 111.18,98.78 110.81,98.41 110.29,98.41 108.99,99.71 108.29,99.71 108.27,99.69 107.66,99.69 107.37,99.39 107.37,99.27 105.85,97.76 105.85,97.27
  BOTTOM w0.165: v2(139.41,92.61) 139.02,93 VRAM1.B13 ; v2(104.65,95.83) 104.26,96.23 U8.E13
VMA_DQ15: length 35.6
  IN1 w0.102: 134.74,94.73 135.01,94.46 135.01,93.8 v2(135.41,93.41)
  IN1 w0.152: v2(104.65,95.03) 105.08,94.6 107.25,94.6 107.5,94.86 108.33,94.86 108.61,94.58 112.56,94.58 112.96,94.98 113.9,94.98 114.28,94.6 114.84,94.6 116.18,95.95 120.67,95.95 121.84,97.12 131.58,97.12 133.96,94.73 134.74,94.73
  BOTTOM w0.165: VRAM1.F13 135.81,93.01 v2(135.41,93.41) ; U8.D13 104.26,95.43 v2(104.65,95.03)
VMA_DQ16: length 31.6
  IN1 w0.152: v2(105.44,92.62) 105.37,92.62 104.71,91.96 104.71,91.05 106.67,89.09 108.46,89.09 109.27,88.28 123.6,88.28 125.08,89.76 129.18,89.76 129.6,90.18 129.6,90.77 v2(129.83,91)
  BOTTOM w0.165: v2(105.44,92.62) 105.44,93.42 105.84,93.83 U8.B15 ; v2(129.83,91) 130.21,91.37 VRAM1.N11
VMA_DQ17: length 26.6
  IN1 w0.152: v2(106.36,92.44) 105.98,92.06 105.98,91.12 107.1,90 108.84,90 109.65,89.19 123.22,89.19 124.95,90.92 126.48,90.92 v2(126.58,91.02)
  BOTTOM w0.165: U8.C16 106.27,94.23 106.27,92.53 v2(106.36,92.44) ; v2(126.58,91.02) 126.96,91.4 VRAM1.U11
VMA_DQ18: length 32.1
  IN1 w0.152: v2(130.61,91) 130.11,90.5 130.11,90.04 129.37,89.31 125.27,89.31 123.79,87.82 109.08,87.82 108.27,88.63 106.23,88.63 104.19,90.68 v2(104.19,92.32)
  BOTTOM w0.165: v2(104.19,92.32) U8.A13 ; VRAM1.M11 v2(130.61,91)
VMA_DQ19: length 26.9
  IN1 w0.152: v2(127.42,90.99) 126.88,90.46 125.14,90.46 123.41,88.73 109.46,88.73 108.65,89.55 106.89,89.55 105.17,91.27 105.17,91.73 v2(105.47,92.04)
  BOTTOM w0.165: U8.A15 105.9,93 105.9,92.46 v2(105.47,92.04) ; VRAM1.T11 127.42,91.01 v2(127.42,90.99)
VMA_DQ20: length 23.1
  IN1 w0.152: v2(108.01,91.68) 108.16,91.53 109.47,91.53 110.28,90.71 122.59,90.71 124.92,93.05 126.33,93.05 v2(126.43,92.95)
  BOTTOM w0.102: U8.B18 108.35,93.67 108.01,93.33 108.01,93.05 107.51,92.55 107.51,92.18 v2(108.01,91.68)
  BOTTOM w0.165: v2(126.43,92.95) 126.96,92.95 VRAM1.U13
VMA_DQ21: length 23.3
  IN1 w0.152: v2(108.01,92.44) 108.47,91.98 109.66,91.98 110.47,91.17 122.4,91.17 125.44,94.21 v2(127.4,94.21)
  BOTTOM w0.165: v2(108.01,92.44) 108.35,92.78 U8.A18 ; v2(127.4,94.21) 127.4,93.41 VRAM1.T13
VMA_DQ22: length 28.6
  IN1 w0.152: v2(109.03,92.44) 109.59,93 110.3,93 110.46,92.85 110.46,91.83 110.61,91.68 110.91,91.68 111.07,91.83 111.07,92.85 111.22,93 111.68,93 111.97,92.71 111.97,91.79 112.13,91.63 117.61,91.63 119.62,93.64 124.22,93.64 125.25,94.67 129.95,94.67 130.25,94.37 130.25,93.83 v2(129.83,93.4)
  BOTTOM w0.165: VRAM1.N13 130.21,93.03 v2(129.83,93.4) ; U8.A19 109.03,92.91 v2(109.03,92.44)
VMA_DQ23: length 27.1
  IN1 w0.152: v2(108.77,93.43) 108.8,93.46 111.87,93.46 112.42,92.9 112.89,92.9 113.7,92.09 117.42,92.09 119.43,94.09 124.03,94.09 125.06,95.13 130.14,95.13 130.71,94.56 130.71,93.5 v2(130.61,93.4)
  BOTTOM w0.165: v2(108.77,93.43) 108.77,94.25 U8.C19 ; v2(130.61,93.4) VRAM1.M13
VMA_DQ24: length 21.2
  BOTTOM w0.165: VRAM1.N4 129.81,86.2 129.81,86.78 129.54,87.04 129.54,87.17 128.84,87.87 127.54,87.87 123.23,92.19 v4(120.84,92.19) 113.98,92.19 113.73,92.44 113.73,93.2 113.33,93.6 U8.B24
VMA_DQ25: length 20.2
  BOTTOM w0.165: VRAM1.U4 126.6,86.21 126.6,87.36 122.64,91.32 v4(122.21,91.32) 113.45,91.32 112.96,91.82 112.96,94.16 U8.C23
VMA_DQ26: length 20.9
  BOTTOM w0.165: U8.A25 114.13,92.78 114.3,92.62 123.46,92.62 v1(123.89,92.19) 127.58,88.51 129.73,88.51 130.62,87.62 130.62,86.19 VRAM1.M4
VMA_DQ27: length 18.6
  BOTTOM w0.165: U8.A24 113.33,92.2 113.78,91.76 122.92,91.76 v1(123.81,90.87) 127.42,87.26 127.42,86.19 VRAM1.T4
VMA_DQ28: length 23.2
  BOTTOM w0.165: VRAM1.T2 127.42,83.81 125.66,83.81 124.81,84.66 124.81,86.43 v4(122.05,89.2) 121.8,89.44 112.41,89.44 111.19,90.66 111.19,92.32 110.83,92.67 U8.A21
VMA_DQ29: length 22.4
  BOTTOM w0.165: VRAM1.U2 126.03,84.2 125.41,84.82 125.41,86.45 v4(124.14,87.72) 121.98,89.88 v4(120.79,89.88) 112.69,89.88 111.45,91.11 111.45,92.61 111.24,92.82 111.24,93.42 U8.B21
VMA_DQ30: length 32.1
  BOTTOM w0.165: VRAM1.M2 130.62,83.81 130.62,82.71 129.62,81.72 126.57,81.72 123.89,84.4 v4(123.89,85.79) 123.89,86.04 121.35,88.58 111.49,88.58 110.17,89.9 110.17,91.55 109.48,92.25 109.48,92.77 109.54,92.82 109.54,93.97 109.99,94.42 U8.C20
VMA_DQ31: length 29.5
  BOTTOM w0.165: VRAM1.N2 129.81,83.8 129.81,83.12 129.06,82.38 126.5,82.38 124.35,84.53 124.35,86.19 v4(122.69,87.84) 121.52,89.01 111.95,89.01 110.68,90.28 110.68,92.06 110.42,92.32 110.42,94.23 U8.C21
VMA_DQ32: length 38.7
  IN1 w0.102: v2(112.11,104.15) 112.11,104.06 112.54,103.63 112.54,102.27 112.84,101.97
  IN1 w0.152: v2(140.21,108.61) 141.1,107.72 141.1,103.56 139.79,102.25 134.36,102.25 133.9,101.79 119.65,101.79 118.98,101.12 117.41,101.12 117.2,101.33 113.47,101.33 112.84,101.97
  BOTTOM w0.165: v2(112.11,104.15) U8.R22 ; VRAM2.U11 140.21,108.6 v2(140.21,108.61)
VMA_DQ33: length 28
  IN1 w0.152: v2(136.21,108.61) 136.71,109.11 136.71,109.84 136.26,110.3 125.19,110.3 123.98,109.09 121.87,109.09 119.24,106.46 117.18,106.46 115.68,104.96 v2(113.74,104.96)
  BOTTOM w0.165: U8.R24 113.36,104.57 v2(113.74,104.96) ; VRAM2.N11 136.61,108.21 v2(136.21,108.61)
VMA_DQ34: length 33.7
  IN1 w0.102: v2(112.11,104.97) 112.54,104.54 112.54,103.92 112.73,103.73 113.23,103.73 113.35,103.62 113.35,103.11 113.58,102.87 113.88,102.87 114.11,102.65 114.11,102.32 114.54,101.89
  IN1 w0.152: 114.54,101.89 117.96,101.89 118.78,102.7 133.53,102.7 133.98,103.16 138.03,103.16 139.63,104.76 139.63,105.63 v2(140.21,106.21)
  BOTTOM w0.165: v2(140.21,106.21) 139.82,106.6 VRAM2.U13
  BOTTOM w0.305: U8.T22 111.71,105.37 v2(112.11,104.97)
VMA_DQ35: length 25.5
  IN1 w0.152: v2(135.41,108.61) 135.02,108.21 125.56,108.21 123.35,106.01 117.37,106.01 115.97,104.61 114.39,104.61 114.29,104.51 113.32,104.51 v2(112.92,104.11)
  BOTTOM w0.165: VRAM2.M11 135.81,108.21 v2(135.41,108.61) ; U8.R23 112.53,104.5 v2(112.92,104.11)
VMA_DQ36: length 25.1
  IN1 w0.152: v2(136.21,106.16) 135.32,107.04 126.72,107.04 125.23,105.55 117.56,105.55 116.56,104.55 v2(116.56,104.38)
  BOTTOM w0.127: v2(116.56,104.38) 116.56,104.04 116.12,103.6 115.61,103.6 115.38,103.36 114.9,103.36 114.43,102.89 U8.N25
  BOTTOM w0.165: VRAM2.N13 136.61,106.55 v2(136.21,106.16)
VMA_DQ37: length 22.9
  IN1 w0.152: v2(135.41,106.16) 134.98,106.59 126.98,106.59 125.49,105.09 117.76,105.09 v2(117.32,104.65)
  BOTTOM w0.127: v2(117.32,104.65) 117.32,104.47 116.22,103.37 115.71,103.37 115.45,103.11 115.15,103.11 U8.N26
  BOTTOM w0.165: v2(135.41,106.16) 135.81,106.55 VRAM2.M13
VMA_DQ38: length 35.3
  IN1 w0.102: 113.35,102.25 113.35,102.6 112.92,103.03 v2(112.92,103.28)
  IN1 w0.152: v2(139.41,107.81) 140.64,106.57 140.64,103.75 139.6,102.7 134.17,102.7 133.71,102.25 119.21,102.25 118.6,101.63 113.96,101.63 113.35,102.25
  BOTTOM w0.165: v2(112.92,103.28) U8.N23 ; v2(139.41,107.81) 139.02,108.2 VRAM2.T11
VMA_DQ39: length 29.9
  IN1 w0.102: v2(113.74,103.33) 114.46,103.33 114.95,102.83 114.95,102.29 115.11,102.14
  IN1 w0.152: 115.11,102.14 117.56,102.14 118.58,103.16 133.34,103.16 133.79,103.62 137.85,103.62 139.13,104.9 139.13,105.92 v2(139.41,106.21)
  BOTTOM w0.165: v2(113.74,103.33) 113.33,102.92 U8.N24 ; v2(139.41,106.21) 139.02,106.6 VRAM2.T13
VMA_DQ40: length 27.7
  IN1 w0.102: v2(135.41,113.4) 134.99,112.98 134.99,112.25
  IN1 w0.152: 134.99,112.25 134.92,112.18 124.41,112.18 123.2,110.97 121.09,110.97 118.64,108.52 116.5,108.52 115.36,107.38 114.49,107.38 114.02,107.86 112.52,107.86 v2(112.11,107.45)
  BOTTOM w0.165: v2(112.11,107.45) 112.51,107.05 U8.V23 ; v2(135.41,113.4) 135.41,113.41 135.81,113.8 VRAM2.M4
VMA_DQ41: length 32.2
  IN1 w0.102: v2(137.01,114.21) 137.41,113.8 137.41,113.08
  IN1 w0.152: v2(111.29,106.63) 111.6,106.63 112.02,106.22 112.26,106.22 113.09,107.04 114.11,107.04 114.23,106.93 115.55,106.93 116.69,108.07 118.83,108.07 121.28,110.51 123.39,110.51 124.6,111.72 136.87,111.72 137.48,112.33 137.48,113.02 137.41,113.08
  BOTTOM w0.165: U8.V22 111.69,107.03 v2(111.29,106.63) ; VRAM2.N4 136.61,113.8 v2(137.01,114.21)
VMA_DQ42: length 31.9
  IN1 w0.152: v2(112.93,104.97) 113.36,105.4 115.4,105.4 117.15,107.15 119.21,107.15 121.66,109.6 123.77,109.6 124.98,110.81 137.61,110.81 v2(140.21,113.41)
  BOTTOM w0.165: v2(140.21,113.41) 139.82,113.8 VRAM2.U4 ; v2(112.93,104.97) U8.T23
VMA_DQ43: length 31.6
  IN1 w0.152: v2(112.11,105.79) 112.34,105.79 112.76,106.22 115.57,106.22 116.96,107.61 119.02,107.61 121.47,110.06 123.58,110.06 124.79,111.26 137.27,111.26 v2(139.41,113.41)
  BOTTOM w0.165: U8.U22 v2(112.11,105.79) ; v2(139.41,113.41) 139.02,113.8 VRAM2.T4
VMA_DQ44: length 30.4
  IN1 w0.102: 136.61,116.8 136.61,116.2 v2(137.01,115.81)
  IN1 w0.152: 136.61,116.8 136.42,117 133.24,117 132.65,117.59 126.26,117.59 121.63,112.95 120.27,112.95 119.49,112.18 116.38,112.18 114.96,110.75 114.96,109.78 114.69,109.51 113.36,109.51 v2(112.96,109.11)
  BOTTOM w0.165: U8.Y24 113.33,108.74 v2(112.96,109.11) ; v2(137.01,115.81) 136.61,115.4 VRAM2.N2
VMA_DQ45: length 32.3
  IN1 w0.152: v2(112.93,109.93) 113,109.93 113.42,110.34 113.9,110.34 116.19,112.63 118.68,112.63 119.46,113.41 121.44,113.41 126.07,118.05 133.08,118.05 133.67,117.45 138.37,117.45 139.08,116.74 139.08,116.4 138.61,115.93 v2(138.61,115.81)
  BOTTOM w0.165: v2(112.93,109.93) U8.AA24 ; v2(138.61,115.81) 138.61,115.8 VRAM2.T2
VMA_DQ46: length 30
  IN1 w0.152: v2(112.11,108.27) 112.16,108.27 112.58,108.7 113.2,108.7 113.58,109.08 114.74,109.08 115.42,109.75 115.42,110.56 116.02,111.16 119.13,111.16 120.46,112.5 121.82,112.5 126.4,117.08 131.13,117.08 132.03,116.17 133.27,116.17 133.41,116.32 135.7,116.32 v2(136.21,115.81)
  BOTTOM w0.165: v2(112.11,108.27) U8.Y22 ; v2(136.21,115.81) 135.81,115.41 VRAM2.M2
VMA_DQ47: length 34.2
  IN1 w0.152: v2(139.41,115.81) 139.63,116.03 139.63,116.95 138.68,117.91 133.98,117.91 133.39,118.5 125.88,118.5 121.25,113.87 119.27,113.87 118.49,113.09 116,113.09 114.34,111.43 113.76,111.43 112.26,109.93 v2(112.08,109.93)
  BOTTOM w0.165: VRAM2.U2 139.41,115.8 v2(139.41,115.81) ; U8.AA23 112.48,109.53 v2(112.08,109.93)
VMA_DQ48: length 19.8
  TOP w0.165: v2(130.61,115.8) 130.68,115.87 130.68,117.02 130.05,117.65 128.62,117.65 128.36,117.91 125.4,117.91 v1(124.54,117.06) 120.85,113.37 118.25,113.37 v2(118.12,113.5)
  BOTTOM w0.165: v2(118.12,113.5) 118.12,113.3 116.95,112.13 116.27,112.13 116.17,112.03 U8.AD27 ; v2(130.61,115.8) 130.61,115.8 VRAM2.F2
VMA_DQ49: length 18.8
  TOP w0.165: v2(127.41,115.88) 127.41,116.42 126.75,117.08 125.87,117.08 v1(124.31,115.52) 121.33,112.53 117.35,112.53 117.2,112.38 116.39,112.38 114.62,110.6 114.23,110.6 113.73,110.1 v2(113.73,109.93)
  BOTTOM w0.165: v2(113.73,109.93) U8.AB25 ; VRAM2.B2 127.81,115.48 v2(127.41,115.88)
VMA_DQ50: length 20.6
  TOP w0.165: v2(129.83,115.8) 130.26,116.24 130.26,116.84 129.92,117.18 128.29,117.18 127.98,117.5 125.63,117.5 v1(122.9,114.76) 121.09,112.95 117.35,112.95 116.95,113.35 v2(116.95,113.52)
  BOTTOM w0.165: v2(116.95,113.52) 116.95,112.94 116.6,112.59 116.27,112.59 116.13,112.44 115.34,112.44 U8.AD26 ; VRAM2.E2 130.21,115.43 v2(129.83,115.8)
VMA_DQ51: length 15.5
  TOP w0.165: v2(117.03,111.62) 117.52,112.11 121.56,112.11 v1(122.73,113.28) 125.35,115.9 126.39,115.9 v2(126.45,115.96)
  BOTTOM w0.165: v2(126.45,115.96) VRAM2.A2 ; U8.AC25 114.58,110.73 115.03,110.73 115.36,111.06 116.6,111.06 117.03,111.49 v2(117.03,111.62)
VMA_DQ52: length 14.2
  TOP w0.165: v2(116.52,110.22) 116.99,110.69 122.13,110.69 v1(123.6,112.16) 125.28,113.83 126.98,113.83 v2(127.42,113.4)
  BOTTOM w0.165: U8.AA27 116.42,110.22 v2(116.52,110.22) ; v2(127.42,113.4) 127.42,113.41 VRAM2.B4
VMA_DQ53: length 14.6
  TOP w0.165: v2(126.58,113.4) 126.57,113.4 125.5,113.4 v1(124.88,112.78) 121.81,109.71 118.27,109.71 v2(117.77,110.22)
  BOTTOM w0.127: 116.15,109.45 115.88,109.17 115.56,109.17 115.2,109.53 U8.AA26
  BOTTOM w0.165: v2(126.58,113.4) 126.58,113.42 126.96,113.8 VRAM2.A4 ; 116.15,109.45 116.99,109.45 v2(117.77,110.22)
VMA_DQ54: length 17.8
  TOP w0.165: v2(117.49,108.96) 117.74,109.21 121.96,109.21 v1(123.62,110.87) 125.46,112.7 128.92,112.7 129.61,113.4 v2(129.83,113.4)
  BOTTOM w0.102: U8.W26 115.3,108.22 116.75,108.22 v2(117.49,108.96)
  BOTTOM w0.165: VRAM2.E4 130.21,113.77 v2(129.83,113.4)
VMA_DQ55: length 19.6
  TOP w0.165: v2(130.61,113.4) 130.6,113.4 129.49,112.28 125.69,112.28 v1(124.8,111.39) 121.85,108.44 116.73,108.44 v2(116.22,108.96)
  BOTTOM w0.127: v2(116.22,108.96) 116.11,108.84 115.46,108.84 115.25,109.05 114.49,109.05 U8.Y25
  BOTTOM w0.165: v2(130.61,113.4) 130.61,113.4 VRAM2.F4
VMA_DQ56: length 13.9
  BOTTOM w0.165: U8.R26 115.2,104.57 115.57,104.94 115.84,104.94 116.49,105.6 118.2,105.6 118.39,105.4 119.1,105.4 119.18,105.48 v1(122.26,105.48) 125.93,105.48 126.65,106.21 127.42,106.21 VRAM2.B13
VMA_DQ57: length 14.1
  BOTTOM w0.165: U8.T25 114.53,104.97 115.06,104.97 115.3,105.21 115.3,105.68 115.49,105.87 116.23,105.87 116.35,105.98 118.21,105.98 118.37,105.82 118.85,105.82 119.06,106.03 v1(121.09,106.03) 125.87,106.03 126.44,106.6 VRAM2.A13
VMA_DQ58: length 17.6
  BOTTOM w0.127: U8.N27 115.88,103.04 117.21,103.04
  BOTTOM w0.165: VRAM2.F13 130.62,106.21 130.62,105.52 130.74,105.4 130.74,105.14 130.15,104.55 127.36,104.55 127.19,104.38 v1(120.97,104.38) 119.27,104.38 118.97,104.08 118.25,104.08 117.21,103.04
VMA_DQ59: length 16
  BOTTOM w0.165: VRAM2.E13 129.81,106.2 129.81,105.47 129.3,104.97 v1(123.51,104.97) 118.41,104.97 118.05,105.33 116.6,105.33 115.84,104.57 U8.R27
VMA_DQ60: length 13.2
  BOTTOM w0.165: VRAM2.A11 126.64,108.57 v1(120.33,108.57) 119.5,108.57 117.71,106.78 116,106.78 115.9,106.68 115.5,106.68 115.12,107.05 U8.V26
VMA_DQ61: length 14
  BOTTOM w0.165: U8.V27 117.39,107.05 119.8,109.46 v1(123.12,109.46) 127.25,109.46 127.42,109.29 127.42,108.59 VRAM2.B11
VMA_DQ62: length 18.1
  BOTTOM w0.165: U8.W27 117,107.85 119.75,110.6 v1(120.58,110.6) 129.86,110.6 130.64,109.82 130.64,108.57 VRAM2.F11
VMA_DQ63: length 18.6
  BOTTOM w0.102: VRAM2.E11 129.77,108.64 129.77,109.12 129.47,109.42
  BOTTOM w0.165: U8.W25 114.55,107.43 117.17,107.43 119.84,110.1 v1(121.85,110.1) 129.01,110.1 129.47,109.64 129.47,109.42
VMA_WCK01: length 37.3
  IN3 w0.089: v2(137.81,86.21) 137.57,86.44 137.45,86.44 136.59,85.58 136.59,85.2 135.6,84.21 127.55,84.21 122.42,89.34 113.7,89.34 109.12,93.92 108.41,93.92 108.13,94.19 v2(107.91,94.19)
  BOTTOM w0.102: U8.D18 108.01,95.09 108.01,94.29 v2(107.91,94.19) ; v2(137.81,86.21) 137.41,85.81 VRAM1.D4
VMA_WCK01#: length 37.3
  IN3 w0.089: v2(137.81,87.01) 137.43,86.62 137.37,86.62 136.41,85.66 136.41,85.28 135.52,84.39 127.62,84.39 122.5,89.51 113.77,89.51 109.19,94.09 108.48,94.09 108.4,94.18 108.4,94.57 108.77,94.94 v2(108.77,95.01)
  BOTTOM w0.102: U8.C18 108.22,94.76 108.22,94.91 108.32,95.01 v2(108.77,95.01) ; VRAM1.D5 137.41,86.61 v2(137.81,87.01)
VMA_WCK23: length 27.9
  IN3 w0.089: v2(107.08,95.02) 107.29,95.24 108.26,95.24 108.51,95.49 109.03,95.49 109.41,95.11 109.41,94.65 111.23,92.82 112.58,92.82 112.91,92.49 112.91,91.61 114.45,90.07 123.59,90.07 127.06,86.61 128.61,86.61 v2(129.01,86.21)
  BOTTOM w0.102: U8.D17 107.48,95.43 v2(107.08,95.02) ; v2(129.01,86.21) 129.01,86.2 VRAM1.P4
VMA_WCK23#: length 28
  IN3 w0.089: v2(129.01,87.01) 128.79,86.78 127.13,86.78 123.66,90.25 114.52,90.25 113.09,91.68 113.09,92.57 112.66,93 111.31,93 109.59,94.72 109.59,95.18 109.1,95.67 108.44,95.67 108.18,95.41 107.5,95.41 v2(107.11,95.8)
  BOTTOM w0.102: VRAM1.P5 129.22,86.6 129.01,86.81 v2(129.01,87.01) ; U8.D16 106.74,95.43 v2(107.11,95.8)
VMA_WCK45: length 35.1
  IN3 w0.089: v2(112.96,105.78) 113.22,106.03 113.22,106.16 112.91,106.47 112.91,107.63 113.4,108.11 114.11,108.11 114.34,107.89 114.82,107.89 115.45,108.52 115.45,108.97 116.19,109.71 117.79,109.71 118.63,110.55 118.63,111.75 119.51,112.63 121.09,112.63 125.79,117.33 130.74,117.33 132.27,115.81 133.16,115.81 133.58,115.39 135.86,115.39 136.59,114.66 136.59,113.41 136.68,113.32 136.93,113.32 v2(137.01,113.41)
  BOTTOM w0.102: U8.T24 113.33,105.68 113.23,105.78 v2(112.96,105.78) ; v2(137.01,113.41) 137.41,113.8 VRAM2.P4
VMA_WCK45#: length 35.1
  IN3 w0.089: v2(137.01,112.61) 137.01,112.85 136.71,113.14 136.6,113.14 136.41,113.34 136.41,114.59 135.79,115.21 133.5,115.21 133.08,115.63 132.2,115.63 130.67,117.16 125.87,117.16 121.17,112.46 119.59,112.46 118.81,111.68 118.81,110.48 117.86,109.54 116.27,109.54 115.63,108.9 115.63,108.44 114.9,107.71 114.26,107.71 114.03,107.94 113.47,107.94 113.09,107.56 113.09,106.54 113.4,106.23 113.4,105.98 113.57,105.8 v2(113.75,105.8)
  BOTTOM w0.102: v2(137.01,112.61) 137.41,113 VRAM2.P5 ; v2(113.75,105.8) 113.74,105.8 U8.U24
VMA_WCK67: length 20
  IN3 w0.089: v2(113.73,107.45) 114.08,107.1 116.45,107.1 117.79,108.44 118.68,108.44 124.32,114.08 128.43,114.08 128.77,113.75 128.87,113.75 129.01,113.89 v2(129.01,114.21)
  BOTTOM w0.102: v2(129.01,114.21) 129.41,113.81 VRAM2.D4 ; U8.V24 v2(113.73,107.45)
VMA_WCK67#: length 19.9
  IN3 w0.089: v2(128.99,113.4) 128.81,113.57 128.69,113.57 128.36,113.91 124.39,113.91 118.75,108.27 117.87,108.27 116.52,106.92 114.02,106.92 v2(113.72,106.62)
  BOTTOM w0.102: VRAM2.D5 129.39,113 v2(128.99,113.4) ; U8.V25 113.82,107.05 113.72,106.95 v2(113.72,106.62)
VR_READY: length 3.9
  BOTTOM w0.203: PU7000.38 142.43,56.27 142.57,56.41 142.57,57.32 142.12,57.77 142.12,59.07 PR7067.2
VR_SVID_ALERT#_VCORE: length 50.2
  TOP w0.102: PR7002.2 139.74,60.94 v2(139.89,61.09)
  IN1 w0.089: v2(104.66,69.12) 105.17,69.12 106.06,68.24 109.55,68.24 110.3,68.99 113.09,68.99 117.26,73.16 119.22,73.16 121.56,70.81 123.06,70.81 124.62,72.37 129.58,72.37 130.79,71.16 130.79,69.88 133.28,67.39 133.28,63.9 134.27,62.9 136.85,62.9 138.35,61.4 139.58,61.4 v2(139.89,61.09)
  BOTTOM w0.102: R64.2 104,69.79 v2(104.66,69.12) 105.21,69.67 R63.1 ; v2(139.89,61.09) 139.73,60.93 139.73,60.61 PR7020.2
VR_SVID_CLK_R: length 4.4
  BOTTOM w0.079: U1.AA1 99.58,67.42 100.56,68.4 R66.1
VRON: length 108.7
  TOP w0.102: v2(201.81,17.61) 201.77,17.57 R25311.1 201.33,17.05 201.08,17.31 199.78,17.31 199.71,17.38 U37.69
  IN3 w0.089: v2(201.81,17.61) 200.98,17.61 200.7,17.89 200.7,19.9 200.09,20.51 200.09,21.21 200.6,21.72 200.6,22.92 199.52,24 199.52,24.69 199.15,25.06 199.15,25.81 198.68,26.28 197.59,26.28 197.35,26.53 195.9,26.53 195.56,26.87 195.14,26.87 194.86,27.14 193.58,27.14 193.34,27.39 193.34,28.2 191.45,30.09 188.04,30.09 186.93,31.2 186.93,31.43 185.85,32.52 183.71,32.52 182.8,31.6 175.75,31.6 175.54,31.81 174.36,31.81 173.97,32.2 171.99,32.2 171.58,31.79 169.67,31.79 168.97,32.49 164.62,32.49 162.12,34.99 156.34,34.99 156.04,34.69 153.23,34.69 152.86,35.06 149.41,35.06 149.31,34.97 149,34.97 147.82,33.78 147.1,33.78 146.61,33.3 144.99,33.3 144.79,33.49 144.79,35.42 144.99,35.62 144.99,39.48 143.7,40.77 143.7,42.49 144.71,43.5 144.71,44.92 145.1,45.3 145.1,46.32 147.05,48.27 147.05,53.87 145.6,55.32 145.6,56.39 145.1,56.89 145.1,57.39 144.63,57.85 144.63,59.38 144.16,59.85 144.16,61.25 142.97,62.44 v2(142.97,62.83)
  BOTTOM w0.102: PR7025.2 v2(142.97,62.83)
VSEN_CORE: length 44.3
  TOP w0.102: v2(120.28,50.76) 120.28,51.14 119.19,52.24 PR7044.2 ; v1(142.76,52.08) 142.78,52.1 144.24,52.1 PC7007.1 145.18,52.13 145.67,52.13 PC7008.2
  IN1 w0.089: v1(142.76,52.08) 139.66,52.08 136.84,49.26 132.01,49.26 130.86,48.11 121.36,48.11 120.97,48.5 120.97,50.07 v2(120.28,50.76)
  IN3 w0.089: v1(142.76,52.08) 143.04,51.8 143.72,51.8 144.34,51.19 144.34,49.34 142.76,47.76 142.76,47.38 142.38,47 v1(142.28,47)
  BOTTOM w0.102: v1(144.64,44.97) 144.64,45.17 143.78,46.03 PC7010.1 143.5,46.42 143.45,46.46 PR7047.2 142.82,46.46 v1(142.28,47) ; PU7000.47 142.39,52.67 142.57,52.49 142.57,52.27 v1(142.76,52.08)
VSEN_GT: length 63
  TOP w0.102: PR7051.2 103.63,78.8 v2(104,78.8) ; PC7013.1 137.08,58.61 136.71,58.61 136.4,58.92 v1(136.13,58.92) PC7014.2 134.69,58.92 v1(134.55,58.79)
  IN1 w0.089: v1(134.55,58.79) 134.15,58.38 118.49,58.38 118,58.86 115.78,58.86 114.23,60.41 111.52,60.41 108.57,63.36 104.84,63.36 103.74,64.45 103.74,67.47 102.7,68.52 102.7,71.17 103.52,71.99 103.52,74.56 103.24,74.84 103.24,78.14 103.44,78.35 103.54,78.35 v2(104,78.8)
  BOTTOM w0.102: PU7000.27 137.35,58.23 136.92,58.66 134.68,58.66 v1(134.55,58.79) 134.05,59.3 132.43,59.3 132.09,58.96 132.09,57.74 PR7054.2 PC7016.2
VSEN_SA: length 39.3
  TOP w0.102: v1(118.76,43.9) 118.58,43.9 118.45,43.78 PR7058.2
  IN1 w0.089: v1(118.76,43.9) 118.76,44.39 120.12,45.74 130.63,45.74 131.53,46.65 132.95,46.65 134.17,47.87 137.53,47.87 138.8,49.14 140.27,49.14 140.79,49.66 142.06,49.66 143.72,47.99 144.33,47.99 145.4,49.06 145.4,52.67 v1(145.55,52.82)
  BOTTOM w0.102: PC7020.2 145.6,51.34 PR7059.2 PC7019.1 144.6,52.36 PC7022.2 145.05,52.82 v1(145.55,52.82)
VSTBY_FSPI: length 25.5
  TOP w0.102: R25330.2 180.09,30.54 179.11,31.52 R359.2 178.9,31.52 178.18,32.24 177.17,32.24 176.85,32.56 v2(176.85,32.88) ; v2(193.64,31.05) 193.65,31.04 U37.106
  IN2 w0.089: v2(193.64,31.05) 193.47,30.89 192.25,30.89 191.93,31.21 191.93,31.89 191.77,32.05 191.56,32.05 190.55,33.06 188.24,33.06 187.5,32.32 185.43,32.32 185,32.75 183.01,32.75 182.05,31.79 180.92,31.79 180.54,32.17 178.44,32.17 177.74,32.88 v2(176.85,32.88)
WIGIG_LED: length 5.3
  BOTTOM w0.102: TP9029.1 191.78,32.14 190.16,32.14 189.75,31.73 189.75,30.13 190,29.88 CN17.6
WLAN_RST#: length 13.7
  TOP w0.102: R2665.1 178.73,18.83 178.75,18.8 179.67,18.8 v2(179.97,19.11)
  IN2 w0.089: v2(189.57,18.57) 189.57,18.76 189.17,19.16 187.6,19.16 186.87,18.42 180.46,18.42 179.97,18.91 v2(179.97,19.11)
  BOTTOM w0.102: CN17.52 189.76,18.38 v2(189.57,18.57)
WLANPWR#: length 5.1
  TOP w0.102: TP2090.1 187.56,10.51 187.56,11.01 187.21,11.37 187.21,12.84 186.85,13.19 185.77,13.19 185.65,13.32 U37.35
WRST#: length 10.3
  TOP w0.102: U37.14 182.38,22.98 182.13,23.23 181.5,23.23 181.07,22.8 179.47,22.8 C6571.1 177.7,21.82 R25300.1 176.99,22.47 176.44,23.02 176.44,23.4 176.85,23.81 v1(176.85,23.84) 176.52,23.84 176.12,24.24 D63.2
XCLK_BIASREF: length 10.1
  BOTTOM w0.102: R145.1 101.44,31.2 v1(101.26,31.38) 100.93,31.71 100.93,33.26 100.34,33.84 100.34,34.83 98.94,36.23 98.94,37.76 98.33,38.37 97.61,38.37 U1.CJ1
XDP_BPM0: length 1.5
  TOP w0.102: TP23.1 97.87,69.83 v2(97.9,69.83)
  BOTTOM w0.079: U1.U1 97.86,69.86 v2(97.9,69.83)
XDP_BPM1: length 2.9
  TOP w0.102: TP25.1 98.72,68.97 v2(98.61,69.07)
  BOTTOM w0.079: v2(98.61,69.07) 98.22,69.47 97.45,69.47 97.36,69.56 97.07,69.69 96.9,69.86 U1.U2
XDP_PRDY#_CPU: length 6.6
  BOTTOM w0.079: U1.W2 96.72,68.48 97,68.21 99.3,68.21 100.5,69.41 100.5,69.75 100.6,69.84 100.6,70.73 TP24.1
XDP_PREQ#_CPU: length 7.5
  BOTTOM w0.079: U1.W1 97.48,68.44 99.29,68.44 100.33,69.48 100.33,69.82 100.43,69.91 100.43,70.89 100.6,71.06 100.6,71.37 100.93,71.7 101.52,71.7 101.81,72
  BOTTOM w0.102: TP22.1 101.99,72.17 101.81,72
XDP_TCK0: length 12.4
  TOP w0.102: v2(94.42,70.39) 94.78,70.04 95.87,70.04 95.95,69.96 96.99,69.96 97.67,70.65 TP52.1 98.23,70.52 100.34,70.52 100.6,70.78 100.6,71.23 100.29,71.54 100.29,72.35 100.61,72.67 100.61,72.93 101.35,73.68 101.54,73.68 101.81,73.95 R24.2 R7.2
  BOTTOM w0.102: v2(94.42,70.39) 94.42,70.46 U1.T6
XDP_TDI_CPU: length 11.6
  TOP w0.102: v2(93.68,69.37) 94.08,69.37 94.55,69.84 95.52,69.84 95.72,69.63 97.04,69.63 97.62,70.21 100.6,70.21 101,70.61 101,71.4 100.75,71.66 R3.2 101.02,71.8 101.18,71.64 101.51,71.64 101.97,72.1 R19.2
  BOTTOM w0.102: v2(93.68,69.37) 93.71,69.4 93.73,69.4 94.03,69.69 U1.U6
XDP_TDO_CPU: length 14.7
  TOP w0.102: R22.1 106,70.32 105.8,70.52 105.8,70.85 105.73,70.93 v1(105.42,70.93) 105.27,70.93 104.79,70.45 104.38,70.45 104.1,70.73 104.1,70.88 103.88,71.09 103.3,71.09 102.88,70.68 R4.2 102.63,70.29 100.63,68.29 95.21,68.29 v2(94.91,68.59)
  BOTTOM w0.102: v2(94.91,68.59) 94.68,68.35 U1.Y5
XDP_TMS_CPU: length 14.7
  TOP w0.102: v2(95.01,70.42) 95.39,70.8 95.39,72.11 96.4,73.12 96.4,73.52 96.76,73.87 arc(96.76,73.87) 96.76,73.88 96.76,75.75 97.07,76.06 98.08,76.06 98.28,76.26 98.28,76.41 98.59,76.72 100.55,76.72 101.43,75.83 102.24,75.83 102.49,76.09 R5.2 102.78,76.09 103.38,75.49 R15.2
  BOTTOM w0.102: U1.T5 94.68,70.75 v2(95.01,70.42)
XDP_TRST#_CPU: length 14.3
  TOP w0.102: v2(93.86,67.63) 94.02,67.47 97.01,67.47 97.32,67.78 101.27,67.78 102.97,69.48 R6.1 103.92,69.48 103.97,69.53 104.81,69.53 105.02,69.74 R25.2 106.54,69.74 v1(106.64,69.63)
  BOTTOM w0.102: U1.Y6 94.03,67.79 v2(93.86,67.63)
XTAL1: length 2.3
  TOP w0.102: R511.2 45.27,108.94 45.27,108.57 44.84,108.14 U24.28
XTAL2: length 2.1
  TOP w0.102: U24.29 44.44,108.12 44.77,108.44 v1(44.77,108.65) R512.1
XTAL24_IN: length 8.7
  BOTTOM w0.079: 98.28,35.75 98.43,35.9 98.43,36.59 98.28,36.74 97.65,36.74 97.1,37.29 96.82,37.29 96.51,36.97 96.16,36.97 U1.CK3
  BOTTOM w0.102: 98.28,35.75 98.28,34.81 98.75,34.34 98.75,32.62 99.22,32.14 99.22,31.85 R166.1
XTAL24_IN_C: length 3.9
  BOTTOM w0.102: R166.2 99.08,30.71 99.27,30.52 99.27,30.04 R167.1 98.99,29.51 99.21,29.28 99.44,29.28 99.56,29.16 C205.2 99.56,28.37 99.46,28.27 Y2.1
XTAL24_OUT: length 8.7
  BOTTOM w0.079: U1.CK2 96.63,37.45 97.06,37.88 97.58,37.88 97.86,37.59 98.07,37.59 98.6,37.06 98.6,35.03 98.99,34.64
  BOTTOM w0.102: R168.1 99.83,32.4 99.25,32.98 99.25,34.38 98.99,34.64
XTAL24_OUT_C: length 5.1
  BOTTOM w0.102: Y2.3 100.51,26.54 100.14,26.91 100.14,28.05 100.51,28.43 C208.2 99.77,29.53 R167.2 99.83,29.82 R168.2
XTAL_SSIN: length 7.4
  BOTTOM w0.102: U8.A10 101.71,92.93 101.38,92.6 101.38,91.59 100.46,90.66 100.03,90.66 98.8,89.43 98.8,87.92 R331.1
N06325: length 6.4
  TOP w0.102: v2(79.06,21.3) 78.84,21.08 R573.2 78.05,21.08 77.56,21.58 R25471.1 77.16,21.2 77.02,21.07 76.52,21.07 76.38,20.93 R25473.2
  BOTTOM w0.102: Q29.3 80.89,21.68 v1(80.5,21.3) v2(79.06,21.3)
N16824426: length 2
  BOTTOM w0.102: R323.2 R324.2 101.03,119.37 U11.2
N17002655: length 3
  BOTTOM w0.203: U20.39 208.36,34.03 208.87,34.53 209.13,34.53 209.36,34.76 209.36,35.64 C572.2
N17002661: length 5.6
  BOTTOM w0.102: U20.37 207.76,35.22 v1(208.21,35.67) 208.67,36.13 208.67,39.1 208.59,39.19 C566.2
N17002676: length 1.9
  BOTTOM w0.102: C567.1 206.54,37.21 206.54,36.79 206.06,36.31 U20.34
N17002678: length 2.3
  BOTTOM w0.203: U20.19 201,32.82 200.95,32.88 200.7,32.88 200.16,33.41 C573.1
N17002722: length 4.7
  TOP w0.102: R453.2 208.96,29.85 v1(209.61,29.2) 209.61,28.9 R454.2
  BOTTOM w0.102: U20.48 208.18,30.43 208.34,30.26 208.34,29.73 v1(208.49,29.58) 208.55,29.63 209.18,29.63 v1(209.61,29.2)
N17002952: length 2.5
  BOTTOM w0.102: U20.7 204.46,28.86 204.56,28.76 204.56,28.36 204.13,27.93 203.69,27.93 C578.1
N17002968: length 7.5
  BOTTOM w0.102: U20.11 202.86,28.79 202.75,28.69 202.37,28.69 201.34,27.66 R739.1 200.96,27.66 200.83,27.52 200.83,27.19 200.64,27 200.64,26.72 200.42,26.5 199.96,26.5 199.55,26.1 v1(199.55,25.92) 199.32,25.92 199.15,26.1 R741.1 198.86,25.56 198.64,25.34 R738.1
N17002995: length 6.7
  BOTTOM w0.102: U20.12 202.46,29.1 201.59,28.23 200.93,28.23 200.59,27.9 200.59,27.35 C846.1 199.64,26.93 v1(199.35,27.21) 198.99,27.21 198.94,27.16 R742.1 198.66,27.39 199.13,27.86 R740.1
N17003129: length 5.1
  BOTTOM w0.102: U20.35 206.46,36.19 206.74,36.47 206.88,36.47 207.33,36.92 207.33,38.34 207.88,38.9 207.88,39.33 207.39,39.83 C566.1
N17003186: length 4.5
  BOTTOM w0.102: R450.1 199.09,34.8 v1(199.96,35.67)
  BOTTOM w0.203: R450.1 199.09,34.62 199.81,33.9 200.14,33.9 200.81,33.22 U20.20
N17004316: length 4.6
  BOTTOM w0.102: D12.1 200.08,22.5 201.21,21.36 Q21.3 201.21,19.71 v1(201.69,19.24)
N17046941: length 6.9
  TOP w0.508: v1(104.43,16.98) 104.58,16.83 104.58,16.77 v1(105.11,16.24) PR13.1
  BOTTOM w0.508: PJ1.3 105.45,20.77 104.39,19.71 104.39,17.02 v1(104.43,16.98)
N17047007: length 3
  TOP w0.152: PR1.1 51.78,114.28 51.78,116.11 51.57,116.32 PR3.1
  vias: v1(51.09,118.71)
N17047009: length 2.6
  BOTTOM w0.178: PU1.20 133.42,27.48 133.23,27.29 131.63,27.29 PR5.1
N17047028: length 3.3
  BOTTOM w0.178: PR6.1 131.73,26.99 132.14,26.99 v1(132.35,26.78) 132.55,26.99 133.36,26.99 133.82,27.45 PU1.19
N17047083: length 3.1
  TOP w0.102: v2(101.41,20.15) 101.04,20.53 PR14.1 101.46,20.81 v1(101.87,21.22)
  BOTTOM w0.102: v2(101.41,20.15) 101.45,20.2 PJ1.5
N17047087: length 25.1
  TOP w0.508: PR7.1 129.25,26.16 129.25,26.76 128.74,27.27 128.1,27.27 127.47,26.63 123.02,26.63 122.66,26.27 PC17.1 120.27,26.27 119.7,25.69 118.25,25.69
  BOTTOM w0.152: 112.13,24.91 111.71,25.33 111.71,26.85 111.87,27.01 PR209.1
  BOTTOM w0.203: 112.13,24.91 112.37,24.67 118.62,24.67 118.9,24.95 120.03,24.95 PR210.2
  vias: v1(113.27,25.41) v1(113.93,26.15) v1(113.9,25.41) v1(114.54,25.41) v1(115.17,25.41) v1(115.81,25.41) v1(116.44,25.41) v1(117.08,25.41) v1(117.71,25.41) v1(118.35,25.41)
N17047112: length 160.4
  TOP w0.508: PQ1.4 44,121.4 PC1.2 44.6,121.34 44.82,121.55 45.13,121.55 PC2.2 45.86,122.28 v1(45.86,122.36) ; PQ9054.4 v1(44.85,116.77)
  IN2 w0.406: v1(44.85,116.77) 53.71,116.77 54.88,115.61 62.2,115.61 67.75,110.05 67.75,106.92 70.73,103.95 72.88,103.95 73.29,104.36 75.13,104.36 75.72,103.77 76.37,103.77 77.12,103.01 81.25,103.01 83.46,100.8 86.2,100.8 88.47,98.54 89.52,98.54 90.99,97.06 90.99,91.81 96,86.81 96,85.27 97.36,83.91 100.98,83.91 102.22,82.66 102.6,82.66 103.03,82.23 103.16,82.23 103.19,82.21 103.19,82.21 103.52,81.88 103.52,81.88 104.68,80.71 104.68,78.78 105.47,77.99 105.47,77.19 106.21,76.45 106.21,75.6 106.72,75.09 112.81,75.09 113.22,74.69 113.22,73.01 114.01,72.22 114.01,68.16 116.71,65.45 116.71,62.06 116.01,61.36 116.01,54.46 115.73,54.18 115.73,53.07 116.39,52.41 116.39,51.15 118.81,48.74 118.81,46.98 119.34,46.44 119.34,41.85 120.43,40.76 120.43,40.17 121.12,39.48 121.12,38.69 122.24,37.57 124.05,37.57 125.03,36.59 v2(125.16,36.59)
  BOTTOM w0.406: v2(125.16,36.59) 125.16,36.56 125.21,36.51 125.21,35.7 125.82,35.09 133.74,35.09 134.56,34.26 PR29.1
  BOTTOM w0.508: v1(44.85,116.77) 45.86,117.78 v1(45.86,122.36)
N17047335: length 3.8
  BOTTOM w0.508: PC19.1 126.93,27.04 v1(126.58,27.04) 125.66,27.04 124.95,26.33 PR33.2
N17047399: length 1.4
  BOTTOM w0.508: PC15.2 PR11.2
N17047425: length 7.3
  TOP w0.508: v1(103.45,16.98) 103.41,16.94 v1(103.41,15.51) 102.62,14.72 PR12.1
  BOTTOM w0.508: PJ1.4 v1(103.45,16.98)
N17047601: length 12.7
  TOP w0.508: PR4.1 130.27,27.69 129.83,28.13 127.87,28.13 127.01,27.27 v1(121.75,27.27) 120.68,27.27 PC17.2 120.04,27.05 119.43,26.44 PQ2.4
N17398787: length 1.6
  TOP w0.203: PR30.2 134.78,32.73 v1(134.65,32.86)
  BOTTOM w0.178: PU1.5 134.62,32.84
  BOTTOM w0.203: 134.62,32.84 v1(134.65,32.86)
N17424918: length 2.3
  BOTTOM w0.178: PU1.11 136.76,29.91 136.94,29.73 137.09,29.73 137.32,29.5 137.68,29.5 138.09,29.91 PR19.2
N17424920: length 2
  BOTTOM w0.178: PU1.12 136.65,29.51 136.75,29.41 136.98,29.41 137.2,29.2 137.83,29.2 137.93,29.3 PR17.2
N17424921: length 1.5
  BOTTOM w0.178: 135.42,32.5 PU1.7
  BOTTOM w0.203: PR32.2 135.69,32.76 135.42,32.5
N17424925: length 1.6
  BOTTOM w0.198: 136.87,30.87 136.7,30.71 PU1.9
  BOTTOM w0.203: 136.87,30.87 136.87,31.12 PR25.2
N17424950: length 2.1
  TOP w0.178: PR8.2 136.52,28.99 136.38,28.85 136.38,28.8 136.37,28.79 136.37,28.78 136.13,28.54 PR205.2 135.98,28.1 v2(136,28.08)
  BOTTOM w0.178: PU1.15 135.73,27.91 135.88,28.05 135.95,28.05 135.98,28.08 v2(136,28.08)
N17661815: length 1.7
  BOTTOM w0.198: 136.56,31.71 136.22,31.37 PU1.8
  BOTTOM w0.203: 136.56,31.71 136.66,31.71 137.2,32.25 PR26.2
N18867651:
  vias: v1(153.17,24.01)
N18867812:
  vias: v1(20.64,29.65)
N18922914: length 1.2
  BOTTOM w0.381: U8.AA8 v2(100.51,109.97) 100.9,109.59 U8.AA9
  vias: v1(97.6,108.22)
N19138106: length 1.5
  TOP w0.102: v2(111.33,96.66) 111.27,96.66 110.82,97.11 R321.2
  BOTTOM w0.102: v2(111.33,96.66) 111.63,96.95 U8.F22
N19138109: length 2.2
  TOP w0.102: v2(112.11,99.19) 111.88,99.19 111.47,99.6 111.01,99.6 110.83,99.79 R322.2
  BOTTOM w0.102: U8.J22 v2(112.11,99.19)
N19521323: length 4
  TOP w0.102: PR6006.1 143.91,31.02 144.33,30.59 v1(144.33,30.21) 144.33,29.98 144.03,29.68 142.63,29.68 142.3,30.01 PQ6000.3
N19521733: length 7.3
  TOP w0.102: PR6012.1 142.26,30.97 142.05,30.97 141.77,30.69 141.77,29.88 141.92,29.73 141.92,28.89 PQ6000.2 141.59,28.08 PR9269.1 141.48,27.3 141.24,27.55 140.88,27.55 140.75,27.67 PR9268.1 140.5,28.18 v1(140.22,28.46)
N19549602: length 6.9
  TOP w0.102: PR9271.1 PR9270.1 46.83,12.38 v1(46.29,12.91) 46.21,12.99 46.21,15.38 PQ6001.2 44.6,15.92 PR6024.1
N20380930: length 2.2
  TOP w0.102: v2(81.35,45.66) 81.6,45.41 81.6,44.61 81.45,44.46 R44.2
  BOTTOM w0.079: v2(81.35,45.66) 81.3,45.66 80.99,45.97 U1.BT27
N20513971: length 1.4
  TOP w0.102: R220.2 113.6,21.3 TP54.1
N20681162: length 14.7
  TOP w0.079: v2(77.91,42.89) 77.6,43.2 77.11,43.2 76.58,43.73 76.06,43.73 75.63,43.29 75.25,43.29
  TOP w0.102: 75.25,43.29 66.42,43.29 R25494.2 65.88,42.24 65.59,41.95 v1(65.29,41.95)
  BOTTOM w0.079: v2(77.91,42.89) 78.36,43.33 U1.BY31
N20858957: length 2
  TOP w0.102: v1(50.18,44.13) 50.15,44.13 49.82,44.46 49.82,44.93 C266.2
  TOP w0.508: R244.2 49.85,44.95 C266.2
N20946170: length 4.2
  TOP w0.102: R245.1 41.07,35.92 42.89,37.73 42.89,38.1 U4.E9
N20946459: length 3.8
  TOP w0.102: R247.1 44.01,69.88 43.62,70.27 v1(43.62,70.3) 43.62,71.11 43.07,71.66 U7.E9
N20946794: length 3.6
  TOP w0.102: R246.1 43,48.64 43.39,49.03 43.39,51.11 U5.E9
N20947128: length 4.3
  TOP w0.102: U6.E9 45.28,83.94 v1(45.28,83.66) R248.1
N21263014: length 17.8
  TOP w0.102: v2(101.3,95.82) 101.3,95.69 100.8,95.2 100.21,95.2 99.96,95.44 99.46,95.44 98.08,94.07 95.29,94.07 93.41,92.19 90.13,92.19 89.6,91.65 89.11,91.65 88.71,92.06 87.95,92.06 87.82,92.19 TP65.1
  BOTTOM w0.102: U8.E10 v2(101.3,95.82)
N21263017: length 15.6
  TOP w0.102: TP66.1 94.3,91.68 96.33,93.71 100.65,93.71 102.04,95.11 102.04,95.87 v2(101.28,96.63)
  BOTTOM w0.102: U8.F10 101.71,97.06 v2(101.28,96.63)
N22413276: length 19.5
  TOP w0.381: v2(114.51,38.37) v1(115.4,38.37) 115.63,38.37 115.82,38.17 116.1,38.17 116.86,37.42 PQ25.2
  IN2 w0.381: v2(111.01,42.15) 111.29,42.15 114.51,38.93 v2(114.51,38.37)
  BOTTOM w0.381: v2(111.01,42.15) 110.49,42.67 PR79.2 110.15,42.86 109.56,43.45 PQ7.3 107.39,45.57 PQ10.2 108.76,45.57 109.05,45.86 109.82,45.86 109.95,46 PR80.1
N22413302: length 1.8
  TOP w0.508: v1(110.12,47.08) PR105.2
  BOTTOM w0.508: PQ10.3 109.56,46.52 v1(110.12,47.08)
N22415444:
  vias: v1(110.5,39.69) v1(110.5,39.05) v1(110.53,38.42) v1(110.53,37.78) v1(110.53,37.15) v1(110.53,36.51) v1(110.65,35.52) v1(111.16,39.69) v1(111.16,39.05) v1(111.19,38.42) v1(111.19,37.78) v1(111.19,37.15) v1(111.19,36.51)
N22415644: length 15.3
  TOP w0.203: v2(111.92,33.06) 111.9,33.03 PR9259.1
  IN2 w0.203: v1(122.95,34.92) 121.55,34.92 121.13,34.5 120.01,34.5 117.64,32.13 112.57,32.13 111.92,32.78 v2(111.92,33.06)
  BOTTOM w0.203: v1(122.95,34.92) 122.87,34.92 122.73,35.06 PR269.1 PC225.2
N22415652: length 3.3
  TOP w0.102: v1(113.82,32.2) 114.09,32.2 114.74,32.85 PC82.1
  TOP w0.508: PC82.1 115.49,33.31 v1(115.56,33.37)
  BOTTOM w0.508: PR99.2 v1(115.56,33.37)
N22415672: length 2.5
  TOP w0.102: v1(114.59,39.43) 114.84,39.43 115.23,39.82 PC235.2
  TOP w0.508: PC235.2 115.76,40.3 115.83,40.37 PR277.1
N22767382: length 9.4
  BOTTOM w0.079: 71.18,44.26 71.45,44.26 74.13,46.93 U1.BP36
  BOTTOM w0.102: 71.18,44.26 69.38,44.26 68.77,43.65 67.36,43.65 R84.2
N24359231: length 2.6
  BOTTOM w0.254: 132,45.78 132.36,46.14 PU7001.4
  BOTTOM w0.508: PC7056.2 132.25,44.82 132,45.07 132,45.78
N24359390: length 8.6
  IN3 w0.508: v1(132.65,45.71) 132.52,45.58 129.14,45.58 128.33,44.77 128.33,44.74 v1(128.28,44.69)
  BOTTOM w0.254: PU7001.3 132.86,45.91 v1(132.65,45.71)
  BOTTOM w0.508: v1(128.28,44.69) 128.05,44.46 v1(128.05,43.67) 128.05,43.51 128.56,43 PR7078.1
N24444747: length 41.6
  TOP w0.203: PR7031.1 133.54,54.67 133.55,54.68 PR7017.2 ; PR7018.1 134.78,55.42 133.81,55.42 PR7017.2 ; PR7017.2 133.55,55.16 133.08,55.63 132.32,55.63 131.99,55.31 v1(131.94,55.31)
  IN2 w0.203: v1(131.94,55.31) 132.47,55.31 133.67,56.5 133.67,59.95 133.33,60.29 133.33,62.1 132.6,62.83 132.6,67.81 132.19,68.21 130.03,68.21 125.89,72.35 125.89,74.51 127.06,75.68 127.06,76.82 127.44,77.2 127.44,77.96 126.33,79.08 124.57,79.08 123.56,80.1 123.56,81.23 v1(123.22,81.57)
  BOTTOM w0.203: PR7021.2 123.22,80.87 v1(123.22,81.57)
N24444757: length 2.2
  TOP w0.203: PC7023.1 v1(145.48,55.22)
  TOP w0.254: PC7023.1 144.59,55 143.94,54.36 PR7063.2
N24445360: length 6.5
  BOTTOM w0.203: PR7025.1 141.71,61.43 PC7005.1 141.43,59.1 141.79,58.75 141.79,58.35 141.29,57.85 141.29,56.86 141.47,56.67 PU7000.37
N24445593: length 6
  BOTTOM w0.203: PR7069.2 141.55,48.2 140.67,48.2 PR7066.2 139.67,48.95 138.89,48.95 138.15,49.7 PU7000.8
N24445614: length 34.2
  IN2 w0.203: v1(127.34,73.49) 127.32,73.47 127.32,73.19 127.57,72.93 129.2,72.93 133.82,68.31 133.82,63.71 134.07,63.46 135.49,63.46 136,62.95 136,60.54 136.64,59.9 136.64,57.39 136,56.76 136,51.22 136.49,50.74 v1(136.49,50.02)
  BOTTOM w0.203: PR7030.1 PR7016.2 136.23,48.47 135.77,48.93 PR7026.1 136.42,49.85 136.42,49.86 136.49,49.92 v1(136.49,50.02) ; v1(127.34,73.49) 127.29,73.44 127.29,72.86 126.95,72.52 PR7032.2
N24446268: length 1.7
  TOP w0.203: PR7038.1 v1(136.54,49.26) PR7037.2
N24459302: length 30.6
  IN3 w0.203: v2(130.75,59.27) 130.75,59.14 133.26,56.63 133.26,53.83 133.92,53.17 133.92,52.36 134.33,51.95 136.31,51.95 137.83,50.43 137.83,49.71 139.28,48.26 139.28,47.88 138.19,46.79 v1(138.19,45.12)
  BOTTOM w0.203: PR7073.2 125.82,62.11 125.41,61.71 125.41,60.18 126.43,59.17 129.09,59.17 129.65,59.73 130.36,59.73 130.75,59.35 v2(130.75,59.27) ; v1(138.19,45.12) PR7076.1
N24492000: length 2
  BOTTOM w0.102: PR7049.1 145.5,47.28 v1(145.6,47.38)
  BOTTOM w0.203: PR7049.1 144.43,47.63 PC7012.1
N24507636:
  vias: v1(168.84,23.13) v2(168.59,23.8) v2(169.31,23.8)
N24507642: length 6
  TOP w0.102: PR6418.2 PC9097.1 159.26,26.29 158.93,25.96 PR283.1 158.28,25.11 v1(158.48,24.9) 158.53,24.85 v2(159.29,24.85)
  BOTTOM w0.102: PU3003.6 160.26,24.2 160.01,24.45 159.69,24.45 v2(159.29,24.85)
N24507664: length 12.8
  TOP w0.102: v2(159.9,24.85) 160.36,25.31 PR6418.1 PC9097.2
  BOTTOM w0.102: v2(159.9,24.85) 161.37,24.85 161.8,24.42 162.2,24.42 162.86,25.08 163.58,25.08 163.7,25.21 163.7,25.55 164.3,26.15 167.57,26.15 168.03,25.69 PR6414.1
N24507676: length 12.7
  TOP w0.102: v2(166.84,25.51) 166.64,25.31 PC6229.2 167.19,23.72 167.19,23.07 166.56,22.44 166.56,21.25 166.36,21.04 166.36,20.34 165.9,19.89 165.9,19.19 165.69,18.98 165.69,18.64 PR6417.1 165.61,17.83 v1(165.72,17.72)
  BOTTOM w0.102: v2(166.84,25.51) 166.81,25.51 166.35,25.51 166.35,25.51 165.8,25.51 164.88,24.6 164.54,24.6 164.14,24.2 PU3003.1
