# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATLED1#: length 52.4
  TOP w0.102: v1(181.82,18.91) 182.1,18.91 182.43,18.59 182.98,18.59 182.99,18.58 U37.25 184.45,18.58 185.06,19.19 185.32,19.19 arc(185.32,19.19) 185.32,19.19 187.76,21.63 190.6,21.63 arc(190.61,21.63) 190.61,21.63 191.06,22.08 191.76,22.08 v2(191.93,22.26)
  IN1 w0.089: v2(206.49,26.58) 206.84,26.58 207.16,26.26 207.92,26.26 209.44,24.73 211.71,24.73 213.47,26.49 213.47,28.76 215.12,30.42 215.12,31.84 215.66,32.37 215.66,33.06 214.44,34.28 213.12,34.28 211.95,35.44 211.95,36.11 212.37,36.54 v2(212.37,36.64)
  IN2 w0.089: v2(206.49,26.58) 206.14,26.93 203.43,26.93 202.54,26.05 202.54,25.03 201.91,24.39 199.88,24.39 198.66,23.17 196.35,23.17 196.27,23.25 195.69,23.25 195.23,22.79 193.97,22.79 193.85,22.66 192.33,22.66 v2(191.93,22.26)
  BOTTOM w0.102: v2(212.37,36.64) 212.63,36.9 CN35.23
BI: length 133.5
  TOP w0.102: PR10.1 99.47,20.31 v2(99.63,20.15)
  IN2 w0.089: v1(25,51.42) 24.52,51.42 23.94,50.84 23.94,50.47 23.42,49.95 23.42,48.72 22.22,47.53 22.22,46.96 22.44,46.75 22.44,44.18 22.79,43.83 23.46,43.83 23.83,43.45 23.83,41.94 23.51,41.62 23.51,40.98 24.3,40.19 24.3,38.96 23.91,38.57 23.91,35.2 26.53,32.58 26.66,32.58 27.28,31.95 27.28,27.17 28.03,26.43 28.84,26.43 29.14,26.13 34.95,26.13 35.59,25.48 38.47,25.48 39.9,24.06 39.9,23.71 41.49,22.12 45.53,22.12 45.78,21.87 45.78,21.61 46.06,21.33 46.06,18.52 47.18,17.4 55.87,17.4 56.02,17.25 56.02,16.64 56.15,16.52 56.73,16.52 56.86,16.65 58.09,16.65 58.99,15.76 72,15.76 72.95,16.71 79.36,16.71 84.09,21.44 88.5,21.44 93.72,16.22 94.78,16.22 95.25,15.74 95.62,15.74 95.97,16.09 v2(97.34,16.09)
  IN3 w0.089: v2(97.34,16.09) 97.34,17.87 v2(99.63,20.15)
  BOTTOM w0.102: PJ1.6 99.45,20.33 v2(99.63,20.15) ; SW2.2 SW2.1 21.25,58.87 20.01,57.63 R25321.2 20.21,57.06 22.44,57.06 v1(22.67,57.29) 22.89,57.06 23.7,57.06 24.45,56.32 24.45,51.74 24.77,51.42 v1(25,51.42)
BIOS_WP#: length 10.9
  TOP w0.102: TP18.1 157.98,30.33 R112.1 158.95,30.33 159.17,30.11 v2(160.84,30.11) 160.84,29.83 160.74,29.73 160.01,29.73 159.75,29.48 R110.1
  BOTTOM w0.102: v2(160.84,30.11) 160.84,30.09 160.72,29.96 U2.3
BL#: length 21.2
  TOP w0.102: 56.58,101.21 56.73,101.05 57.08,101.05 57.23,101.19 Q6521.3 ; 56.58,101.21 Q6521.2 ; 56.58,101.21 55.76,100.39 55.76,100.11 55.54,99.88 53.91,99.88 53.73,100.06 53.73,100.87 52.66,101.94 v1(52.46,101.94) 51.23,101.94 50.66,102.51 50.66,103.2 51.15,103.69 53.67,103.69 54.14,104.17 54.14,105.26 52.91,106.49 52.1,106.49 51.85,106.74 51.85,108.69 52.11,108.95 R25368.1
BL_ON: length 21.8
  TOP w0.102: v1(51.5,102.86) 52.89,102.86 53.16,102.59 D3.2 ; Q6522.3 55.05,109.59 55.69,110.22 55.69,110.48 56.2,110.98 57.29,110.98 57.85,110.43 R25367.1 57.21,109.71 57.21,108.06 56.89,107.74 56.89,106.59 56.7,106.41 56.26,106.41 v2(56.05,106.21) 56.05,106.19 55.48,105.62 55.48,105.1 55.51,105.06 55.51,104.43 55.93,104.01 Q6521.6
  IN2 w0.089: v1(51.5,102.86) 51.87,102.86 53.96,104.95 54.8,104.95 v2(56.05,106.21)
  BOTTOM w0.102: v2(56.05,106.21) 56.35,106.51 CN29.26
BOARD_ID0: length 12.5
  BOTTOM w0.079: U1.CH36 75.14,38.73 74.95,38.93 74.89,38.98 74.88,38.99 74.57,38.99 74.2,38.61 73.46,38.61 72.32,37.48 71.79,37.48
  BOTTOM w0.102: R25395.1 65.99,33.82 R25392.2 66.35,34.53 66.47,34.66 67.7,34.66 68.93,35.89 69.32,35.89 69.66,36.23 70.55,36.23 71.79,37.48
BOARD_ID1: length 16.8
  BOTTOM w0.079: 70.86,35.02 71,35.17 71.26,35.17 71.56,34.86 71.87,34.86 73.49,36.48 73.7,36.48 74.39,37.17 74.88,37.17 75.05,37.27 75.26,37.27 75.43,37.11 75.98,37.11 U1.CL35
  BOTTOM w0.102: 70.86,35.02 70.73,34.89 70.73,34.82 69.96,34.05 69.96,32.14 v1(69.78,31.96) 69.38,31.96 68.89,31.47 67.65,31.47 67.54,31.37 67.54,30.73 67.38,30.57 66.81,30.57 66.69,30.69 66.69,30.92 66.61,31 R73.2 66.35,30.84 65.85,30.34 65.85,29.81 65.37,29.33 R25396.1
BOARD_ID2: length 21.8
  TOP w0.102: v2(71.23,34.66) 70.51,34.66 68.61,32.75 68.13,32.75 66.31,30.92 66.31,27.94 65.53,27.16 65.26,27.16 64.93,26.83 61.78,26.83 v1(61.66,26.71) 61.35,26.4 R25393.2 61.97,25.26 R25397.1
  BOTTOM w0.079: v2(71.23,34.66) 71.28,34.61 71.92,34.61 73.39,36.08 73.69,36.08 74.53,36.92 75.05,36.92 U1.CL36
BOARD_ID3: length 18.5
  TOP w0.102: R25399.1 v1(64.2,26.28) 64.33,26.41 R25394.2 65.53,26.94 65.64,26.94 66.53,27.82 66.53,30.83 68.04,32.34 68.93,32.34 69.48,32.88 70.01,32.88 70.39,33.26 70.8,33.26 v2(71.21,33.67)
  BOTTOM w0.079: 74.38,36.44 74.38,36.5 74.63,36.75 74.91,36.75 75.1,36.57 U1.CM35
  BOTTOM w0.102: 74.38,36.44 73.82,35.88 73.47,35.88 71.7,34.11 71.65,34.11 v2(71.21,33.67)
BOARD_ID4: length 165.4
  TOP w0.102: v2(56.4,25.97) 56.5,26.07 56.5,27.14 56.63,27.27 58.22,27.27 58.24,27.29 60.23,27.29 v1(60.31,27.37) 60.62,27.67 R25398.1 61.65,27.16 63.57,27.16 R59.2 64.08,27.31 64.2,27.19 64.96,27.19 65.16,27.39 65.44,27.39 66.08,28.03 66.08,31.02 68.04,32.98 68.51,32.98 71.18,35.65 72.45,35.65 72.88,36.08 73.56,36.08 73.92,36.44 v2(76.13,36.44)
  IN2 w0.089: v2(56.4,25.97) 56.37,25.97 56.25,25.84 53.61,25.84 53.05,26.4 53.05,27.72 52.69,28.08 52.08,28.08 51.61,28.55 48.54,28.55 48.19,28.21 48.19,27.19 48.03,27.03 46,27.03 42.26,30.77 39.99,30.77 39.45,31.31 38.73,31.31 35.76,34.28 33.3,34.28 33.23,34.21 27.84,34.21 27.6,34.45 27.6,37.03 25.82,38.81 25.82,40.9 26.01,41.08 26.33,41.08 26.48,41.24 26.48,43.46 26.38,43.57 26.38,47.48 24.6,49.26 24.6,49.77 24.75,49.92 25.11,49.92 25.26,50.07 25.36,50.07 25.87,50.59 25.87,74.01 25.54,74.34 25.54,81.49 26.41,82.35 26.41,84.02 25.71,84.71 25.08,84.71 24.71,85.08 24.71,86.96 27.34,89.58 27.34,91.91 29.88,94.45 29.88,95.65 31.96,97.73 43.76,97.73 44.96,98.94 48.72,98.94 49.53,99.75 49.53,101.24 50.66,102.36 50.66,103.26 51.09,103.69 51.9,103.69 53.5,105.3 53.5,106.06 53.65,106.21 v2(54.49,106.21)
  BOTTOM w0.079: v2(76.13,36.44) 76.02,36.34 U1.CN35
  BOTTOM w0.102: R25521.1 56.42,104.44 C20001.2 56.01,104.21 55.69,104.53 55.69,105.08 54.56,106.21 v2(54.49,106.21)
BOARD_ID5: length 12.7
  BOTTOM w0.079: U1.CH35 75.87,38.73 75.48,39.13 74.99,39.13 74.98,39.13 74.91,39.15 74.49,39.15 74.12,38.78 73.39,38.78 72.31,37.71 72.2,37.71
  BOTTOM w0.102: 72.2,37.71 71.61,37.71 70.35,36.44 69.05,36.44 68.41,35.8 66.83,35.8 R25391.2 65.81,34.78 R25390.1
BOARD_ID6: length 173.7
  IN1 w0.089: v2(26.22,85.33) 25.97,85.08 25.97,82.41 25.56,82 25.56,74.33 26.76,73.14 27.37,73.14 27.62,72.88 27.62,68.69 26.07,67.14 26.07,65.67 24.93,64.53 24.93,54.32 25.46,53.79 25.46,42.83 v2(23.94,41.31)
  IN2 w0.089: v2(56.07,105.63) 56.07,105.63 56.07,105.19 55.54,104.66 54.24,104.66 51.82,102.25 50.32,100.74 50.32,99.39 49.09,98.16 45.3,98.16 44.09,96.95 32.28,96.95 30.73,95.39 30.73,94.41 28.1,91.79 28.1,87.51 26.83,86.24 26.83,85.69 26.48,85.33 v2(26.22,85.33) ; v2(32.68,36.66) 32.75,36.59 36.43,36.59 39.3,33.72 41.36,33.72 41.62,33.46 42.91,33.46 45.17,31.2 45.17,30.85 46.29,29.73 47.05,29.73 48.09,30.77 49.24,30.77 49.8,30.21 52.77,30.21 53.33,30.77 54.57,30.77 55.21,30.14 55.56,30.14 56.2,30.77 61.91,30.77 63.49,32.35 66.25,32.35 67.42,33.51 67.83,33.51 68.51,34.2 69.71,34.2 70.75,35.24 v2(71.72,35.24)
  BOTTOM w0.079: U1.CK36 75.16,37.54 74.83,37.34 74.32,37.34 73.72,36.74 73.42,36.74 73.42,36.74
  BOTTOM w0.102: v2(32.68,36.66) 35.22,34.12 35.22,33.26 34.81,32.85 30.95,32.85 29.63,34.17 29.63,36.13 26.94,38.82 26.94,40.58 26.35,41.16 24.09,41.16 v2(23.94,41.31) ; R25388.1 65.4,30.37 65.85,30.82 65.85,31.47 R25386.2 66.78,32.4 68.85,32.4 69.53,33.08 v1(69.53,33.46) 69.53,34 70.95,35.42 71.54,35.42 v2(71.72,35.24) 73.21,36.74 73.42,36.74 ; R25522.1 57.77,104.94 57.53,105.18 C20002.2 56.81,105.55 56.15,105.55 v2(56.07,105.63)
BOARD_ID7: length 15.2
  BOTTOM w0.079: U1.CK34 75.84,37.67 75.67,37.84 74.99,37.84 74.81,38.01 74.13,38.01 73.82,37.7 73.09,37.7
  BOTTOM w0.102: 73.09,37.7 72.4,37.02 72.27,37.02 70.59,35.34 70.51,35.34 69.05,33.87 69.05,33.46 v1(68.41,32.83) 68.21,32.63 66.31,32.63 65.76,32.08 R25387.2 65.09,31.69 65.4,31.37 R25389.1
BRIGHT: length 3.1
  TOP w0.102: v1(54.14,108.49) 54.29,108.34 R441.1 R443.2 53.23,107.69 52.62,107.08 R439.2
BT_EN: length 17.1
  TOP w0.102: v2(203.67,23.35) 203.85,23.35 204.05,23.55 R960.2
  IN2 w0.089: v2(203.67,23.35) 203.62,23.35 202.72,22.46 199.71,22.46 199.66,22.41 197.6,22.41 197.53,22.34 196.88,22.34 196.21,21.67 195.16,21.67 194.76,21.27 v2(194.7,21.27)
  BOTTOM w0.102: CN17.54 191.51,17.88 191.73,18.1 191.73,18.45 192.16,18.88 R671.1 192.5,19.19 192.31,19.38 192.31,19.82 192.87,20.38 v1(192.87,20.48) 192.92,20.48 193.2,20.76 194.17,20.76 194.68,21.27 v2(194.7,21.27)
BXTALOUT: length 7.9
  BOTTOM w0.102: R330.1 R332.1 98.44,89.4 99.96,90.92 100.39,90.92 101.15,91.68 101.15,92.7 101.28,92.82 101.28,93.89 101.71,94.32 U8.C10
C_IN_CLK: length 12.7
  TOP w0.102: R706.1 14.29,81.39 14.65,81.04 v1(14.82,81.04) 15.14,80.71 15.26,80.71 15.33,80.79 R703.2
  IN3 w0.089: v1(14.82,81.04) 14.82,80.91 14.97,80.76 15.13,80.76 15.3,80.93 15.3,81.52 15.17,81.65 14.41,81.65 13.22,80.45 13.22,77.3 12.92,77 12.19,77 12.05,76.85 12.05,76.44 11.81,76.2 CN37.10
  BOTTOM w0.102: R489.1 14.71,81.15 v1(14.82,81.04) 14.93,80.92 15.16,80.92 15.33,81.09 R703.2
C_IN_CLK#: length 12.7
  TOP w0.102: R707.1 14.37,80.58 14.59,80.58 v1(14.79,80.38) 14.92,80.5 15.22,80.5 15.33,80.39 R702.2
  IN3 w0.089: v1(14.79,80.38) 14.97,80.55 15.21,80.55 15.51,80.85 15.51,81.6 15.26,81.85 14.33,81.85 13.02,80.54 13.02,77.38 12.84,77.2 CN37.12
  BOTTOM w0.102: R489.2 14.24,80.45 14.72,80.45 v1(14.79,80.38) 14.92,80.38 R702.2
C_IN_CLK#_R: length 3
  TOP w0.102: C847.2 25.55,80.95 25.45,81.05 25.23,81.05 25.01,80.83 25.01,80.17 24.75,79.91 24.49,79.91 24.3,79.72 U23.31
C_IN_CLK_R: length 3
  TOP w0.102: U23.32 24.35,80.22 24.44,80.13 24.66,80.13 24.8,80.26 24.8,80.92 25.14,81.27 25.39,81.27 25.55,81.42 C849.2
C_TX0_HDMI+: length 15.6
  TOP w0.102: R712.1 14.67,75.3 v1(14.82,75.14) 15.12,75.45 R697.2
  IN1 w0.089: v1(14.82,75.14) 15.68,75.14 16.29,74.54 16.29,73.99 15.95,73.65 15.05,73.65 14.08,72.68 13.1,72.68 12.53,72.11 12.53,71.81 11.98,71.26 11.26,71.26 10.73,71.78 10.73,74.55 10.58,74.7 CN37.7
  BOTTOM w0.102: R487.1 14.66,75.31 v1(14.82,75.14) 15.12,75.45 R697.2
C_TX0_HDMI+_R: length 3.5
  TOP w0.102: U23.26 24.42,77.22 24.56,77.08 24.85,77.08 25.08,76.85 25.08,75.74 25.22,75.6 25.44,75.6 25.55,75.71 C852.2
C_TX0_HDMI-: length 15.6
  TOP w0.102: R713.1 14.57,74.28 v1(14.79,74.5) 15.09,74.5 R696.2
  IN1 w0.089: CN37.9 10.55,75.2 10.55,75.01 10.93,74.63 10.93,71.87 11.34,71.46 11.9,71.46 12.33,71.89 12.33,72.2 13.02,72.88 14,72.88 14.96,73.85 15.86,73.85 16.09,74.08 16.09,74.45 15.6,74.94 15.18,74.94 14.79,74.55 v1(14.79,74.5)
  BOTTOM w0.102: R696.2 15.09,74.5 v1(14.79,74.5) 14.68,74.61 14.24,74.61 R487.2
C_TX0_HDMI-_R: length 3.5
  TOP w0.102: U23.25 24.42,76.72 24.56,76.86 24.76,76.86 24.86,76.76 24.86,75.65 25.13,75.38 25.44,75.38 25.55,75.27 C853.2
C_TX1_HDMI+: length 10.2
  TOP w0.102: R710.1 14.54,77.33 v1(14.79,77.08) 15.07,77.35 R699.2
  IN3 w0.089: CN37.4 12.54,73.2 13.22,73.87 15.02,73.87 15.43,74.28 15.43,76.63 15.21,76.85 15.02,76.85 v1(14.79,77.08)
  BOTTOM w0.102: R486.1 14.66,77.21 v1(14.79,77.08) 15.07,77.35 R699.2
C_TX1_HDMI+_R: length 2.5
  TOP w0.102: C851.2 25.55,77.56 25.49,77.5 25.35,77.5 24.77,78.08 24.46,78.08 24.31,78.22 U23.28
C_TX1_HDMI-: length 10.2
  TOP w0.102: R698.2 15.06,76.43 v1(14.79,76.43) 14.73,76.5 14.35,76.5 R711.1
  IN3 w0.089: v1(14.79,76.43) 14.79,76.52 14.92,76.64 15.12,76.64 15.23,76.54 15.23,74.37 14.94,74.08 13.13,74.08 12.46,73.4 12.24,73.4 12.1,73.54 12.1,74.05 11.95,74.2 CN37.6
  BOTTOM w0.102: R698.2 15.06,76.43 v1(14.79,76.43) 14.71,76.52 14.24,76.52 R486.2
C_TX1_HDMI-_R: length 2.4
  TOP w0.102: U23.27 24.33,77.72 24.47,77.86 24.68,77.86 25.26,77.28 25.46,77.28 25.55,77.19 C848.2
C_TX2_HDMI+: length 16.2
  TOP w0.102: R708.1 14.44,79.09 v1(14.79,79.09) 15.07,79.37 15.22,79.37 R701.2
  IN3 w0.089: CN37.1 10.56,71.7 11.1,71.16 12.08,71.16 14.19,73.27 15.31,73.27 16.04,73.99 16.04,78.49 15.44,79.09 v1(14.79,79.09)
  BOTTOM w0.102: R701.2 15.22,79.37 15.07,79.37 v1(14.79,79.09) 14.75,79.04 14.23,79.04 R484.1
C_TX2_HDMI+_R: length 2.3
  TOP w0.102: U23.30 24.42,79.22 24.56,79.08 24.86,79.08 25.18,79.41 25.44,79.41 25.55,79.52 C854.2
C_TX2_HDMI-: length 16.2
  TOP w0.102: R709.1 14.36,78.54 14.71,78.54 v1(14.79,78.46) 15.18,78.07 R700.2
  IN3 w0.089: CN37.3 10.45,72.3 10.45,72.1 11.19,71.36 12,71.36 14.11,73.47 15.23,73.47 15.84,74.08 15.84,78.41 15.36,78.89 15.16,78.89 14.79,78.52 v1(14.79,78.46)
  BOTTOM w0.102: R484.2 14.28,78.46 v1(14.79,78.46) 14.94,78.46 R700.2
C_TX2_HDMI-_R: length 2.3
  TOP w0.102: U23.29 24.42,78.72 24.56,78.86 24.95,78.86 25.27,79.19 25.39,79.19 25.55,79.03 C850.2
CATERR#: length 5.2
  BOTTOM w0.079: R10.2 100.09,67.3 99.79,67 97.23,67 97.19,67.01 97.02,67.05 97.01,67.05 96.79,66.98 96.66,66.98 96.52,67.01 96.39,67.08 95.84,67.17 U1.AA4
CFG0: length 20.5
  TOP w0.102: v2(98.46,69.77) 98.78,69.46 99.4,69.46 99.78,69.07 100.44,69.07 101.04,69.67 101.04,69.96 101.49,70.41 101.49,70.94 102.17,71.62 102.52,71.62 102.89,71.98 103.45,71.98 104.33,72.86 104.89,72.86 104.99,72.76 v1(106.46,72.76) 107.15,72.76 107.61,72.3 107.61,69.3 107.38,69.07 106.46,69.07 106.36,68.97 R216.1 105.95,68.51 105.93,68.49 R218.1
  BOTTOM w0.079: U1.T4 96.28,70.14 97.14,70.14 97.19,70.19 98.04,70.19 v2(98.46,69.77)
CFG1: length 1.3
  TOP w0.102: TP28.1 94.42,71.78 v2(94.88,71.32)
  BOTTOM w0.102: U1.R4 95.09,71.32 v2(94.88,71.32)
CFG2: length 4.3
  TOP w0.102: v2(99.55,69.81) 100.19,69.81 TP30.1
  BOTTOM w0.079: v2(99.55,69.81) 99.55,69.81 99.01,70.35 96.47,70.35 U1.T3
CFG3: length 11.5
  TOP w0.102: v2(99.4,73.44) 99.5,73.44 99.68,73.62 100.29,73.62 101.13,74.46 R217.1
  BOTTOM w0.079: U1.R3 96.72,70.62 96.82,70.52 99.45,70.52 100,71.07 100,72.75 100.51,73.25
  BOTTOM w0.102: v2(99.4,73.44) 99.83,73.44 100.04,73.65 R86.1 100.93,73.45 100.8,73.32 100.57,73.32 100.51,73.25
CFG4: length 9.3
  TOP w0.102: TP34.1 100.21,75.32 v2(99.91,75.02)
  BOTTOM w0.079: U1.J4 95.62,74.74 95.84,74.97 96.07,75.2 96.07,75.45 96.22,75.6 96.55,75.6 96.68,75.48 97.45,75.48 97.88,75.91 97.99,75.91 ; v2(99.91,75.02) 100.16,75.02 100.39,74.79
  BOTTOM w0.102: 100.39,74.79 100.52,74.66 R87.1 100.93,74.76 100.26,75.42 100.26,75.55 99.76,76.06 98.36,76.06 98.21,75.91 97.99,75.91
CFG5: length 5.7
  TOP w0.102: v2(99.53,74.03) 99.5,74 TP36.1
  BOTTOM w0.079: U1.M4 96.22,73.13 96.5,73.13 96.81,72.99 97.7,72.99 97.8,72.88 98.21,72.88 98.27,72.95 98.68,72.95 98.99,73.26 98.99,73.77 99.25,74.03 v2(99.53,74.03)
CFG6: length 2.9
  TOP w0.102: TP38.1 97.5,75.47 v2(97.98,75.47)
  BOTTOM w0.079: U1.J3 96.28,74.74 96.81,75.27 97.78,75.27 v2(97.98,75.47)
CFG7: length 9.4
  TOP w0.102: TP40.1 104.66,74.33 104.23,74.33 104.07,74.48 101.62,74.48 101.35,74.21 101.21,74.21 100.34,73.34 99.88,73.34 99.4,72.86 v2(99.4,72.86)
  BOTTOM w0.079: v2(99.4,72.86) 98.89,72.86 98.74,72.71 97.7,72.71 97.65,72.76 96.51,72.76 U1.M3
CFG8: length 3.8
  TOP w0.102: v2(99.55,71.23) 99.81,70.98 TP31.1
  BOTTOM w0.079: U1.R2 97,70.72 99.04,70.72 v2(99.55,71.23)
CFG9: length 2.9
  TOP w0.102: v2(98.57,72.07) 98.57,72.5 TP33.1
  BOTTOM w0.079: U1.N2 96.91,72.12 97.09,72.12 97.37,71.99 97.59,71.77 98.26,71.77 v2(98.57,72.07)
CFG10: length 3.4
  TOP w0.102: v2(99.54,71.97) 99.18,71.61 TP35.1
  BOTTOM w0.079: v2(99.54,71.97) 98.87,71.3 98.87,71.11 98.64,70.88 97.59,70.88 97.48,70.99 U1.R1
CFG11: length 2.1
  TOP w0.102: v2(97.98,72.15) 97.78,72.15 97.47,71.84 TP37.1
  BOTTOM w0.079: v2(97.98,72.15) 97.78,72.15 97.62,72.3 U1.N1
CFG12: length 3.1
  TOP w0.102: v2(98.56,75.47) 98.94,75.86 TP42.1
  BOTTOM w0.079: U1.J2 97.03,75.05 98.08,75.05 98.51,75.47 v2(98.56,75.47)
CFG13: length 2.5
  TOP w0.102: TP44.1 97.22,73.29 v2(97.98,73.29)
  BOTTOM w0.079: v2(97.98,73.29) 97.8,73.29 97.67,73.16 96.99,73.16 U1.L2
CFG14: length 2
  TOP w0.102: v2(98.49,74.89) 98.64,75.04 TP46.1
  BOTTOM w0.079: v2(98.49,74.89) 98.46,74.87 97.5,74.87 U1.J1
CFG15: length 3.2
  TOP w0.102: v2(98.59,73.38) 98.5,73.38 98.18,73.7 97.9,73.7 TP48.1
  BOTTOM w0.079: U1.L1 97.62,73.67 98.18,73.67 98.48,73.38 v2(98.59,73.38)
CFG16: length 4.6
  TOP w0.102: TP29.1 99.88,74.43 99.1,74.43 v2(99.07,74.41)
  BOTTOM w0.079: U1.L3 96.24,73.43 arc(96.28,73.44) 96.32,73.46 96.47,73.61 arc(96.53,73.65) 96.59,73.68 arc(96.6,73.68) 96.61,73.68 arc(96.65,73.69) 96.69,73.7 96.76,73.7 96.76,73.7 97.14,73.7 97.55,74.1 98.18,74.1 98.49,74.41 v2(99.07,74.41)
CFG17: length 1.3
  TOP w0.102: TP27.1 95.08,73.6 v2(95.08,73.01)
  BOTTOM w0.079: U1.L4 95.08,73.08 arc(95.08,73.08) 95.08,73.08 95.08,73.02 arc(95.08,73.02) 95.08,73.02 v2(95.08,73.01)
CFG18: length 5.4
  TOP w0.102: v2(98.45,71.24) 98.03,71.66 97.65,71.66 97.37,71.39 97.37,70.88 97.04,70.55 TP41.1
  BOTTOM w0.079: U1.N3 96.07,72.25 96.38,71.94 97.08,71.94 97.23,71.87 97.5,71.6 98.1,71.6 v2(98.45,71.24)
CFG19: length 5
  TOP w0.102: v2(99.06,72.38) 99.56,72.38 TP39.1
  BOTTOM w0.079: U1.N4 95.62,72.3 95.87,72.56 97.53,72.56 97.57,72.52 98.93,72.52 v2(99.06,72.38)
CFG_RCOMP: length 11.1
  TOP w0.102: v2(94.88,66.71) 95.36,66.71 95.69,66.38 96.81,66.38 97.7,67.27 102.07,67.27 102.88,68.08 103.44,68.08 104.02,68.66 R82.1
  BOTTOM w0.203: U1.AB5 94.68,66.97 94.88,66.76 v2(94.88,66.71)
CHA_SA0: length 6.4
  TOP w0.102: v1(49.54,34.07) 49.03,34.07 48.83,34.28 R225.2 R228.1 48.71,33.01 v1(48.32,32.63)
  BOTTOM w0.102: JDIM1.256 49.35,30.45 48.96,30.85 48.96,31.1 48.07,31.99 48.07,32.37 v1(48.32,32.63)
CHA_SA1: length 6.9
  TOP w0.102: v1(48.09,31.36) 48.09,31.85 R229.1 47.87,31.95 47.19,31.26 R226.2 47.19,30.53 v1(47.48,30.24)
  BOTTOM w0.102: JDIM1.260 48.57,29.45 48.14,29.88 48.14,31.18 48.09,31.23 v1(48.09,31.36)
CHA_SA2: length 4.5
  TOP w0.102: v1(52.39,53.52) 52.39,53.7 52.06,54.03 52.06,54.11 51.87,54.3 R230.1 51.62,54.6 R227.2
  BOTTOM w0.102: JDIM1.166 51.84,52.95 52.39,53.5 v1(52.39,53.52)
CK_XDP_N: length 6.8
  BOTTOM w0.102: TP47.1 102.65,57.95 102.51,58.09 101.8,58.09 101.22,58.67 100.15,58.67 99.53,58.05 97.55,58.05 97.37,57.88 U1.AU1
CK_XDP_P: length 6.8
  BOTTOM w0.102: U1.AU2 96.82,57.66 97.43,58.27 99.45,58.27 100.07,58.89 101.31,58.89 101.89,58.3 102.45,58.3 TP45.1
CLK_24M_DEBUG: length 181
  TOP w0.102: R92.2 64.7,46.09 EC3.2 63.95,45.58 63.38,45.58 61.5,43.7 61.5,30.27 61.21,29.98 61.21,29.32 61.23,29.3 61.23,28.79 60.95,28.51 60.76,28.51 60.15,27.9 v2(59.81,27.9)
  IN1 w0.089: v2(59.81,27.9) 59.81,27.73 59.37,27.29 59.12,27.29 58.41,26.58 58.41,25.77 58.11,25.47 58.11,20.33 60.51,17.93 60.51,16.24 61.08,15.67 73.99,15.67 74.97,16.64 78.67,16.64 83.66,21.63 88.74,21.63 93.87,16.5 98.21,16.5 98.88,15.82 99.8,15.82 100.46,15.16 108.3,15.16 108.91,15.77 118.77,15.77 119.38,15.16 176.11,15.16 177.07,16.12 177.07,16.57 177.38,16.88 180.58,16.88 181.47,15.99 182.19,15.99 183.73,14.45 193.14,14.45 193.91,15.23 v2(193.91,15.68)
  BOTTOM w0.102: R655.1 194.47,17.5 194.12,17.16 194.12,17.06 193.97,16.9 193.97,16.52 194.07,16.42 194.07,15.84 v2(193.91,15.68) 193.71,15.48 R674.2
CLK_24M_DEBUG_R: length 3.3
  BOTTOM w0.102: R674.1 192.97,15.1 v1(192.58,15.49) 192.47,15.61 192.47,16.14 192.21,16.39 191.65,16.39 191.64,16.38 CN17.60
CLK_PCI_EC: length 191.5
  TOP w0.102: R402.2 181.06,23.23 181.37,23.53 182.26,23.53 182.41,23.38 U37.13 184.11,23.38 185.43,22.06 v2(186.9,22.06)
  IN1 w0.089: v2(60.82,28.96) 60.72,28.86 60.72,28.08 59.53,26.9 59.28,26.9 58.81,26.43 58.81,25.61 58.5,25.31 58.5,20.67 63.1,16.06 73.83,16.06 74.8,17.04 78.51,17.04 83.5,22.02 88.9,22.02 94.03,16.89 98.37,16.89 99.04,16.22 99.97,16.22 100.63,15.56 108.11,15.56 108.72,16.17 118.93,16.17 119.55,15.55 175.95,15.55 176.63,16.23 176.63,16.95 176.95,17.27 181.46,17.27 183.89,14.85 189.42,14.85 190.83,16.25 190.83,19.04 187.81,22.06 v2(186.9,22.06)
  BOTTOM w0.102: v2(60.82,28.96) 60.39,29.39 60.39,48.81 62.41,50.83 EC2.2 62.41,51.93 R91.2
CLK_PCI_EC_R: length 19.8
  TOP w0.102: v2(77.36,44.74) 77.36,44.76 77.28,44.84 74.99,44.84 74.89,44.74 68.46,44.74 66.33,46.87 66.33,47.38 64.65,49.06 64.65,51.45 v1(64.58,51.52)
  BOTTOM w0.079: U1.BV32 77.74,44.28 77.38,44.64 77.38,44.72 v2(77.36,44.74)
  BOTTOM w0.102: R91.1 63.69,52.06 63.82,52.18 v1(64.25,52.18) 64.58,51.85 v1(64.58,51.52)
CLK_PCI_LPC_R: length 13.9
  TOP w0.079: v2(78.67,43.82) 78.53,43.82 78.17,44.18 75.88,44.18 75.73,44.03 75.25,44.03
  TOP w0.102: 75.25,44.03 75.14,44.03 74.99,44.18 68.27,44.18 R92.1
  BOTTOM w0.079: U1.BV30 79.04,44.19 v2(78.67,43.82)
CLK_PCIE_LANN: length 93
  TOP w0.102: U24.16 46.04,102.63 46.07,102.59 46.07,102.26 46.24,102.09 46.34,102.09 v1(46.52,102.27)
  IN3 w0.089: v2(99.25,56.02) 99.07,56.2 99.07,56.55 98.87,56.76 97.42,56.76 96.53,57.64 96.53,72.38 96.61,72.45 96.61,74.42 95.16,75.86 95.16,77.11 93.41,78.86 93.41,80.24 92.59,81.05 92.59,81.7 91.76,82.54 91.76,84.88 91.1,85.54 91.1,87.95 89.1,89.95 88.58,89.95 86.24,92.29 85,92.29 83.93,93.36 82.12,93.36 79.99,95.49 77.18,95.49 76.22,96.46 61.33,96.46 60.44,97.34 59.42,97.34 57.08,99.68 57.08,101.14 55.72,102.5 52.56,102.5 51.69,101.64 48.4,101.64 47.8,102.24 47.09,102.24 46.95,102.09 46.7,102.09 v1(46.52,102.27)
  BOTTOM w0.079: U1.BA1 97.23,55.22 97.16,55.28 97.16,55.4 97.26,55.49 97.6,55.49 97.76,55.33 98.76,55.33 99.01,55.59 99.01,55.85 99.18,56.02 v2(99.25,56.02)
CLK_PCIE_LANP: length 93.1
  TOP w0.102: v1(46.39,101.64) 45.86,102.17 45.86,102.5 45.64,102.72 U24.15
  IN3 w0.089: v1(46.39,101.64) 46.64,101.89 47.03,101.89 47.18,102.03 47.71,102.03 48.31,101.43 51.78,101.43 52.64,102.3 55.64,102.3 56.88,101.05 56.88,99.6 59.34,97.14 60.35,97.14 61.24,96.25 76.13,96.25 77.1,95.29 79.9,95.29 82.04,93.15 83.85,93.15 84.92,92.09 86.16,92.09 88.5,89.75 89.01,89.75 90.89,87.87 90.89,85.46 91.55,84.8 91.55,82.45 92.39,81.61 92.39,80.97 93.2,80.16 93.2,78.78 94.96,77.02 94.96,75.78 96.4,74.33 96.4,72.54 96.33,72.46 96.33,57.56 97.34,56.55 98.78,56.55 98.87,56.47 98.87,56.22 v2(98.66,56.02)
  BOTTOM w0.079: v2(98.66,56.02) 98.85,55.83 98.85,55.65 98.69,55.49 97.82,55.49 97.66,55.65 97.16,55.65 U1.BA2
CLK_PCIE_REQ2#: length 15.2
  TOP w0.102: v2(78.7,40.22) 78.7,40.73 TP9011.1 78.01,40.88 77.64,41.25 77.43,41.25 77.14,41.54 72.62,41.54 72.06,42.1 69.04,42.1 66.45,39.51 R25440.1
  BOTTOM w0.079: U1.CF30 78.7,40.03 v2(78.7,40.22)
CLK_PCIE_REQ3#: length 14.7
  TOP w0.102: R25441.1 66.56,38.54 66.99,38.98 66.99,39.73 69.14,41.87 71.97,41.87 72.53,41.31 76.82,41.31 TP9012.1 77.63,40.5 77.79,40.5 v2(78.06,40.23)
  BOTTOM w0.079: v2(78.06,40.23) 78.06,40.27 U1.CE31
CLK_PCIE_SSDN: length 106.9
  IN3 w0.089: v1(27.68,12.64) 27.57,12.75 27.57,12.94 27.75,13.12 27.75,14.34 27.59,14.49 27.59,20.19 28.54,21.14 28.54,23.3 29.17,23.93 29.17,24.57 30.9,26.3 30.9,27.2 31.32,27.62 34,27.62 34.21,27.83 39.31,27.83 41.74,30.26 44.01,30.26 47.06,33.31 49.63,33.31 50.44,32.5 57.28,32.5 57.55,32.77 58.7,32.77 60.68,34.75 64.92,34.75 65.85,35.68 68.6,35.68 69.15,36.23 69.99,36.23 71.26,37.5 72.56,37.5 73.5,38.44 74.38,38.44 75.58,39.64 78.93,39.64 79.01,39.56 79.51,39.56 79.58,39.63 81.05,39.63 81.47,40.04 81.47,43.64 81.93,44.1 81.93,46.1 81.85,46.17 81.85,47.15 81.9,47.2 81.9,48.47 82.26,48.83 82.26,50.84 82.71,51.29 83.78,51.29 84.91,52.42 84.91,52.65 86.73,54.47 90.38,54.47 90.71,54.14 91.46,54.14 91.5,54.18 95.1,54.18 95.31,53.96 97.67,53.96 97.93,54.22 98.69,54.22 v2(99.3,54.82)
  BOTTOM w0.079: U1.BC1 97.37,53.95 97.53,54.11 98.23,54.11 98.34,54.22 98.74,54.22 99.03,54.5 99.03,54.62 99.23,54.82 v2(99.3,54.82)
  BOTTOM w0.102: R2658.1 27.47,11.77 27.37,11.87 27.37,12.08 27.46,12.16 27.46,12.41 v1(27.68,12.64)
CLK_PCIE_SSDN_C: length 2.5
  BOTTOM w0.102: CN16.53 26.85,10.33 26.73,10.46 26.73,10.57 26.85,10.69 27.21,10.69 27.45,10.94 27.45,11.14 27.62,11.32 R2658.2
CLK_PCIE_SSDP: length 106.9
  IN3 w0.089: v2(98.72,54.82) 98.72,54.53 98.61,54.42 97.84,54.42 97.59,54.16 95.4,54.16 95.18,54.38 91.41,54.38 91.37,54.34 90.79,54.34 90.46,54.67 86.64,54.67 84.71,52.74 84.71,52.51 83.7,51.5 82.63,51.5 82.05,50.92 82.05,48.91 81.7,48.56 81.7,47.28 81.65,47.23 81.65,46.09 81.72,46.01 81.72,44.18 81.27,43.72 81.27,40.13 80.97,39.83 79.5,39.83 79.43,39.76 79.09,39.76 79.01,39.84 75.49,39.84 74.3,38.64 73.42,38.64 72.48,37.71 71.17,37.71 69.9,36.44 69.07,36.44 68.51,35.88 65.77,35.88 64.84,34.95 60.59,34.95 58.62,32.97 57.47,32.97 57.2,32.71 50.53,32.71 49.72,33.51 46.98,33.51 43.93,30.47 41.66,30.47 39.23,28.03 34.13,28.03 33.92,27.82 31.24,27.82 30.7,27.29 30.7,26.38 28.97,24.65 28.97,24.02 28.33,23.38 28.33,21.22 27.39,20.28 27.39,14.41 27.54,14.25 27.54,13.2 27.37,13.02 27.37,12.95 v1(27.05,12.64)
  BOTTOM w0.079: v2(98.72,54.82) 98.87,54.67 98.87,54.56 98.68,54.37 98.27,54.37 98.17,54.27 97.47,54.27 97.42,54.22 97.22,54.22 96.9,53.9 U1.BC2
  BOTTOM w0.102: R2659.1 27.15,11.93 27.15,12.17 27.24,12.25 27.24,12.44 v1(27.05,12.64)
CLK_PCIE_SSDP_C: length 2.4
  BOTTOM w0.102: CN16.55 26.35,10.35 26.49,10.49 26.49,10.63 26.77,10.91 27.12,10.91 27.23,11.03 27.23,11.2 27.11,11.32 R2659.2
CLK_PCIE_WLANN: length 138.1
  IN1 w0.089: v2(98.06,53.43) 97.85,53.22 97.85,50.79 98.31,50.33 99.4,50.33 99.73,50 99.73,46.39 103.08,43.04 103.08,42.45 103.54,42 105.46,42 106.84,43.37 112.86,43.37 113.42,42.81 113.42,42.38 114.53,41.27 114.88,41.27 115.56,40.59 117.24,40.59 117.31,40.52 118.12,40.52 118.58,40.07 120.53,40.07 122.2,41.74 125.47,41.74 126.41,40.8 133.08,40.8 136.56,44.29 140.93,44.29 141.95,43.28 141.95,41.62 142.46,41.11 142.91,41.11 143.39,40.62 143.39,40.13 147.47,36.05 147.71,36.05 147.92,35.84 148.31,35.84 148.55,35.61 148.72,35.61 149.11,35.22 155.74,35.22 156.42,35.89 159.19,35.89 160.04,35.04 161.31,35.04 162.27,34.08 163.55,34.08 164.44,33.19 165.36,33.19 165.5,33.06 167.57,33.06 168.04,33.53 180.34,33.53 180.59,33.79 185.9,33.79 186.31,34.2 189.13,34.2 189.61,34.68 190.07,34.68 190.26,34.49 190.26,34.2 v2(190.47,33.98)
  BOTTOM w0.079: v2(98.06,53.43) 98.06,53.4 97.43,52.78 U1.BE1
  BOTTOM w0.102: v2(190.47,33.98) 190.24,33.75 190.24,33.45 189.99,33.2 188.37,33.2 187.48,32.31 187.48,31.96 187.01,31.48 187.01,30.95 187.57,30.39 187.72,30.39 188.15,29.96 188.15,28.79 187.92,28.56 187.92,27.88 188.49,27.3 188.49,26.85 188.68,26.66 188.68,24.31 188.58,24.2 188.58,23.07 188.28,22.77 188.28,19.8 187.32,18.85 185.15,18.85 184.71,19.29 184.34,19.29 184.18,19.13 CN17.49
CLK_PCIE_WLANP: length 138.1
  IN1 w0.089: v2(189.86,34.01) 190.05,34.2 190.05,34.41 189.98,34.48 189.7,34.48 189.22,34 186.4,34 185.98,33.59 180.68,33.59 180.42,33.33 168.13,33.33 167.65,32.85 165.41,32.85 165.28,32.99 164.36,32.99 163.47,33.88 162.19,33.88 161.22,34.84 159.95,34.84 159.1,35.69 156.5,35.69 155.83,35.01 149.02,35.01 148.64,35.4 148.46,35.4 148.23,35.64 147.83,35.64 147.62,35.85 147.38,35.85 143.19,40.04 143.19,40.53 142.82,40.9 142.37,40.9 141.74,41.53 141.74,43.19 140.85,44.09 136.65,44.09 133.16,40.6 126.33,40.6 125.39,41.54 122.29,41.54 120.61,39.86 118.49,39.86 118.04,40.32 117.22,40.32 117.16,40.38 115.47,40.38 114.79,41.06 114.45,41.06 113.22,42.29 113.22,42.73 112.78,43.17 106.92,43.17 105.55,41.79 103.46,41.79 102.88,42.37 102.88,42.95 99.53,46.31 99.53,49.91 99.32,50.13 98.22,50.13 97.65,50.7 97.65,53.25 v2(97.47,53.43)
  BOTTOM w0.079: v2(97.47,53.43) 97.59,53.31 97.59,53.2 97.44,53.04 97.16,53.04 96.89,52.78 U1.BE2
  BOTTOM w0.102: CN17.47 184.2,19.63 184.32,19.51 184.8,19.51 185.24,19.06 187.23,19.06 188.06,19.89 188.06,22.86 188.36,23.16 188.36,24.29 188.47,24.4 188.47,26.57 188.28,26.76 188.28,27.22 187.7,27.79 187.7,28.65 187.93,28.88 187.93,29.87 187.63,30.17 187.48,30.17 186.79,30.86 186.79,31.57 187.26,32.05 187.26,32.4 188.28,33.41 189.9,33.41 190.03,33.54 190.03,33.85 v2(189.86,34.01)
CLK_VGA_N: length 69
  IN1 w0.089: v2(99.67,112.43) 99.67,112.74 99.58,112.84 99.38,112.84 98.44,111.9 98.44,108.52 96.71,106.79 96.71,102.25 97.14,101.82 97.14,100.21 96.28,99.35 96.28,97.67 95.64,97.04 95.64,94.18 96.06,93.76 96.06,91.48 95.48,90.9 95.48,82.69 95.58,82.6 95.58,80.78 96.47,79.89 96.47,78.47 97.34,77.59 97.34,75.65 97.47,75.53 97.47,70.91 97.98,70.41 99.91,70.41 100.21,70.11 100.21,67.32 100.51,67.01 100.51,65.91 100.8,65.62 100.8,63.08 99.64,61.92 99.64,59.12 100.74,58.03 100.9,58.03 v2(101.03,58.15)
  BOTTOM w0.079: 100.39,58.03 100.26,58.03 99.92,57.68 99.27,57.68 98.29,56.71 98.16,56.71 97.52,56.06 96.44,56.06 96.38,56.12 96.38,56.3 96.42,56.34 U1.AW2
  BOTTOM w0.102: v2(101.03,58.15) 100.9,58.03 100.39,58.03 ; U8.AD8 v2(99.67,112.43)
CLK_VGA_P: length 69
  IN1 w0.089: v2(101.03,57.57) 100.77,57.82 100.65,57.82 99.44,59.04 99.44,62 100.6,63.16 100.6,65.54 100.31,65.82 100.31,66.93 100,67.23 100,70.02 99.82,70.2 97.89,70.2 97.27,70.83 97.27,75.44 97.14,75.57 97.14,77.51 96.26,78.38 96.26,79.81 95.38,80.69 95.38,82.51 95.28,82.61 95.28,90.98 95.86,91.56 95.86,93.67 95.44,94.09 95.44,97.12 96.07,97.76 96.07,99.44 96.94,100.3 96.94,101.74 96.51,102.17 96.51,106.88 98.24,108.61 98.24,111.99 99.29,113.04 99.5,113.04 v2(99.68,113.22)
  BOTTOM w0.079: U1.AY3 96.53,55.91 97.58,55.91 98.23,56.55 98.36,56.55 99.33,57.52 99.99,57.52 100.27,57.81 100.39,57.81
  BOTTOM w0.102: U8.AE8 v2(99.68,113.22) ; 100.39,57.81 100.77,57.81 101.01,57.57 v2(101.03,57.57)
CLKRUN#: length 155
  TOP w0.079: 81.65,35.67 81.65,35.88 81.72,35.95 81.72,37.41 81.52,37.61 81.52,40.99 80.95,41.56 80.59,41.56 80.35,41.79 80.35,42.25 80.26,42.35 79.34,42.35 78.79,42.9 v2(78.67,42.9)
  TOP w0.102: 81.65,35.67 81.65,33.65 81.14,33.14 81.14,31.36 81.55,30.95 81.55,28.81 80.61,27.87 80.61,26.81 80.33,26.53 80.33,25.82 80.58,25.56 80.58,25.12 R96.2 80.45,23.98 v1(80.45,23.74) v2(80.45,22.9) ; v2(196.79,24.19) 196.79,24.39 196.71,24.47 196.71,25.83 196.78,25.9 196.78,26.27 197.68,27.16 197.93,27.16 198.11,26.98 U37.93
  IN2 w0.089: v2(80.45,22.9) 80.76,22.9 82.68,24.81 84.23,24.81 84.88,25.47 87.14,25.47 87.8,24.81 90.28,24.81 90.68,24.42 91.76,24.42 95.36,20.81 97.78,20.81 98.9,19.69 99.45,19.69 99.53,19.78 103.86,19.78 104.68,20.6 108.53,20.6 110.52,22.59 112.99,22.59 113.14,22.74 118.99,22.74 120.64,24.4 123.45,24.4 123.96,23.88 126.5,23.88 128.17,22.21 133.97,22.21 134.44,22.68 137.57,22.68 138.16,22.08 146.73,22.08 147.46,22.81 165.04,22.81 165.33,23.1 172.38,23.1 173.12,23.84 173.8,23.84 173.98,24.02 178.21,24.02 178.85,23.38 181.87,23.38 182.84,22.41 186.04,22.41 186.28,22.65 187.13,22.65 187.73,22.05 188.34,22.05 188.57,21.82 189.75,21.82 191.45,23.53 193.02,23.53 193.74,24.24 195.51,24.24 195.75,24.01 196.45,24.01 196.63,24.19 v2(196.79,24.19)
  BOTTOM w0.079: v2(78.67,42.9) 78.69,42.9 79.04,43.25 U1.BY30
CLR_CMOS: length 155.9
  TOP w0.102: v2(178.94,19.21) 178.95,19.54 179.08,19.67 179.57,19.67 180.21,20.31 181.16,20.31 181.34,20.48 181.34,20.84 181.57,21.07 182.03,21.07 182.12,20.98 U37.19 ; v2(51.34,15.8) 51.34,17 50.96,17.39 50.96,18.76 50.3,19.42 50.3,19.93 50.55,20.17 50.55,21.54 51.4,22.39 52.44,22.39 52.7,22.65 v1(52.7,22.87) Q22.2 52.7,24.04 52.23,24.5 52.23,25.11 52.39,25.26 52.51,25.26 52.7,25.44 Q6520.2 53.36,25.98 53.39,26.01 R409.2
  IN2 w0.089: v2(51.34,15.8) 51.34,15.73 51.75,15.33 72.11,15.33 73.05,16.27 79.47,16.27 84.16,20.97 88.43,20.97 93.58,15.81 94.58,15.81 95.03,15.36 95.67,15.36 96.01,15.02 96.56,15.02 96.76,15.23 99.32,15.23 100.04,14.51 107.5,14.51 108.85,15.86 113.1,15.86 114.38,17.14 118.77,17.14 119.23,17.61 121.62,17.61 122.39,18.38 123.7,18.38 124.14,17.94 128.42,17.94 129.12,17.24 137.16,17.24 137.16,17.24 138.53,17.24 139.09,17.8 143.32,17.8 143.88,17.24 149.06,17.24 149.68,17.86 163.16,17.86 163.74,18.43 164.47,18.43 164.9,18.01 170.14,18.01 170.39,18.25 172.79,18.25 173.57,19.04 178.77,19.04 v2(178.94,19.21)
CNV_BRI_DT: length 114.1
  TOP w0.102: R668.1 103.85,33.74 103.97,33.87 v2(104.25,33.87)
  IN2 w0.089: v2(104.25,33.87) 104.49,34.11 106.5,34.11 106.54,34.07 110.73,34.07 110.96,34.3 116.11,34.3 116.78,33.64 117.9,33.64 119.64,35.39 120.4,35.39 120.82,35.81 123.3,35.81 124.29,34.82 126.33,34.82 128.54,37.03 136.07,37.03 136.87,37.83 143.44,37.83 144.18,37.1 144.18,36.65 145.51,35.31 145.87,35.31 147.61,33.56 156.42,33.56 156.65,33.8 158.4,33.8 158.4,33.8 161.55,33.8 162.3,33.04 162.75,33.04 163.42,32.38 164.49,32.38 165.16,31.72 168.24,31.72 168.75,32.22 169.27,32.22 169.8,31.69 175.34,31.69 175.88,31.15 180.12,31.15 180.47,30.8 182.46,30.8 183.42,31.76 184.59,31.76 185.02,31.33 185.28,31.33 185.92,30.69 186.41,30.69 186.95,30.15 187.74,30.15 187.86,30.03 191.71,30.03 192.42,29.32 193.9,29.32 195.07,28.15 195.07,27.42 195.79,26.69 196.35,26.69 197.18,25.86 v2(197.19,25.86)
  BOTTOM w0.102: v2(197.19,25.86) 196.91,25.58 196.91,24.88 197.22,24.57 197.22,23.56 197.25,23.52 197.25,23.24 197.09,23.07 R664.2 197.09,22.76 196.57,22.24 195.16,22.24 194.88,22.52 192.86,22.52 192.69,22.69 191.79,22.69 191.48,22.38 CN17.36
CNV_BRI_DT_R: length 24.9
  TOP w0.102: v2(103.24,33.62) 103.24,33.46 103.74,32.96 R668.2
  IN2 w0.089: v2(103.24,33.62) 103.08,33.45 97.31,33.45 96.01,34.75 93.3,34.75 92.61,35.43 90.04,35.43 89.83,35.65 88.1,35.65 87.18,36.57 87.18,38.33 87.28,38.43 87.28,38.9 86.95,39.23 86.55,39.23 86.17,38.85 v2(84.64,38.85)
  BOTTOM w0.079: v2(84.64,38.85) 84.77,38.72 84.77,38.47 85.24,38 U1.CJ20
CNV_BRI_RSP: length 135.5
  TOP w0.102: v2(103.24,34.78) 103.24,34.74 102.83,34.33 102.83,33.23 103.72,32.34 R662.2
  IN2 w0.089: v2(84.69,37.86) 84.18,38.37 84.18,39.75 84.47,40.04 85.78,40.04 86.22,39.61 86.82,39.61 87.45,38.98 87.45,38.29 87.39,38.23 87.39,36.65 88.17,35.86 89.99,35.86 90.05,35.81 92.59,35.81 93.4,35 96.16,35 97.5,33.67 100.94,33.67 102.03,34.76 103.22,34.76 v2(103.24,34.78) 104.27,34.78 104.72,34.33 110.48,34.33 110.67,34.52 116.2,34.52 116.85,33.87 117.82,33.87 119.56,35.6 120.31,35.6 120.73,36.02 123.39,36.02 124.38,35.03 126.24,35.03 128.45,37.25 135.98,37.25 136.78,38.05 143.64,38.05 144.39,37.29 144.39,36.74 145.6,35.53 145.96,35.53 146.94,34.54 147.81,34.54 148.57,33.78 156.1,33.78 157.09,34.77 158.44,34.77 159.19,34.02 161.63,34.02 162.39,33.26 162.9,33.26 163.56,32.6 164.58,32.6 165.17,32.01 168.18,32.01 168.61,32.44 169.46,32.44 169.96,31.94 172.35,31.94 172.53,32.12 173.8,32.12 173.97,31.96 175.37,31.96 175.97,31.37 180.24,31.37 180.59,31.02 182.37,31.02 183.33,31.98 184.68,31.98 185.11,31.55 185.37,31.55 186.01,30.9 186.5,30.9 187.03,30.37 187.83,30.37 187.95,30.25 191.8,30.25 192.49,29.55 195.36,29.55 196.04,28.88 196.04,27.43 196.3,27.16 196.46,27.16 v2(196.71,27.41)
  BOTTOM w0.079: v2(84.69,37.86) 84.69,37.83 U1.CK20
  BOTTOM w0.102: R665.2 196.69,27.33 196.71,27.34 196.71,27.41 v2(196.71,27.41)
CNV_BRI_RSP_L: length 9.8
  BOTTOM w0.102: CN17.22 190.78,25.35 190.37,24.94 190.37,24.23 190.82,23.78 192.18,23.78 192.79,24.39 194.83,24.39 195.25,24.81 v1(195.25,25.18) 195.25,26.52 195.46,26.73 R665.1
CNV_RF_RESET#: length 79.1
  TOP w0.102: v2(145.3,26.81) 145.58,26.81 145.82,26.57 U35.1 145.82,25.53 146.42,24.93 R677.1 146.64,25.37 146.47,25.54 U35.2
  IN1 w0.089: v2(145.3,26.81) 145.3,26.43 144.69,25.82 143.59,25.82 143.34,25.58 138.35,25.58 137.66,26.26 134.98,26.26 134.16,27.08 133.08,27.08 132.72,26.72 129.97,26.72 129.06,25.81 127.3,25.81 125.56,27.55 111.42,27.55 111.23,27.36 105.95,27.36 105.31,28.01 103.49,28.01 102.77,28.73 99.96,28.73 98.54,30.15 96.46,30.15 95.55,31.05 95.4,31.05 94.31,32.15 94.31,32.2 93.94,32.57 88.54,32.57 87.95,33.16 87.18,33.16 85.42,34.92 84.21,34.92 82.7,36.43 82.43,36.43 81.37,37.49 80.39,37.49 80.07,37.81 78.47,37.81 78.07,38.21 v2(78.07,38.24)
  BOTTOM w0.079: U1.CJ32 77.74,37.94 78.04,38.24 v2(78.07,38.24)
CNV_RF_RESET#_L: length 52.5
  TOP w0.102: U35.4 147.12,29.16 146.57,29.7 R676.1 146.48,27.81 147,27.29 147.55,27.29 v2(148.22,26.62)
  IN3 w0.089: v2(189.37,27.09) 189.06,26.78 188.2,26.78 187.81,26.4 186.87,26.4 186.45,26.82 186.45,26.96 186.22,27.19 185.46,27.19 184.67,26.4 183.25,26.4 182.55,27.09 181.08,27.09 180.51,26.52 171.69,26.52 170.98,25.81 168.59,25.81 167.92,25.14 165.08,25.14 164.65,25.57 154.04,25.57 153.57,26.04 149.55,26.04 148.96,26.62 v2(148.22,26.62)
  BOTTOM w0.102: CN17.10 189.97,28.88 189.82,28.74 189.82,28.36 189.42,27.95 189.42,27.14 v2(189.37,27.09)
CNV_RGI_DT: length 109.3
  TOP w0.102: R183.2 106.41,33.11 105.88,33.64 v2(105.26,33.64) 105.02,33.41 R666.1
  IN2 w0.089: v2(105.26,33.64) 106.41,33.64 106.59,33.82 110.78,33.82 111.05,34.09 116.02,34.09 116.69,33.43 117.99,33.43 119.73,35.17 120.55,35.17 120.97,35.59 123.18,35.59 124.17,34.6 126.42,34.6 128.48,36.66 138.14,36.66 138.51,36.29 144.23,36.29 145.42,35.1 145.78,35.1 147.52,33.35 156.51,33.35 156.74,33.58 161.31,33.58 161.92,32.97 161.92,32.39 162.24,32.07 164.5,32.07 165.07,31.5 168.33,31.5 168.84,32.01 169.18,32.01 169.71,31.48 175.25,31.48 175.79,30.94 180.01,30.94 180.36,30.59 182.55,30.59 182.82,30.85 185.45,30.85 185.83,30.47 186.32,30.47 186.86,29.94 187.65,29.94 187.85,29.74 191.69,29.74 192.48,28.96 192.65,28.96 193.1,28.51 193.1,27.62 193.58,27.14 194.68,27.14 195.69,26.13 v2(195.8,26.13)
  BOTTOM w0.102: v2(195.8,26.13) 195.8,25.89 195.72,25.81 195.72,24.42 195.41,24.12 194.32,24.12 194.07,23.86 194.07,23.76 R180.2 193.68,23.84 193.68,23.9 193.41,24.16 192.89,24.16 192.28,23.55 191.78,23.55 191.6,23.38 CN17.32
CNV_RGI_DT_R: length 23.5
  TOP w0.102: v2(105.12,32.88) 105.04,32.96 R666.2
  IN2 w0.089: v2(105.12,32.88) 105.09,32.88 105.09,32.88 105.09,32.86 104.97,32.74 101.21,32.74 100.72,33.23 97.06,33.23 95.78,34.52 93.21,34.52 92.66,35.07 90.09,35.07 89.72,35.43 87.99,35.43 86.8,36.62 v2(86.8,38.85)
  BOTTOM w0.102: U1.CG19 86.42,39.24 v2(86.8,38.85)
CNV_RGI_RSP: length 130.2
  TOP w0.102: R663.2 105.32,32.34 v2(105.68,32.7)
  IN2 w0.089: v2(85.81,38.34) 86.31,37.84 86.31,36.73 87.82,35.22 89.6,35.22 90.09,34.72 92.58,34.72 93.07,34.23 93.7,34.23 94.39,33.54 96.34,33.54 96.86,33.02 100.45,33.02 101.12,32.35 105.17,32.35 105.52,32.7 v2(105.68,32.7) 106.4,33.43 110.69,33.43 111.14,33.87 114.01,33.87 115.06,32.82 115.77,32.82 116,32.58 117.45,32.58 119.82,34.96 120.94,34.96 121.36,35.37 123.09,35.37 124.08,34.38 126.51,34.38 128.57,36.45 137.97,36.45 138.34,36.08 144.11,36.08 145.32,34.86 145.71,34.86 147.62,32.95 156.41,32.95 156.83,33.37 161.19,33.37 161.7,32.86 161.7,32.3 162.15,31.86 164.41,31.86 165,31.26 175.16,31.26 175.7,30.72 179.89,30.72 180.24,30.37 182.64,30.37 182.91,30.64 185.36,30.64 185.74,30.26 186.23,30.26 186.77,29.72 187.56,29.72 187.76,29.53 191.6,29.53 192.64,28.48 192.64,27.7 193.43,26.91 194.35,26.91 195.51,25.74 196.05,25.74 v2(196.38,26.07)
  BOTTOM w0.079: v2(85.81,38.34) 86.06,38.59 U1.CH19
  BOTTOM w0.102: v2(196.38,26.07) 196.63,25.82 196.63,24.81 v1(195.47,23.65) 194.92,23.1 193.77,23.1 R667.2
CNV_RGI_RSP_L: length 2.6
  BOTTOM w0.102: CN17.34 191.56,22.88 191.81,23.13 192.97,23.13 R667.1
CNV_WR_CLK_DN: length 127.5
  IN1 w0.089: v2(79.11,33.29) 79.11,33 79.21,32.9 79.21,32.1 79.55,31.76 80.73,31.76 80.82,31.86 80.82,32.7 81.03,32.9 81.72,32.9 81.93,32.7 81.93,31.76 82.59,31.1 83.79,31.1 84.8,30.09 86.23,30.09 87.41,28.92 88.25,28.92 88.45,28.71 91.74,28.71 91.9,28.56 94.4,28.56 95.16,27.8 95.16,26.77 96.24,25.69 96.94,25.69 100.16,22.47 105.92,22.47 106.01,22.56 106.01,22.7 106.22,22.91 106.75,22.91 106.95,22.7 106.95,22.38 107.04,22.29 107.4,22.29 107.49,22.38 107.49,22.73 107.7,22.94 108.22,22.94 108.43,22.73 108.43,22.39 108.52,22.3 108.87,22.3 108.96,22.39 108.96,22.73 109.17,22.94 109.7,22.94 109.9,22.73 109.9,22.56 109.99,22.47 113.12,22.47 113.29,22.64 119.33,22.64 120.6,23.91 122.72,23.91 124.03,22.59 125.96,22.59 127.23,21.32 133.79,21.32 134.45,21.98 137.26,21.98 137.81,21.42 145.27,21.42 145.65,21.05 155.04,21.05 155.59,20.51 158.41,20.51 158.99,19.93 162.92,19.93 163.36,19.49 164.41,19.49 165.01,18.9 173.77,18.9 174.22,19.34 177.73,19.34 178.29,19.9 179.19,19.9 179.28,19.99 179.28,20.24 v2(179.1,20.43)
  BOTTOM w0.079: v2(79.11,33.29) 78.87,33.29 78.78,33.38 78.78,34.25 78.89,34.37 78.89,35.04 78.72,35.21 78.56,35.21 78.46,35.32 U1.CN31
  BOTTOM w0.102: CN17.21 182.49,26.13 182.35,25.99 181.18,25.99 180.97,25.78 180.46,25.78 179.96,25.27 179.2,25.27 178.23,24.3 178.23,23.16 178.31,23.09 178.31,21.87 179.28,20.9 179.28,20.61 v2(179.1,20.43)
CNV_WR_CLK_DP: length 127.5
  IN1 w0.089: v2(78.7,32.88) 78.94,32.88 79.01,32.82 79.01,32.01 79.46,31.56 80.81,31.56 81.02,31.77 81.02,32.61 81.11,32.7 81.63,32.7 81.72,32.61 81.72,31.68 82.5,30.9 83.7,30.9 84.71,29.89 86.15,29.89 87.33,28.71 88.17,28.71 88.37,28.51 91.65,28.51 91.81,28.35 94.32,28.35 94.96,27.71 94.96,26.68 96.15,25.48 96.85,25.48 100.08,22.26 106.01,22.26 106.22,22.47 106.22,22.62 106.3,22.71 106.66,22.71 106.75,22.62 106.75,22.29 106.96,22.08 107.48,22.08 107.69,22.29 107.69,22.65 107.78,22.74 108.14,22.74 108.22,22.65 108.22,22.31 108.43,22.1 108.96,22.1 109.17,22.31 109.17,22.65 109.26,22.74 109.61,22.74 109.7,22.65 109.7,22.47 109.91,22.26 113.2,22.26 113.38,22.44 119.42,22.44 120.68,23.7 122.64,23.7 123.95,22.39 125.87,22.39 127.15,21.12 133.88,21.12 134.53,21.77 137.17,21.77 137.73,21.22 145.19,21.22 145.56,20.85 154.96,20.85 155.5,20.31 158.33,20.31 158.91,19.73 162.84,19.73 163.27,19.29 164.33,19.29 164.92,18.69 173.86,18.69 174.3,19.14 177.81,19.14 178.37,19.7 179.28,19.7 179.49,19.9 179.49,20.23 v2(179.68,20.43)
  BOTTOM w0.079: v2(78.7,32.88) 78.7,33.24 78.62,33.32 78.62,34.32 78.73,34.43 78.73,34.98 78.66,35.06 78.55,35.06 78.46,34.96 U1.CP31
  BOTTOM w0.102: CN17.23 182.52,25.63 182.38,25.77 181.27,25.77 181.06,25.56 180.55,25.56 180.05,25.06 179.29,25.06 178.45,24.21 178.45,23.25 178.52,23.18 178.52,21.96 179.49,20.99 179.49,20.62 v2(179.68,20.43)
CNV_WR_LANE0_DN: length 126.9
  IN1 w0.089: v2(177.35,20.38) 177.53,20.2 177.53,20.06 177.42,19.95 167.27,19.95 167.22,20 166.7,20 166.65,19.95 164.8,19.95 164.57,20.19 163.51,20.19 163.15,20.55 159.24,20.55 158.67,21.12 157.02,21.12 156.88,21.26 156.88,21.94 156.66,22.16 156.3,22.16 156.08,21.94 156.08,21.3 155.99,21.21 155.77,21.21 155.69,21.3 155.69,21.86 155.36,22.18 142.37,22.18 142.28,22.27 142.28,22.37 142.08,22.58 141.55,22.58 141.34,22.37 141.34,22.27 141.25,22.18 140.9,22.18 140.81,22.27 140.81,22.37 140.6,22.58 140.07,22.58 139.87,22.37 139.87,22.27 139.78,22.18 139.42,22.18 139.33,22.27 139.33,22.37 139.12,22.58 138.6,22.58 138.39,22.37 138.39,22.27 138.3,22.18 137.9,22.18 137.51,22.58 134.2,22.58 133.54,21.92 127.48,21.92 126.21,23.19 124.5,23.19 123.19,24.51 120.33,24.51 119.09,23.26 113.07,23.26 112.87,23.07 112.35,23.07 111.86,23.55 105.56,23.55 105.13,23.13 100.59,23.13 97.22,26.5 97.22,26.81 94.87,29.17 92.22,29.17 91.84,29.56 90.72,29.56 90.27,30.01 87.23,30.01 86.55,30.69 85.19,30.69 84.17,31.71 83.38,31.71 83.09,32.01 83.09,33.06 82.77,33.39 82.13,33.39 82,33.51 82,34.01 81.31,34.71 79.91,34.71 79.64,34.44 79.64,33.77 79.51,33.64 79.51,33.2 79.72,32.99 79.93,32.99 v2(80.12,32.8)
  BOTTOM w0.079: v2(80.12,32.8) 79.92,33.01 79.74,33.01 79.58,33.16 79.58,34.08 79.25,34.41 79.25,34.58 U1.CR30
  BOTTOM w0.102: v2(177.35,20.38) 177.51,20.54 177.51,21.04 177.2,21.35 177.2,22.7 177.57,23.06 177.57,24.56 178.92,25.91 179.71,25.91 180.21,26.4 180.46,26.4 181.69,27.63 CN17.15
CNV_WR_LANE0_DP: length 126.9
  IN1 w0.089: v2(177.93,20.38) 177.73,20.19 177.73,19.98 177.51,19.75 167.18,19.75 167.13,19.8 166.79,19.8 166.74,19.75 164.72,19.75 164.48,19.99 163.42,19.99 163.06,20.35 159.15,20.35 158.58,20.92 156.93,20.92 156.68,21.17 156.68,21.86 156.58,21.96 156.38,21.96 156.28,21.86 156.28,21.22 156.08,21.01 155.69,21.01 155.48,21.22 155.48,21.77 155.28,21.98 142.29,21.98 142.08,22.18 142.08,22.28 141.99,22.37 141.63,22.37 141.55,22.28 141.55,22.18 141.34,21.98 140.81,21.98 140.6,22.18 140.6,22.29 140.52,22.38 140.16,22.38 140.07,22.29 140.07,22.18 139.86,21.98 139.34,21.98 139.13,22.18 139.13,22.29 139.04,22.38 138.68,22.38 138.6,22.29 138.6,22.18 138.39,21.98 137.82,21.98 137.42,22.37 134.29,22.37 133.63,21.71 127.4,21.71 126.12,22.99 124.42,22.99 123.11,24.3 120.41,24.3 119.17,23.06 113.15,23.06 112.96,22.86 112.26,22.86 111.78,23.35 105.64,23.35 105.22,22.92 100.51,22.92 97.02,26.41 97.02,26.73 94.78,28.97 92.14,28.97 91.75,29.35 90.64,29.35 90.19,29.81 87.15,29.81 86.47,30.49 85.1,30.49 84.09,31.51 83.3,31.51 82.89,31.92 82.89,32.98 82.68,33.18 82.04,33.18 81.8,33.43 81.8,33.93 81.22,34.5 80,34.5 79.84,34.35 79.84,33.68 79.71,33.55 79.71,33.28 79.8,33.2 79.93,33.2 v2(80.12,33.39)
  BOTTOM w0.079: v2(80.12,33.39) 79.9,33.16 79.8,33.16 79.74,33.23 79.74,34.15 79.41,34.48 79.41,35 U1.CP30
  BOTTOM w0.102: CN17.17 182.47,27.13 182.18,27.41 181.78,27.41 180.55,26.19 180.3,26.19 179.8,25.69 179,25.69 177.79,24.47 177.79,22.97 177.42,22.61 177.42,21.44 177.72,21.13 177.72,20.59 v2(177.93,20.38)
CNV_WR_LANE1_DN: length 127.8
  IN1 w0.089: v2(184.97,21.27) 184.92,21.27 184.29,21.91 183.47,21.91 182.54,20.98 180.97,20.98 180.25,21.7 176.11,21.7 175.77,22.05 175.26,22.05 174.36,21.15 167.95,21.15 167.9,21.2 166.15,21.2 166.11,21.16 165.61,21.16 164.05,22.73 159.26,22.73 158.61,23.38 147.06,23.38 146.73,23.71 144.89,23.71 144.66,23.94 137.4,23.94 136.55,24.78 133.33,24.78 133.12,24.57 125.18,24.57 124.05,25.7 119.21,25.7 118.49,24.97 111.91,24.97 111.68,24.75 104.67,24.75 104.55,24.63 102.88,24.63 102.27,25.24 101.64,25.24 101.21,25.67 101.21,26.13 98.55,28.79 96.99,28.79 95.41,30.37 93.79,30.37 93.32,30.84 93.32,31.09 92.51,31.89 85.9,31.89 85.53,32.25 85.53,33.04 82.9,35.67 82.31,35.67 81.52,36.46 79.39,36.46 78.98,36.87 78.98,37.12 79.11,37.26 v2(79.2,37.26)
  BOTTOM w0.079: U1.CM30 78.96,36.78 78.96,37.1 79.11,37.26 v2(79.2,37.26)
  BOTTOM w0.102: CN17.9 184.18,29.13 184.32,28.99 184.72,28.99 185.6,28.12 185.6,26.44 186.17,25.87 186.17,23.61 185.6,23.04 185.6,22.95 184.84,22.18 184.84,21.41 v2(184.97,21.27)
CNV_WR_LANE1_DP: length 127.8
  IN1 w0.089: v2(78.62,37.24) 78.62,37.24 78.78,37.08 78.78,36.78 79.3,36.26 81.43,36.26 82.22,35.47 82.82,35.47 85.33,32.96 85.33,32.17 85.81,31.68 92.43,31.68 93.11,31 93.11,30.75 93.7,30.16 95.33,30.16 96.9,28.59 98.46,28.59 101,26.05 101,25.59 101.55,25.04 102.19,25.04 102.8,24.43 104.64,24.43 104.75,24.54 111.77,24.54 111.99,24.77 118.57,24.77 119.3,25.5 123.97,25.5 125.1,24.36 133.2,24.36 133.42,24.58 136.47,24.58 137.31,23.74 144.58,23.74 144.81,23.51 146.64,23.51 146.98,23.17 158.52,23.17 159.17,22.52 163.96,22.52 165.53,20.95 166.2,20.95 166.24,20.99 167.82,20.99 167.87,20.94 174.45,20.94 175.34,21.84 175.68,21.84 176.03,21.49 180.17,21.49 180.89,20.78 182.62,20.78 183.55,21.7 184.2,21.7 184.39,21.52 v2(184.39,21.27)
  BOTTOM w0.079: U1.CN30 79.15,36.09 78.8,36.44 78.8,37.05 78.62,37.24 v2(78.62,37.24)
  BOTTOM w0.102: CN17.11 184.18,28.63 184.32,28.77 184.63,28.77 185.38,28.03 185.38,26.35 185.95,25.78 185.95,23.7 185.38,23.13 185.38,23.04 184.62,22.27 184.62,21.5 v2(184.39,21.27)
CNV_WT_CLK_DN: length 132
  IN1 w0.089: v2(171.21,17.69) 171.19,17.69 170.79,17.28 163.68,17.28 163.4,17.56 159.04,17.56 158,18.6 155.94,18.6 155.51,19.04 154.99,19.04 154.38,19.65 145.07,19.65 144.7,20.02 137.15,20.02 136.59,20.58 135.23,20.58 134.45,19.8 132.86,19.8 132.23,19.16 130.56,19.16 129.84,19.88 126.64,19.88 126.22,20.31 123.33,20.31 122.53,21.11 122.53,21.51 121.74,22.29 120.96,22.29 119.89,21.22 113.86,21.22 113.71,21.07 110.89,21.07 110.7,20.88 103.71,20.88 103.52,21.07 98.06,21.07 97.6,21.52 97.6,21.81 98.1,22.31 98.1,22.44 97.85,22.69 97.73,22.69 96.44,21.41 96.15,21.41 95.78,21.78 95.78,22.07 97.05,23.35 97.05,23.48 96.8,23.73 96.68,23.73 96.18,23.24 95.89,23.24 95.1,24.02 95.1,24.77 94.72,25.16 94.13,25.16 92.97,26.33 91.48,26.33 90.5,27.3 85.16,27.3 83.87,28.59 77.1,28.59 76.82,28.87 76.82,29.98 76.46,30.35 75.66,30.35 75.4,30.61 74.93,30.61 74.43,31.12 74.43,32.04 75.53,33.14 75.9,33.14 76.21,33.45 76.21,33.78 76.59,34.16 v2(76.59,34.2)
  BOTTOM w0.079: U1.CP34 76.74,35.34 76.74,34.85 76.79,34.8 76.79,34.39 v2(76.59,34.2)
  BOTTOM w0.102: CN17.71 182.15,13.63 182.03,13.51 181.03,13.51 180.54,14 173.81,14 171,16.8 171,17.49 v2(171.21,17.69)
CNV_WT_CLK_DP: length 132.1
  IN1 w0.089: v2(76.59,33.62) 76.59,33.54 75.99,32.93 75.62,32.93 74.64,31.95 74.64,31.2 75.02,30.82 75.48,30.82 75.75,30.55 76.54,30.55 77.02,30.07 77.02,28.95 77.19,28.79 83.96,28.79 85.24,27.51 90.59,27.51 91.56,26.53 93.05,26.53 94.22,25.36 94.8,25.36 95.31,24.86 95.31,24.1 95.97,23.44 96.1,23.44 96.59,23.94 96.89,23.94 97.26,23.56 97.26,23.27 95.98,21.99 95.98,21.86 96.23,21.61 96.36,21.61 97.64,22.9 97.94,22.9 98.31,22.52 98.31,22.23 97.81,21.73 97.81,21.6 98.14,21.27 103.61,21.27 103.8,21.08 110.62,21.08 110.81,21.27 113.63,21.27 113.78,21.42 119.81,21.42 120.88,22.5 121.83,22.5 122.73,21.59 122.73,21.2 123.42,20.51 126.3,20.51 126.73,20.08 129.92,20.08 130.64,19.37 132.14,19.37 132.78,20 134.37,20 135.15,20.78 136.68,20.78 137.24,20.23 144.78,20.23 145.15,19.86 154.46,19.86 155.08,19.24 155.59,19.24 156.03,18.81 158.09,18.81 159.13,17.77 163.49,17.77 163.77,17.49 170.42,17.49 v2(170.62,17.69)
  BOTTOM w0.079: U1.CN34 76.66,35.82 76.75,35.73 76.94,35.53 76.94,35.3 76.91,35.27 76.91,34.92 76.95,34.87 76.95,33.98 v2(76.59,33.62)
  BOTTOM w0.102: v2(170.62,17.69) 170.79,17.53 170.79,16.71 173.72,13.78 180.45,13.78 180.94,13.29 182.03,13.29 182.19,13.13 CN17.73
CNV_WT_LANE0_DN: length 132
  IN1 w0.089: v2(77.46,37.28) 77.64,37.11 77.63,36.72 77.63,36.55 78.79,35.39 81.19,35.39 81.99,34.6 82.77,34.6 83.08,34.29 83.08,33.68 83.5,33.26 83.92,33.26 84.26,32.92 84.26,32.27 85.45,31.09 86.89,31.09 87.56,30.42 90.42,30.42 90.89,29.95 92,29.95 92.39,29.56 95.07,29.56 97.37,27.27 97.82,27.27 98.33,26.75 98.33,25.96 100.7,23.6 104.84,23.6 105.18,23.94 112.26,23.94 112.46,24.14 118.81,24.14 119.56,24.9 123.36,24.9 124.67,23.59 126.64,23.59 127.92,22.31 133.13,22.31 133.54,22.72 133.54,23.86 133.67,23.98 134.82,23.98 134.94,23.86 134.94,23.23 135.19,22.97 144.32,22.97 144.48,22.82 146.48,22.82 146.73,22.57 157.78,22.57 159.41,20.95 163.31,20.95 163.67,20.59 164.77,20.59 165,20.36 166.53,20.36 166.57,20.4 167.46,20.4 167.51,20.35 176.74,20.35 177.2,20.8 179.95,20.8 181.41,19.34 185.83,19.34 187.43,17.73 187.43,17.34 187.72,17.05 v2(187.72,16.65)
  BOTTOM w0.079: v2(77.46,37.28) 77.53,37.21 77.53,36.59 77.84,36.28 U1.CN32
  BOTTOM w0.102: v2(187.72,16.65) 187.95,16.42 187.95,16.24 186.66,14.96 184.25,14.96 184.08,15.13 CN17.65
CNV_WT_LANE0_DP: length 132
  IN1 w0.089: v2(78.02,37.28) 77.84,37.1 77.84,36.72 77.84,36.64 78.88,35.6 81.28,35.6 82.07,34.8 82.86,34.8 83.28,34.38 83.28,33.77 83.59,33.46 84.01,33.46 84.47,33.01 84.47,32.35 85.53,31.29 86.97,31.29 87.64,30.62 90.51,30.62 90.97,30.15 92.09,30.15 92.47,29.77 95.16,29.77 97.45,27.47 97.9,27.47 98.54,26.83 98.54,26.05 100.78,23.8 104.76,23.8 105.1,24.15 112.17,24.15 112.37,24.34 118.72,24.34 119.48,25.1 123.44,25.1 124.76,23.79 126.73,23.79 128,22.52 133.05,22.52 133.33,22.8 133.33,23.94 133.58,24.19 134.9,24.19 135.14,23.95 135.14,23.31 135.27,23.18 144.41,23.18 144.56,23.02 146.57,23.02 146.81,22.78 157.86,22.78 159.49,21.15 163.39,21.15 163.75,20.79 164.86,20.79 165.08,20.56 166.45,20.56 166.49,20.6 167.55,20.6 167.6,20.55 176.66,20.55 177.12,21.01 180.03,21.01 181.49,19.55 185.91,19.55 187.64,17.82 187.64,17.43 187.92,17.14 187.92,16.98 188.28,16.62 v2(188.3,16.62)
  BOTTOM w0.079: U1.CM32 77.76,36.64 77.69,36.71 77.69,37 77.97,37.28 v2(78.02,37.28)
  BOTTOM w0.102: v2(188.3,16.62) 188.16,16.48 188.16,16.15 186.75,14.74 184.31,14.74 184.2,14.63 CN17.67
