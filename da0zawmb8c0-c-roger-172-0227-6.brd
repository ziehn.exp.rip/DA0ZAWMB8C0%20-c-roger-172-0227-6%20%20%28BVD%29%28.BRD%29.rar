# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Library data of the parts (continued)
PL12 PL9002 = INDUCTOR_BGM: tolerance: CV+68F5MZ05
PL14 = INDUCTOR_BGM: tolerance: CV-2219MZ02
PL30 PL6000 PL6001 = INDUCTOR_BGM: tolerance: CV-10B0MZ13
PL551 = INDUCTOR_BGM: tolerance: CV-1037MZ00
PL7000 PL7001 PL7003 = INDUCTOR_BGM: tolerance: CV+15^0MZ09
PL7002 = INDUCTOR_BGM: tolerance: CV+47R0MZ07
PL9000 PL9001 = INDUCTOR_BGM: tolerance: CV+22N0MZ04
PQ1 PQ2 PQ9054 = MOS-N_8P_BGM: tolerance: BAM23140000
PQ6 PQ10 PQ12 PQ14 PQ19 PQ25 PQ6000 PQ6001 PQ9009 PQ9011 PQ9050 PQ9085 = MOS-N_3P_ESD_BGM: tolerance: BAM70020002
PQ7 PQ16 PQ9083 = DTC144EU_BGM: tolerance: BA001440013
PQ9 PQ11 = MOS-N_3P_BGM: tolerance: BAM34040001
PQ17 Q9 Q14-Q16 Q20-Q22 Q29 Q33 Q34 Q63 Q81 Q85 Q6505 Q6507 Q6509 Q6512 Q6515 Q6520 Q6531 Q6533 = MOS-N_3P_ESD_BGM
PQ29 PQ30 PQ7002 = MOS-N_8P_BGM: tolerance: BAM74100001
PQ35 PQ9008 = MOS-N_8P_BGM: tolerance: BAM74080000
PQ7000 PQ7001 = MOS-N-Dual_10P_BGM: tolerance: BAM69320002
PQ7003 = MOS-N_8P_SCH_BGM: tolerance: BAM77520000
PQ7004 PQ9000 PQ9001 = MOS-N-Dual_10P_BGM: tolerance: BAM69360000
PQ9010 PQ9086 = MOS-N_3P_ESD_BGM: tolerance: BAM10120003
PQ9084 = MOS-N_3P_ESD_BGM: tolerance: BAM70020041
PR1 PR2 PR208 PR569 PR6008 PR6026 PR6414 PR7073 PR7074 PR7082 PR7083 PR7088 PR7089 PR7096 PR7097 PR9259 PR9263 PR9266 = SHORTPAD_V01_BGM: tolerance: TMPSHT00201
PR3 PR209 = R_Current_SEN_BGM: tolerance: CS+0108FP01
PR7 PR6000 PR6018 = RES_BGM: tolerance: CS01003F935
PR9 PR15 = RES_BGM: tolerance: CS31002JB28
PR10 PR98 PR205 PR266 PR9025 PR9091 PR9251 PR9252 PR9268 PR9270 PR9272 R25511-R25518 = RES_BGM: tolerance: CS00001JE18
PR12-PR14 = RES_BGM: tolerance: CS11002JB32
PR16 = RES_BGM: tolerance: CS02006J201
PR18 PR9077 PR9101 = RES_BGM: tolerance: CS51002JB21
PR22 PR186 PR275 PR6416 PR9088 PR9255 = RES_BGM: tolerance: CS41001FE08
PR23 = RES_BGM: tolerance: CS34122FB19
PR28 PR29 = RES_BGM: tolerance: CS24022FB13
PR31 = RES_BGM: tolerance: CS48662FB00
PR33 PR99 PR6001 PR6019 PR9092 = RES_BGM: tolerance: CS-4703J917
PR39 PR40 PR206 PR224 PR6007 PR6012 PR6024 PR7060 PR9074 PR9086 PR9100 PR9265 = RES_BGM: tolerance: CS41002FB28
PR59 PR79 PR80 PR116 PR118 PR191 PR9102 PR9104 = RES_BGM: tolerance: CS51003J936
PR104 PR7064 PR9087 = RES_BGM: tolerance: CS01003J953
PR105 PR106 PR111 PR9099 PR9103 PR9227 = RES_BGM: tolerance: CS02204JA18
PR120 PR9105 = RES_BGM: tolerance: CS41003F932
PR126 = RES_BGM: tolerance: CS12204JA44
PR184 PR207 = RES_BGM: tolerance: CS41002JB20
PR204 = RES_BGM: tolerance: CS43162FB00
PR211 = RES_BGM: tolerance: CS41372FB12
PR222 = RES_BGM: tolerance: CS42152FB19
PR230 PR235 R1-R7 R9-R47 R51 R52 R54 R56 R59 R60 R63-R74 R82-R92 R94-R104 R106-R125 R134 R136-R139 R144-R148 R152-R155 R157-R159 R161 R166-R169 R179 R180 R183 R186-R188 R191 R194 R202 R209-R213 R215-R218 R220-R222 R224-R248 R252-R257 R261-R294 R296 R297 R299 R305-R307 R311-R326 R329-R332 R339 R341-R359 R361-R370 R372-R374 R376 R378 R380 R382-R386 R391 R394-R399 R402-R407 R409-R411 R414-R418 R421-R430 R436 R439-R443 R445-R449 R451-R455 R459 R461 R462 R464 R465 R467-R469 R471-R484 R486 R487 R489-R491 R494 R495 R497-R500 R502-R513 R516-R519 R551 R554 R557-R563 R565-R567 R572-R576 R579 R580 R582 R583 R586 R590-R593 R596-R601 R604-R609 R638-R641 R645-R649 R651-R655 R662-R668 R670-R679 R696-R703 R706-R713 R720 R732-R742 R746-R750 R825 R894 R895 R951 R953 R956 R960 R971 R978 R979 R1234-R1239 R1250-R1253 R1260 R1262 R1264-R1267 R1270-R1281 R1284-R1291 R2356 R2525 R2652-R2667 R6504-R6506 R6508 R6510 R6515-R6517 R6603 R9041 R9042 R9048 R9261 R10880 R25270-R25280 R25282-R25285 R25288-R25298 R25300 R25303 R25304 R25306-R25310 R25312 R25314-R25318 R25321-R25323 R25328 R25332 R25336-R25344 R25346-R25348 R25350-R25353 R25355-R25359 R25362-R25364 R25367-R25376 R25378-R25399 R25403 R25413 R25415 R25428-R25431 R25433 R25434 R25436-R25441 R25444-R25446 R25448-R25450 R25456 R25458 R25459 R25462 R25465-R25469 R25471-R25475 R25477 R25479-R25490 R25492-R25495 R25497-R25501 R25503 R25504 R25519-R25522 = RES_BGM
PR253 PR567 PR6003 PR6006 PR6009 PR6014 PR6021 PR6031 PR7042 PR7047 PR7049 PR7054 PR7056 PR7059 PR7063 PR7065 PR7069 PR7103 PR7104 PR9013 PR9022 PR9075 = RES_BGM: tolerance: CS31002FB26
PR254 PR7001 PR7041 PR7043 PR7045 PR7050 PR7052 PR7057 PR7061 PR9026 PR9031 = RES_BGM: tolerance: CS11002FB22
PR256 PR277 PR551 PR7000 PR7072 PR7081 PR7087 PR7095 PR9004 PR9019 PR9089 PR9264 = RES_BGM: tolerance: CS-2203J913
PR261 PR9002 = RES_BGM: tolerance: CS44992FB11
PR263 = RES_BGM: tolerance: CS26042FB00
PR268 = RES_BGM: tolerance: CS37322FB14
PR269 = RES_BGM: tolerance: CS26342FB27
PR270 PR568 = RES_BGM: tolerance: CS32002FB29
PR283 = RES_BGM: tolerance: CS31502FB24
PR3020 = RES_BGM: tolerance: CS11502JB22
PR3021 = RES_BGM: tolerance: CS32552FB11
PR6010 PR6011 PR6029 PR6030 PR9012 = RES_BGM: tolerance: CS21002FB24
PR6418 PR7013 = RES_BGM: tolerance: CS32262FB15
PR7002 = RES_BGM: tolerance: CS11102FB18
PR7003 = RES_BGM: tolerance: CS04532FB12
PR7004 = RES_BGM: tolerance: CS33002FB13
PR7005 = RES_BGM: tolerance: CS33922FB15
PR7006 = RES_BGM: tolerance: CS34642FB16
PR7007 PR7021 PR7032 PR9274 = Thermistor_BGM: tolerance: CU4100B0001
PR7008 = RES_BGM: tolerance: CS-3902FB00
PR7009 PR7010 PR7023 = RES_BGM: tolerance: CS31272FB17
PR7011 PR7068 PR9009 PR9033 PR9076 = RES_BGM: tolerance: CS31001FE14
PR7014 = RES_BGM: tolerance: CS22322FB01
PR7015 PR7027 = RES_BGM: tolerance: CS04992FB31
PR7016 PR7017 = RES_BGM: tolerance: CS21052FB00
PR7018 PR7026 = RES_BGM: tolerance: CS55602FB00
PR7019 = RES_BGM: tolerance: CS01002FB21
PR7022 = RES_BGM: tolerance: CS25902FB10
PR7024 = RES_BGM: tolerance: CS33742FB17
PR7028 = RES_BGM: tolerance: CS06982FB00
PR7029 PR7098 = RES_BGM: tolerance: CS16492FB13
PR7030 PR7031 = RES_BGM: tolerance: CS31402FB12
PR7033 PR7034 PR7037 = RES_BGM: tolerance: CS31052FB02
PR7035 = RES_BGM: tolerance: CS23162FB04
PR7036 = RES_BGM: tolerance: CS27322FB12
PR7038 = RES_BGM: tolerance: CS27502FB11
PR7040 = RES_BGM: tolerance: CS13012FB14
PR7048 = RES_BGM: tolerance: CS36342FB11
PR7055 = RES_BGM: tolerance: CS32612FB09
PR7066 PR9096 PR9253 = RES_BGM: tolerance: CS00002JB38
PR7075 PR7085 = RES_BGM: tolerance: CS13652FB14
PR7076 PR7084 = RES_BGM: tolerance: CS15362FB13
PR7078 PR7106 PR7110 PR7114 PR9000 PR9001 PR9006 PR9014 = RES_BGM: tolerance: CS-1003J913
PR7080 PR7108 PR7112 PR7116 = RES_BGM: tolerance: CS-2203F911
PR7090 PR9030 = RES_BGM: tolerance: CS13092FB03
PR7091 = RES_BGM: tolerance: CS11822FB21
PR7092 = RES_BGM: tolerance: CS24702FB10
PR7093 PR7101 = 10K-0603-1%: tolerance: CU2470B0001
PR7099 = RES_BGM: tolerance: CS17152FB17
PR7100 = RES_BGM: tolerance: CS24752FB12
PR9011 PR9032 = RES_BGM: tolerance: CS31472FB14
PR9018 = RES_BGM: tolerance: CS31202FB15
PR9021 = RES_BGM: tolerance: CS32052FB21
PR9023 = RES_BGM: tolerance: CS26192FB14
PR9024 = RES_BGM: tolerance: CS24322FB14
PR9027 = RES_BGM: tolerance: CS31652FB12
PR9073 = RES_BGM: tolerance: CS-5604JA13
PR9080 = RES_BGM: tolerance: CS04702FB16
PR9081 = RES_BGM: tolerance: CS11332FB19
PR9082 = RES_BGM: tolerance: CS11242FB10
PR9094 = RES_BGM: tolerance: CS26492FB23
PR9095 = RES_BGM: tolerance: CS22202JB18
PR9097 = RES_BGM: tolerance: CS29312FB13
PR9254 = RES_BGM: tolerance: CS00004FA00
PU1 = BQ24780SRUYR_BGM: tolerance: AL024780001
PU14 = G9661-25ADJF12U_BGM: tolerance: AL009661003
PU16 = G5335QT2U_BGM: tolerance: AL005335005
PU26 = G5416QS1U_30P_V2_BGM: tolerance: AL005416001
PU3002 = TMP708_BGM: tolerance: AL000708001
PU3003 = JW5222RSOTB#TRPBF_6P_V1_BGM: tolerance: AL005222000
PU3004 = JW5213DFND_8P_BGM: tolerance: AL005213003
PU6000 = RT6256BGQUF_12P_BGM: tolerance: AL006256000
PU6001 PU6002 PU9002 = AOZ1331DI_BGM: tolerance: AL007110000
PU6003 = RT6258CGQUF_12P_BGM: tolerance: AL006258006
PU7000 = RT3602AJGQW_48P_BGM_1: tolerance: AL003602004
PU7001-PU7004 = RT9610BZQW_BGM: tolerance: AL009610001
PU9000 = RT8813DGQW_BGM: tolerance: AL008813004
PU9003 = G9336ADJTP1U_BGM: tolerance: AL009336000
PU9004 = G5335QT2U_V1_BGM: tolerance: AL005335005
Q3 Q27 Q41 Q6519 Q6521 = MOS-N_Dual_6P_ESD_BGM
Q13 = 2N7002_3
Q30 Q32 = MOS-P_3P_BGM
Q31 Q6522 = DTC144EU_BGM
Q86 = NPN_0
Q6508 = AP2331SA-7-01_BGM
Q6516 = MOS-P_8P_BGM
Q6518 = DTA124EU_0
Q6523 = NPN_BGM
R77-R81 = R_Current_SEN_BGM
R340 R890 R25311 R25320 R25502 = RES_S_BGM
R450 R460 R463 R470 R589 R614 R775 R777 R25330 R25365 R25366 = SHORTPAD_BGM
R821 R822 R25377 = R_3
RV1 = TVS_DIODE_DUAL_BGM
RV2 RV3 = TPD4E02B04DQAR_BGM
SW1 = SW_4P_BGM
SW2 = SW_6P_R_BGM
SW3 = SW_6P_BGM
TP1 TP3-TP7 TP9-TP12 TP14-TP48 TP50 TP52 TP54 TP55 TP65-TP78 TP81 TP2090 TP2092 TP9011 TP9012 TP9018 TP9019 TP9021 TP9023-TP9027 TP9029-TP9033 TP9035 TP9037-TP9044 = TP_BGM
TP9000 TP9001 = TP_BGM: tolerance: TMPTST00003
U1 = CFL_U_43E_IL_IP_DDR4_8
U2 = SPI_WND_8P_BGM
U3 = AP2821KTR-G1_BGM
U4-U7 = DDR4_96P_BGM
U8 = GPU_N16S-GTR_595P_BGM
U9 U6504 = Logic_AND_BGM
U11 = NL17SZ32DFT2G_BGM
U14 = SLGC55544VTR_BGM
U15 U18 = MAX8863_2
U16 U17 = LXESEABAA6-046_0
U19 = APL3512ABI-TRG_BGM
U20 = ALC255-CG_BGM_0
U23 = PTN3366BS_BGM
U24 = RTL8111HSH-CG_BGM
U25 = NS680016_0
U32 = LIS3DHTR_BGM
U33 = NPCT750AAAYX_32P_BGM
U35 U36 = NL17SZ08DFT2G_5P_BGM
U37 = IT8987E/CX_BGM
U42 = SN75LVCP601RTJR_BGM
U6502 = PI2EQX632EXUBE_0
U6503 = TPS25810RVC/SSOP_0
VRAM1 VRAM2 = GDDR5_170P_BGM
Y1 = CRYSTAL_2P_BGM
Y2-Y4 = CRYSTAL_4P_BGM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-6X6-S
  round 0.991 smd: 1(6,-3)
132F18-100000-A2-R-18P-L
  rect 0.305x0.838 smd: 1(-4.25,3.175) 2(-3.75,3.175) 3(-3.25,3.175) 4(-2.75,3.175) 5(-2.25,3.175) 6(-1.75,3.175) 7(-1.25,3.175) 8(-0.75,3.175) 9(-0.25,3.175) 10(0.25,3.175) 11(0.75,3.175) 12(1.25,3.175) 13(1.75,3.175) 14(2.25,3.175) 15(2.75,3.175) 16(3.25,3.175) 17(3.75,3.175) 18(4.25,3.175)
  rect 0.787x2.007 smd: 19(-5.95,0) 20(5.95,0)
50208-00401-V02-4P-L
  rect 0.508x0.991 smd: 1(-1.2,1.95) 2(-0.4,1.95) 3(0.4,1.95) 4(1.2,1.95)
  rect 1.194x1.702 smd: 5(-2.5,0) 6(2.5,0)
50281-00201-001-2P-L
  rect 0.787x2.007 smd: 1(-0.625,4.05) 2(0.625,4.05)
  rect 2.007x2.489 smd: 3(-2.825,0) 4(2.825,0)
50458-00801-V02-8P-L
  rect 0.559x1.295 smd: 1(-7,5.025) 2(-5,5.025) 3(-3,5.025) 4(-1,5.025) 5(1,5.025) 6(3,5.025) 7(5,5.025) 8(7,5.025)
  rect 1.295x2.057 smd: 9(-10.1,0) 10(10.1,0)
50505-00401-V01-4P-L
  rect 0.61x1.295 smd: 1(-1.5,3.25) 2(-0.5,3.25) 3(0.5,3.25) 4(1.5,3.25)
  rect 0.991x2.007 smd: 5(-4.1,0) 6(4.1,0)
50584-0280N-V02-28P-L
  rect 0.61x1.092 smd: 1(-13.5,2.05) 2(-12.5,2.05) 3(-11.5,2.05) 4(-10.5,2.05) 5(-9.5,2.05) 6(-8.5,2.05) 7(-7.5,2.05) 8(-6.5,2.05) 9(-5.5,2.05) 10(-4.5,2.05) 11(-3.5,2.05) 12(-2.5,2.05) 13(-1.5,2.05) 14(-0.5,2.05) 15(0.5,2.05) 16(1.5,2.05) 17(2.5,2.05) 18(3.5,2.05) 19(4.5,2.05) 20(5.5,2.05) 21(6.5,2.05) 22(7.5,2.05) 23(8.5,2.05) 24(9.5,2.05) 25(10.5,2.05) 26(11.5,2.05) 27(12.5,2.05) 28(13.5,2.05)
  rect 2.159x2.997 smd: 29(-15.975,0) 30(15.975,0)
51325-00401-001-4P-L
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.8,0) 6(2.8,0)
51619-04001-V04-40P-L
  rect 0.305x1.295 smd: 1(-9.75,2.8) 2(-9.25,2.8) 3(-8.75,2.8) 4(-8.25,2.8) 5(-7.75,2.8) 6(-7.25,2.8) 7(-6.75,2.8) 8(-6.25,2.8) 9(-5.75,2.8) 10(-5.25,2.8) 11(-4.75,2.8) 12(-4.25,2.8) 13(-3.75,2.8) 14(-3.25,2.8) 15(-2.75,2.8) 16(-2.25,2.8) 17(-1.75,2.8) 18(-1.25,2.8) 19(-0.75,2.8) 20(-0.25,2.8) 21(0.25,2.8) 22(0.75,2.8) 23(1.25,2.8) 24(1.75,2.8) 25(2.25,2.8) 26(2.75,2.8) 27(3.25,2.8) 28(3.75,2.8) 29(4.25,2.8) 30(4.75,2.8) 31(5.25,2.8) 32(5.75,2.8) 33(6.25,2.8) 34(6.75,2.8) 35(7.25,2.8) 36(7.75,2.8) 37(8.25,2.8) 38(8.75,2.8) 39(9.25,2.8) 40(9.75,2.8)
  rect 1.803x1.397 smd: 41(-11.4,0) 42(11.4,0)
51625-01201-001-12P-L
  rect 0.305x0.838 smd: 1(-2.75,3.555) 2(-2.25,3.555) 3(-1.75,3.555) 4(-1.25,3.555) 5(-0.75,3.555) 6(-0.25,3.555) 7(0.25,3.555) 8(0.75,3.555) 9(1.25,3.555) 10(1.75,3.555) 11(2.25,3.555) 12(2.75,3.555)
  rect 0.991x1.448 smd: 13(-4.54,0) 14(4.54,0)
196047-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-3.5,2.65) 2(-2.5,2.65) 3(-1.5,2.65) 4(-0.5,2.65) 5(0.5,2.65) 6(1.5,2.65) 7(2.5,2.65) 8(3.5,2.65)
  rect 1.803x1.397 smd: 9(-5.65,0) 10(5.65,0)
196241-08021-3-8P-L
  rect 0.305x1.295 smd: 1(-1.75,2.7) 2(-1.25,2.7) 3(-0.75,2.7) 4(-0.25,2.7) 5(0.25,2.7) 6(0.75,2.7) 7(1.25,2.7) 8(1.75,2.7)
  rect 1.854x1.397 smd: 9(-3.425,0) 10(3.425,0)
196538-40041-3-40P-L
  rect 0.305x0.838 smd: 1(-9.75,3.175) 2(-9.25,3.175) 3(-8.75,3.175) 4(-8.25,3.175) 5(-7.75,3.175) 6(-7.25,3.175) 7(-6.75,3.175) 8(-6.25,3.175) 9(-5.75,3.175) 10(-5.25,3.175) 11(-4.75,3.175) 12(-4.25,3.175) 13(-3.75,3.175) 14(-3.25,3.175) 15(-2.75,3.175) 16(-2.25,3.175) 17(-1.75,3.175) 18(-1.25,3.175) 19(-0.75,3.175) 20(-0.25,3.175) 21(0.25,3.175) 22(0.75,3.175) 23(1.25,3.175) 24(1.75,3.175) 25(2.25,3.175) 26(2.75,3.175) 27(3.25,3.175) 28(3.75,3.175) 29(4.25,3.175) 30(4.75,3.175) 31(5.25,3.175) 32(5.75,3.175) 33(6.25,3.175) 34(6.75,3.175) 35(7.25,3.175) 36(7.75,3.175) 37(8.25,3.175) 38(8.75,3.175) 39(9.25,3.175) 40(9.75,3.175)
  rect 0.787x2.007 smd: 41(-11.45,0) 42(11.45,0)
BGA96-MICRON-MT41J64M16JT-187EG
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA170-HYNIX-H5GQ1H24MJR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA595-NVIDIA-N13P-GV2-S-A2
  round 0.381 smd: A2(-10.7,-9.9) A3(-10.7,-9.1) A4(-10.7,-8.3) A6(-10.7,-6.6) A7(-10.7,-5.8) A9(-10.7,-4.12) A10(-10.7,-3.32) A12(-10.7,-1.64) A13(-10.7,-0.84) A15(-10.7,0.84) A16(-10.7,1.64) A18(-10.7,3.32) A19(-10.7,4.12) A21(-10.7,5.8) A22(-10.7,6.6) A24(-10.7,8.3) A25(-10.7,9.1) A26(-10.7,9.9) AA1(5.8,-10.7) AA2(5.8,-9.9) AA3(5.8,-9.1) AA4(5.8,-8.3) AA5(5.8,-7.5) AA6(5.8,-6.66) AA7(5.8,-5.8) AA8(5.8,-4.96) AA9(5.86,-4.12) AA10(5.86,-3.32) AA12(5.86,-1.64) AA13(5.86,-0.84) AA14(5.86,0) AA15(5.86,0.84) AA16(5.86,1.64) AA18(5.86,3.32) AA19(5.86,4.12) AA20(5.8,4.96) AA21(5.8,5.8) AA22(5.8,6.66) AA23(5.8,7.5) AA24(5.8,8.3) AA25(5.8,9.1) AA26(5.8,9.9) AA27(5.8,10.7) AB1(6.6,-10.7) AB2(6.6,-9.9) AB3(6.6,-9.1) AB4(6.6,-8.3) AB5(6.6,-7.5) AB6(6.6,-6.6) AB7(6.66,-5.8) AB8(6.66,-4.96) AB9(6.66,-4.12) AB10(6.66,-3.32) AB11(6.66,-2.48) AB12(6.66,-1.64) AB13(6.66,-0.84) AB14(6.66,0) AB15(6.66,0.84) AB16(6.66,1.64) AB17(6.66,2.48) AB18(6.66,3.32) AB19(6.66,4.12) AB20(6.66,4.96) AB21(6.66,5.8) AB22(6.6,6.6) AB23(6.6,7.5) AB24(6.6,8.3) AB25(6.6,9.1) AB26(6.6,9.9) AB27(6.6,10.7) AC2(7.45,-9.9) AC3(7.45,-9.1) AC4(7.45,-8.3) AC5(7.45,-7.45) AC6(7.5,-6.6) AC7(7.5,-5.8) AC8(7.5,-4.96) AC9(7.5,-4.12) AC10(7.5,-3.32) AC11(7.5,-2.48) AC12(7.5,-1.64) AC13(7.5,-0.84) AC14(7.5,0) AC15(7.5,0.84) AC16(7.5,1.64) AC17(7.5,2.48) AC18(7.5,3.32) AC19(7.5,4.12) AC20(7.5,4.96) AC21(7.5,5.8) AC22(7.5,6.6) AC23(7.45,7.45) AC24(7.45,8.3) AC25(7.45,9.1) AC26(7.45,9.9) AD1(8.3,-10.7) AD2(8.3,-9.9) AD3(8.3,-9.1) AD4(8.3,-8.3) AD5(8.3,-7.45) AD6(8.3,-6.6) AD7(8.3,-5.8) AD8(8.3,-4.96) AD9(8.3,-4.12) AD10(8.3,-3.32) AD11(8.3,-2.48) AD12(8.3,-1.64) AD13(8.3,-0.84) AD14(8.3,0) AD15(8.3,0.84) AD16(8.3,1.64) AD17(8.3,2.48) AD18(8.3,3.32) AD19(8.3,4.12) AD20(8.3,4.96) AD21(8.3,5.8) AD22(8.3,6.6) AD23(8.3,7.45) AD24(8.3,8.3) AD25(8.3,9.1) AD26(8.3,9.9) AD27(8.3,10.7) AE1(9.1,-10.7) AE2(9.1,-9.9) AE3(9.1,-9.1) AE4(9.1,-8.3) AE5(9.1,-7.45) AE6(9.1,-6.6) AE7(9.1,-5.8) AE8(9.1,-4.96) AE9(9.1,-4.12) AE10(9.1,-3.32) AE11(9.1,-2.48) AE12(9.1,-1.64) AE13(9.1,-0.84) AE14(9.1,0) AE15(9.1,0.84) AE16(9.1,1.64) AE17(9.1,2.48) AE18(9.1,3.32) AE19(9.1,4.12) AE20(9.1,4.96) AE21(9.1,5.8) AE22(9.1,6.6) AE23(9.1,7.45) AE24(9.1,8.3) AE25(9.1,9.1) AE26(9.1,9.9) AE27(9.1,10.7) AF1(9.9,-10.7) AF2(9.9,-9.9) AF3(9.9,-9.1) AF4(9.9,-8.3) AF5(9.9,-7.45) AF6(9.9,-6.6) AF7(9.9,-5.8) AF8(9.9,-4.96) AF9(9.9,-4.12) AF10(9.9,-3.32) AF11(9.9,-2.48) AF12(9.9,-1.64) AF13(9.9,-0.84) AF14(9.9,0) AF15(9.9,0.84) AF16(9.9,1.64) AF17(9.9,2.48) AF18(9.9,3.32) AF19(9.9,4.12) AF20(9.9,4.96) AF21(9.9,5.8) AF22(9.9,6.6) AF23(9.9,7.45) AF24(9.9,8.3) AF25(9.9,9.1) AF26(9.9,9.9) AF27(9.9,10.7) AG2(10.7,-9.9) AG3(10.7,-9.1) AG4(10.7,-8.3) AG6(10.7,-6.6) AG7(10.7,-5.8) AG9(10.7,-4.12) AG10(10.7,-3.32) AG12(10.7,-1.64) AG13(10.7,-0.84) AG15(10.7,0.84) AG16(10.7,1.64) AG18(10.7,3.32) AG19(10.7,4.12) AG21(10.7,5.8) AG22(10.7,6.6) AG24(10.7,8.3) AG25(10.7,9.1) AG26(10.7,9.9) B1(-9.9,-10.7) B2(-9.9,-9.9) B3(-9.9,-9.1) B4(-9.9,-8.3) B5(-9.9,-7.45) B6(-9.9,-6.6) B7(-9.9,-5.8) B8(-9.9,-4.96) B9(-9.9,-4.12) B10(-9.9,-3.32) B11(-9.9,-2.48) B12(-9.9,-1.64) B13(-9.9,-0.84) B14(-9.9,0) B15(-9.9,0.84) B16(-9.9,1.64) B17(-9.9,2.48) B18(-9.9,3.32) B19(-9.9,4.12) B20(-9.9,4.96) B21(-9.9,5.8) B22(-9.9,6.6) B23(-9.9,7.45) B24(-9.9,8.3) B25(-9.9,9.1) B26(-9.9,9.9) B27(-9.9,10.7) C1(-9.1,-10.7) C2(-9.1,-9.9) C3(-9.1,-9.1) C4(-9.1,-8.3) C5(-9.1,-7.45) C6(-9.1,-6.6) C7(-9.1,-5.8) C8(-9.1,-4.96) C9(-9.1,-4.12) C10(-9.1,-3.32) C11(-9.1,-2.48) C12(-9.1,-1.64) C13(-9.1,-0.84) C14(-9.1,0) C15(-9.1,0.84) C16(-9.1,1.64) C17(-9.1,2.48) C18(-9.1,3.32) C19(-9.1,4.12) C20(-9.1,4.96) C21(-9.1,5.8) C22(-9.1,6.6) C23(-9.1,7.45) C24(-9.1,8.3) C25(-9.1,9.1) C26(-9.1,9.9) C27(-9.1,10.7) D1(-8.3,-10.7) D2(-8.3,-9.9) D3(-8.3,-9.1) D4(-8.3,-8.3) D5(-8.3,-7.45) D6(-8.3,-6.6) D7(-8.3,-5.8) D8(-8.3,-4.96) D9(-8.3,-4.12) D10(-8.3,-3.32) D11(-8.3,-2.48) D12(-8.3,-1.64) D13(-8.3,-0.84) D14(-8.3,0) D15(-8.3,0.84) D16(-8.3,1.64) D17(-8.3,2.48) D18(-8.3,3.32) D19(-8.3,4.12) D20(-8.3,4.96) D21(-8.3,5.8) D22(-8.3,6.6) D23(-8.3,7.45) D24(-8.3,8.3) D25(-8.3,9.1) D26(-8.3,9.9) D27(-8.3,10.7) E2(-7.45,-9.9) E3(-7.45,-9.1) E4(-7.45,-8.3) E5(-7.45,-7.45) E6(-7.5,-6.6) E7(-7.5,-5.8) E8(-7.5,-4.96) E9(-7.5,-4.12) E10(-7.5,-3.32) E11(-7.5,-2.48) E12(-7.5,-1.64) E13(-7.5,-0.84) E14(-7.5,0) E15(-7.5,0.84) E16(-7.5,1.64) E17(-7.5,2.48) E18(-7.5,3.32) E19(-7.5,4.12) E20(-7.5,4.96) E21(-7.5,5.8) E22(-7.5,6.6) E23(-7.45,7.45) E24(-7.45,8.3) E25(-7.45,9.1) E26(-7.45,9.9) F1(-6.6,-10.7) F2(-6.6,-9.9) F3(-6.6,-9.1) F4(-6.6,-8.3) F5(-6.6,-7.5) F6(-6.6,-6.6) F7(-6.66,-5.8) F8(-6.66,-4.96) F9(-6.66,-4.12) F10(-6.66,-3.32) F11(-6.66,-2.48) F12(-6.66,-1.64) F13(-6.66,-0.84) F14(-6.66,0) F15(-6.66,0.84) F16(-6.66,1.64) F17(-6.66,2.48) F18(-6.66,3.32) F19(-6.66,4.12) F20(-6.66,4.96) F21(-6.66,5.8) F22(-6.6,6.6) F23(-6.6,7.5) F24(-6.6,8.3) F25(-6.6,9.1) F26(-6.6,9.9) F27(-6.6,10.7) G1(-5.8,-10.7) G2(-5.8,-9.9) G3(-5.8,-9.1) G4(-5.8,-8.3) G5(-5.8,-7.5) G6(-5.8,-6.66) G7(-5.8,-5.8) G8(-5.8,-4.96) G9(-5.86,-4.12) G10(-5.86,-3.32) G12(-5.86,-1.64) G13(-5.86,-0.84) G14(-5.86,0) G15(-5.86,0.84) G16(-5.86,1.64) G18(-5.86,3.32) G19(-5.86,4.12) G20(-5.8,4.96) G21(-5.8,5.8) G22(-5.8,6.66) G23(-5.8,7.5) G24(-5.8,8.3) G25(-5.8,9.1) G26(-5.8,9.9) G27(-5.8,10.7) H2(-4.96,-9.9) H3(-4.96,-9.1) H4(-4.96,-8.3) H5(-4.96,-7.5) H6(-4.96,-6.66) H22(-4.96,6.66) H23(-4.96,7.5) H24(-4.96,8.3) H25(-4.96,9.1) H26(-4.96,9.9) J1(-4.12,-10.7) J2(-4.12,-9.9) J3(-4.12,-9.1) J4(-4.12,-8.3) J5(-4.12,-7.5) J6(-4.12,-6.66) J7(-4.12,-5.86) J21(-4.12,5.86) J22(-4.12,6.66) J23(-4.12,7.5) J24(-4.12,8.3) J25(-4.12,9.1) J26(-4.12,9.9) J27(-4.12,10.7) K1(-3.32,-10.7) K2(-3.32,-9.9) K3(-3.32,-9.1) K4(-3.32,-8.3) K5(-3.32,-7.5) K6(-3.32,-6.66) K7(-3.32,-5.86) K21(-3.32,5.86) K22(-3.32,6.66) K23(-3.32,7.5) K24(-3.32,8.3) K25(-3.32,9.1) K26(-3.32,9.9) K27(-3.32,10.7) L2(-2.48,-9.9) L3(-2.48,-9.1) L4(-2.48,-8.3) L5(-2.48,-7.5) L6(-2.48,-6.66) L22(-2.48,6.66) L23(-2.48,7.5) L24(-2.48,8.3) L25(-2.48,9.1) L26(-2.48,9.9) M1(-1.64,-10.7) M2(-1.64,-9.9) M3(-1.64,-9.1) M4(-1.64,-8.3) M5(-1.64,-7.5) M6(-1.64,-6.66) M7(-1.64,-5.86) M21(-1.64,5.86) M22(-1.64,6.66) M23(-1.64,7.5) M24(-1.64,8.3) M25(-1.64,9.1) M26(-1.64,9.9) M27(-1.64,10.7) N1(-0.84,-10.7) N2(-0.84,-9.9) N3(-0.84,-9.1) N4(-0.84,-8.3) N5(-0.84,-7.5) N6(-0.84,-6.66) N7(-0.84,-5.86) N21(-0.84,5.86) N22(-0.84,6.66) N23(-0.84,7.5) N24(-0.84,8.3) N25(-0.84,9.1) N26(-0.84,9.9) N27(-0.84,10.7) P2(0,-9.9) P3(0,-9.1) P4(0,-8.3) P5(0,-7.5) P6(0,-6.66) P22(0,6.66) P23(0,7.5) P24(0,8.3) P25(0,9.1) P26(0,9.9) R1(0.84,-10.7) R2(0.84,-9.9) R3(0.84,-9.1) R4(0.84,-8.3) R5(0.84,-7.5) R6(0.84,-6.66) R7(0.84,-5.86) R21(0.84,5.86) R22(0.84,6.66) R23(0.84,7.5) R24(0.84,8.3) R25(0.84,9.1) R26(0.84,9.9) R27(0.84,10.7) T1(1.64,-10.7) T2(1.64,-9.9) T3(1.64,-9.1) T4(1.64,-8.3) T5(1.64,-7.5) T6(1.64,-6.66) T7(1.64,-5.86) T21(1.64,5.86) T22(1.64,6.66) T23(1.64,7.5) T24(1.64,8.3) T25(1.64,9.1) T26(1.64,9.9) T27(1.64,10.7) U2(2.48,-9.9) U3(2.48,-9.1) U4(2.48,-8.3) U5(2.48,-7.5) U6(2.48,-6.66) U22(2.48,6.66) U23(2.48,7.5) U24(2.48,8.3) U25(2.48,9.1) U26(2.48,9.9) V1(3.32,-10.7) V2(3.32,-9.9) V3(3.32,-9.1) V4(3.32,-8.3) V5(3.32,-7.5) V6(3.32,-6.66) V7(3.32,-5.86) V21(3.32,5.86) V22(3.32,6.66) V23(3.32,7.5) V24(3.32,8.3) V25(3.32,9.1) V26(3.32,9.9) V27(3.32,10.7) W1(4.12,-10.7) W2(4.12,-9.9) W3(4.12,-9.1) W4(4.12,-8.3) W5(4.12,-7.5) W6(4.12,-6.66) W7(4.12,-5.86) W21(4.12,5.86) W22(4.12,6.66) W23(4.12,7.5) W24(4.12,8.3) W25(4.12,9.1) W26(4.12,9.9) W27(4.12,10.7) Y2(4.96,-9.9) Y3(4.96,-9.1) Y4(4.96,-8.3) Y5(4.96,-7.5) Y6(4.96,-6.66) Y22(4.96,6.66) Y23(4.96,7.5) Y24(4.96,8.3) Y25(4.96,9.1) Y26(4.96,9.9)
  round 0.4 smd: K10(-4,-4) K11(-4,-3) K12(-4,-2) K13(-4,-1) K14(-4,0) K15(-4,1) K16(-4,2) K17(-4,3) K18(-4,4) L10(-3,-4) L11(-3,-3) L12(-3,-2) L13(-3,-1) L14(-3,0) L15(-3,1) L16(-3,2) L17(-3,3) L18(-3,4) M10(-2,-4) M11(-2,-3) M12(-2,-2) M13(-2,-1) M14(-2,0) M15(-2,1) M16(-2,2) M17(-2,3) M18(-2,4) N10(-1,-4) N11(-1,-3) N12(-1,-2) N13(-1,-1) N14(-1,0) N15(-1,1) N16(-1,2) N17(-1,3) N18(-1,4) P10(0,-4) P11(0,-3) P12(0,-2) P13(0,-1) P14(0,0) P15(0,1) P16(0,2) P17(0,3) P18(0,4) R10(1,-4) R11(1,-3) R12(1,-2) R13(1,-1) R14(1,0) R15(1,1) R16(1,2) R17(1,3) R18(1,4) T10(2,-4) T11(2,-3) T12(2,-2) T13(2,-1) T14(2,0) T15(2,1) T16(2,2) T17(2,3) T18(2,4) U10(3,-4) U11(3,-3) U12(3,-2) U13(3,-1) U14(3,0) U15(3,1) U16(3,2) U17(3,3) U18(3,4) V10(4,-4) V11(4,-3) V12(4,-2) V13(4,-1) V14(4,0) V15(4,1) V16(4,2) V17(4,3) V18(4,4)
BGA1528-INTEL-WHL-U
  round 0.356 smd: A3(-22.315,-10.396) A36(-22.315,10.855) B2(-21.855,-10.855) B37(-21.855,11.315) C1(-21.396,-11.315) CP1(21.855,-11.315) CP37(21.855,11.315) CR2(22.315,-10.855) CR36(22.315,10.855)
  round 0.33 smd: A4(-22.315,-9.746) A35(-22.315,10.205) B3(-21.687,-10.227) B36(-21.687,10.687) C2(-21.227,-10.687) C37(-21.205,11.315) CN1(21.205,-11.315) CN37(21.205,11.315) CP2(21.687,-10.687) CP36(21.687,10.687) CR3(22.315,-10.205) CR35(22.315,10.205) D1(-20.746,-11.315)
  round 0.305 smd: A5(-22.292,-9.096) A6(-22.315,-8.232) A32(-22.315,8.228) A34(-22.315,9.555) AA4(-10.421,-9.365) AA9(-10.624,-6.21) AA24(-10.481,3.679) AA26(-10.481,4.606) AA34(-10.719,9.365) AB3(-9.763,-10.334) AB4(-9.763,-9.325) AB5(-10.162,-8.617) AB6(-10.162,-7.967) AB7(-10.162,-7.317) AB8(-10.162,-6.668) AB9(-9.7,-6.21) AB10(-10.162,-5.753) AB25(-10.025,4.142) AB27(-10.025,5.069) AB28(-10.025,5.719) AB29(-10.025,6.369) AB30(-10.025,7.019) AB31(-10.025,7.669) AB32(-10.025,8.32) AB33(-10.068,9.04) AB34(-10.068,9.69) AC4(-9.106,-9.365) AC5(-9.238,-8.617) AC6(-9.238,-7.967) AC7(-9.238,-7.317) AC8(-9.238,-6.668) AC10(-9.238,-5.753) AC24(-9.57,3.679) AC25(-9.114,4.142) AC26(-9.57,4.606) AC27(-9.114,5.069) AC28(-9.114,5.719) AC29(-9.114,6.369) AC30(-9.114,7.019) AC31(-9.114,7.669) AC32(-9.114,8.32) AC34(-9.417,9.365) AD4(-8.543,-9.69) AD9(-8.776,-6.21) AD24(-8.658,3.679) AD26(-8.658,4.606) AD33(-8.809,9.04) AD35(-8.809,10.245) AE4(-7.98,-9.365) AE5(-8.314,-8.617) AE6(-8.314,-7.967) AE7(-8.314,-7.317) AE8(-8.314,-6.668) AE9(-7.852,-6.21) AE10(-8.314,-5.753) AE24(-7.747,3.679) AE25(-8.203,4.142) AE26(-7.747,4.606) AE27(-8.203,5.069) AE28(-8.203,5.719) AE29(-8.203,6.369) AE30(-8.203,7.019) AE31(-8.203,7.669) AE32(-8.203,8.32) AE34(-8.202,9.365) AF3(-7.322,-10.334) AF4(-7.322,-9.325) AF5(-7.39,-8.617) AF6(-7.39,-7.967) AF7(-7.39,-7.317) AF8(-7.39,-6.668) AF10(-7.39,-5.753) AF25(-7.291,4.142) AF27(-7.291,5.069) AF28(-7.291,5.719) AF29(-7.291,6.369) AF30(-7.291,7.019) AF31(-7.291,7.669) AF32(-7.291,8.32) AF33(-7.551,9.04) AF34(-7.551,9.69) AG4(-6.665,-9.365) AG5(-6.467,-8.617) AG6(-6.467,-7.967) AG7(-6.467,-7.317) AG8(-6.467,-6.668) AG9(-6.929,-6.21) AG10(-6.467,-5.753) AG24(-6.835,3.679) AG26(-6.835,4.606) AG34(-6.9,9.365) AH4(-6.102,-9.69) AH9(-6.005,-6.21) AH24(-5.924,3.679) AH25(-6.38,4.142) AH26(-5.924,4.606) AH27(-6.38,5.069) AH28(-6.38,5.719) AH29(-6.38,6.369) AH30(-6.38,7.019) AH31(-6.38,7.669) AH32(-6.38,8.32) AH33(-6.293,9.04) AH35(-6.293,10.245) AJ4(-5.539,-9.365) AJ5(-5.543,-8.617) AJ6(-5.543,-7.967) AJ7(-5.543,-7.317) AJ8(-5.543,-6.668) AJ10(-5.543,-5.753) AJ25(-5.468,4.142) AJ27(-5.468,5.069) AJ28(-5.468,5.719) AJ29(-5.468,6.369) AJ30(-5.468,7.019) AJ31(-5.468,7.669) AJ32(-5.468,8.32) AJ34(-5.685,9.365) AK3(-4.882,-10.334) AK4(-4.882,-9.325) AK9(-5.081,-6.21) AK24(-5.013,3.679) AK26(-5.013,4.606) AK33(-5.034,9.04) AK34(-5.034,9.69) AL4(-4.224,-9.365) AL5(-4.619,-8.617) AL6(-4.619,-7.967) AL7(-4.619,-7.317) AL8(-4.619,-6.668) AL9(-4.157,-6.21) AL10(-4.619,-5.753) AL24(-4.101,3.679) AL25(-4.557,4.142) AL26(-4.101,4.606) AL27(-4.557,5.069) AL28(-4.557,5.719) AL29(-4.557,6.369) AL30(-4.557,7.019) AL31(-4.557,7.669) AL32(-4.557,8.32) AL34(-4.383,9.365) AM4(-3.661,-9.69) AM5(-3.695,-8.617) AM6(-3.695,-7.967) AM7(-3.695,-7.317) AM8(-3.695,-6.668) AM10(-3.695,-5.753) AM25(-3.646,4.142) AM27(-3.646,5.069) AM28(-3.646,5.719) AM29(-3.646,6.369) AM30(-3.646,7.019) AM31(-3.646,7.669) AM32(-3.646,8.32) AM33(-3.775,9.04) AM35(-3.775,10.245) AN4(-3.098,-9.365) AN5(-2.771,-8.617) AN6(-2.771,-7.967) AN7(-2.771,-7.317) AN8(-2.771,-6.668) AN9(-3.233,-6.21) AN10(-2.771,-5.753) AN24(-3.19,3.679) AN25(-2.734,4.142) AN26(-3.19,4.606) AN27(-2.734,5.069) AN28(-2.734,5.719) AN29(-2.734,6.369) AN30(-2.734,7.019) AN31(-2.734,7.669) AN32(-2.734,8.32) AN34(-3.168,9.365) AP3(-2.441,-10.334) AP4(-2.441,-9.325) AP9(-2.31,-6.21) AP24(-2.278,3.679) AP26(-2.278,4.606) AP33(-2.517,9.04) AP34(-2.517,9.69) AR4(-1.783,-9.365) AR5(-1.848,-8.617) AR6(-1.848,-7.967) AR7(-1.848,-7.317) AR8(-1.848,-6.668) AR10(-1.848,-5.753) AR25(-1.823,4.142) AR27(-1.823,5.069) AR28(-1.823,5.719) AR29(-1.823,6.369) AR30(-1.823,7.019) AR31(-1.823,7.669) AR32(-1.823,8.32) AR34(-1.866,9.365) AT4(-1.22,-9.69) AT9(-1.386,-6.21) AT24(-1.367,3.679) AT26(-1.367,4.606) AT33(-1.259,9.04) AT35(-1.259,10.245) AU4(-0.657,-9.365) AU5(-0.924,-8.617) AU6(-0.924,-7.967) AU7(-0.924,-7.317) AU8(-0.924,-6.668) AU9(-0.462,-6.21) AU10(-0.924,-5.753) AU24(-0.456,3.679) AU25(-0.911,4.142) AU26(-0.456,4.606) AU27(-0.911,5.069) AU28(-0.911,5.719) AU29(-0.911,6.369) AU30(-0.911,7.019) AU31(-0.911,7.669) AU32(-0.911,8.32) AU34(-0.65,9.365) AV3(0,-10.334) AV4(0,-9.325) AV5(0,-8.617) AV6(0,-7.967) AV7(0,-7.317) AV8(0,-6.668) AV10(0,-5.753) AV25(0,4.142) AV27(0,5.069) AV28(0,5.719) AV29(0,6.369) AV30(0,7.019) AV31(0,7.669) AV32(0,8.32) AV33(0,9.04) AV34(0,9.69) AW4(0.657,-9.365) AW5(0.924,-8.617) AW6(0.924,-7.967) AW7(0.924,-7.317) AW8(0.924,-6.668) AW9(0.462,-6.21) AW10(0.924,-5.753) AW24(0.456,3.679) AW25(0.911,4.142) AW26(0.456,4.606) AW27(0.911,5.069) AW28(0.911,5.719) AW29(0.911,6.369) AW30(0.911,7.019) AW31(0.911,7.669) AW32(0.911,8.32) AW34(0.65,9.365) AY4(1.22,-9.69) AY9(1.386,-6.21) AY24(1.367,3.679) AY26(1.367,4.606) AY33(1.259,9.04) AY35(1.259,10.245) B4(-21.707,-9.515) B5(-21.684,-8.866) B33(-22.004,8.901) B34(-21.582,9.396) B35(-21.687,10.037) BA4(1.783,-9.365) BA5(1.848,-8.617) BA6(1.848,-7.967) BA7(1.848,-7.317) BA8(1.848,-6.668) BA10(1.848,-5.753) BA25(1.823,4.142) BA27(1.823,5.069) BA28(1.823,5.719) BA29(1.823,6.369) BA30(1.823,7.019) BA31(1.823,7.669) BA32(1.823,8.32) BA34(1.866,9.365) BB3(2.441,-10.334) BB4(2.441,-9.325) BB9(2.31,-6.21) BB24(2.278,3.679) BB26(2.278,4.606) BB33(2.517,9.04) BB34(2.517,9.69) BC4(3.098,-9.365) BC5(2.771,-8.617) BC6(2.771,-7.967) BC7(2.771,-7.317) BC8(2.771,-6.668) BC9(3.233,-6.21) BC10(2.771,-5.753) BC24(3.19,3.679) BC25(2.734,4.142) BC26(3.19,4.606) BC27(2.734,5.069) BC28(2.734,5.719) BC29(2.734,6.369) BC30(2.734,7.019) BC31(2.734,7.669) BC32(2.734,8.32) BC34(3.168,9.365) BD4(3.661,-9.69) BD5(3.695,-8.617) BD6(3.695,-7.967) BD7(3.695,-7.317) BD8(3.695,-6.668) BD10(3.695,-5.753) BD25(3.646,4.142) BD27(3.646,5.069) BD28(3.646,5.719) BD29(3.646,6.369) BD30(3.646,7.019) BD31(3.646,7.669) BD32(3.646,8.32) BD33(3.775,9.04) BD35(3.775,10.245) BE4(4.224,-9.365) BE5(4.619,-8.617) BE6(4.619,-7.967) BE7(4.619,-7.317) BE8(4.619,-6.668) BE9(4.157,-6.21) BE10(4.619,-5.753) BE24(4.101,3.679) BE25(4.557,4.142) BE26(4.101,4.606) BE27(4.557,5.069) BE28(4.557,5.719) BE29(4.557,6.369) BE30(4.557,7.019) BE31(4.557,7.669) BE32(4.557,8.32) BE34(4.383,9.365) BF3(4.882,-10.334) BF4(4.882,-9.325) BF9(5.081,-6.21) BF24(5.013,3.679) BF26(5.013,4.606) BF33(5.034,9.04) BF34(5.034,9.69) BG4(5.539,-9.365) BG5(5.543,-8.617) BG6(5.543,-7.967) BG7(5.543,-7.317) BG8(5.543,-6.668) BG10(5.543,-5.753) BG25(5.468,4.142) BG27(5.468,5.069) BG28(5.468,5.719) BG29(5.468,6.369) BG30(5.468,7.019) BG31(5.468,7.669) BG32(5.468,8.32) BG34(5.685,9.365) BH4(6.102,-9.69) BH9(6.005,-6.21) BH24(5.924,3.679) BH25(6.38,4.142) BH26(5.924,4.606) BH27(6.38,5.069) BH28(6.38,5.719) BH29(6.38,6.369) BH30(6.38,7.019) BH31(6.38,7.669) BH32(6.38,8.32) BH33(6.293,9.04) BH35(6.293,10.245) BJ4(6.665,-9.365) BJ5(6.467,-8.617) BJ6(6.467,-7.967) BJ7(6.467,-7.317) BJ8(6.467,-6.668) BJ9(6.929,-6.21) BJ10(6.467,-5.753) BJ24(6.835,3.679) BJ26(6.835,4.606) BJ34(6.9,9.365) BK3(7.322,-10.334) BK4(7.322,-9.325) BK5(7.39,-8.617) BK6(7.39,-7.967) BK7(7.39,-7.317) BK8(7.39,-6.668) BK10(7.39,-5.753) BK25(7.291,4.142) BK27(7.291,5.069) BK28(7.291,5.719) BK29(7.291,6.369) BK30(7.291,7.019) BK31(7.291,7.669) BK32(7.291,8.32) BK33(7.551,9.04) BK34(7.551,9.69) BL4(7.98,-9.365) BL5(8.314,-8.617) BL6(8.314,-7.967) BL7(8.314,-7.317) BL8(8.314,-6.668) BL9(7.852,-6.21) BL10(8.314,-5.753) BL24(7.747,3.679) BL25(8.203,4.142) BL26(7.747,4.606) BL27(8.203,5.069) BL28(8.203,5.719) BL29(8.203,6.369) BL30(8.203,7.019) BL31(8.203,7.669) BL32(8.203,8.32) BL34(8.202,9.365) BM4(8.543,-9.69) BM9(8.776,-6.21) BM24(8.658,3.679) BM26(8.658,4.606) BM33(8.809,9.04) BM35(8.809,10.245) BN4(9.106,-9.365) BN5(9.238,-8.617) BN6(9.238,-7.967) BN7(9.238,-7.317) BN8(9.238,-6.668) BN10(9.238,-5.753) BN25(9.114,4.142) BN27(9.114,5.069) BN28(9.114,5.719) BN29(9.114,6.369) BN30(9.114,7.019) BN31(9.114,7.669) BN32(9.114,8.32) BN34(9.417,9.365) BP3(9.763,-10.334) BP4(9.763,-9.325) BP5(10.162,-8.617) BP6(10.162,-7.967) BP7(10.162,-7.317) BP8(10.162,-6.668) BP9(10.162,-6.018) BP11(9.786,-5.093) BP12(9.786,-4.253) BP14(9.786,-3.413) BP15(9.786,-2.574) BP16(9.786,-1.734) BP18(9.786,-0.894) BP19(9.786,-0.054) BP20(9.786,0.786) BP22(9.786,1.626) BP23(9.786,2.465) BP24(9.786,3.305) BP25(9.786,4.145) BP27(10.025,5.069) BP28(10.025,5.719) BP29(10.025,6.369) BP30(10.025,7.019) BP31(10.025,7.669) BP32(10.025,8.32) BP33(10.068,9.04) BP34(10.068,9.69) BR4(10.421,-9.365) BR11(10.436,-5.093) BR12(10.436,-4.253) BR14(10.436,-3.413) BR15(10.436,-2.574) BR16(10.436,-1.734) BR18(10.436,-0.894) BR19(10.436,-0.054) BR20(10.436,0.786) BR22(10.436,1.626) BR23(10.436,2.465) BR24(10.436,3.305) BR25(10.436,4.145) BR34(10.719,9.365) BT4(10.984,-9.69) BT5(11.086,-8.617) BT6(11.086,-7.967) BT7(11.086,-7.317) BT8(11.086,-6.668) BT9(11.086,-6.018) BT11(11.086,-5.093) BT12(11.086,-4.253) BT14(11.086,-3.413) BT15(11.086,-2.574) BT16(11.086,-1.734) BT18(11.086,-0.894) BT19(11.086,-0.054) BT20(11.086,0.786) BT22(11.086,1.626) BT23(11.086,2.465) BT24(11.086,3.305) BT25(11.086,4.145) BT27(10.937,5.069) BT28(10.937,5.719) BT29(10.937,6.369) BT30(10.937,7.019) BT31(10.937,7.669) BT32(10.937,8.32) BT33(11.327,9.04) BT35(11.327,10.245) BU4(11.547,-9.365) BU5(12.009,-8.617) BU6(12.009,-7.967) BU7(12.009,-7.317) BU8(12.009,-6.668) BU9(12.009,-6.018) BU11(11.736,-5.093) BU12(11.736,-4.253) BU14(11.736,-3.413) BU15(11.736,-2.574) BU16(11.736,-1.734) BU18(11.736,-0.894) BU19(11.736,-0.054) BU20(11.736,0.786) BU22(11.736,1.626) BU23(11.736,2.465) BU24(11.736,3.305) BU25(11.736,4.145) BU27(11.848,5.069) BU28(11.848,5.719) BU29(11.848,6.369) BU30(11.848,7.019) BU31(11.848,7.669) BU32(11.848,8.32) BU34(11.934,9.365) BV3(12.204,-10.334) BV4(12.204,-9.325) BV11(12.386,-5.093) BV12(12.386,-4.253) BV14(12.386,-3.413) BV15(12.386,-2.574) BV16(12.386,-1.734) BV18(12.386,-0.894) BV19(12.386,-0.054) BV20(12.386,0.786) BV22(12.386,1.626) BV23(12.386,2.465) BV24(12.386,3.305) BV25(12.386,4.145) BV27(12.76,5.069) BV28(12.76,5.719) BV29(12.76,6.369) BV30(12.76,7.019) BV31(12.76,7.669) BV32(12.76,8.32) BV33(12.585,9.04) BV34(12.585,9.69) BW4(12.861,-9.365) BW5(12.933,-8.617) BW6(12.933,-7.967) BW7(12.933,-7.317) BW8(12.933,-6.668) BW9(12.933,-6.018) BW11(13.036,-5.093) BW12(13.036,-4.253) BW14(13.036,-3.413) BW15(13.036,-2.574) BW16(13.036,-1.734) BW18(13.036,-0.894) BW19(13.036,-0.054) BW20(13.036,0.786) BW22(13.036,1.626) BW23(13.036,2.465) BW24(13.036,3.305) BW25(13.036,4.145) BW34(13.236,9.365) BY4(13.424,-9.69) BY5(13.857,-8.617) BY6(13.857,-7.967) BY7(13.857,-7.317) BY8(13.857,-6.668) BY9(13.857,-6.018) BY11(13.686,-5.093) BY12(13.686,-4.253) BY14(13.686,-3.413) BY15(13.686,-2.574) BY16(13.686,-1.734) BY18(13.686,-0.894) BY19(13.686,-0.054) BY20(13.686,0.786) BY22(13.686,1.626) BY23(13.686,2.465) BY24(13.686,3.305) BY25(13.686,4.145) BY27(13.671,5.069) BY28(13.671,5.719) BY29(13.671,6.369) BY30(13.671,7.019) BY31(13.671,7.669) BY32(13.671,8.32) BY33(13.844,9.04) BY35(13.844,10.245) C3(-21.059,-10.059) C4(-21.132,-9.213) C9(-21.245,-6.305) C21(-21.245,1.275) C25(-21.245,3.792) C29(-21.245,6.309) C33(-21.245,8.826) C34(-20.932,9.396) C35(-21.037,10.037) C36(-21.037,10.687) CA4(13.988,-9.365) CA11(14.336,-5.093) CA12(14.336,-4.253) CA14(14.336,-3.413) CA15(14.336,-2.574) CA16(14.336,-1.734) CA18(14.336,-0.894) CA19(14.336,-0.054) CA20(14.336,0.786) CA22(14.336,1.626) CA23(14.336,2.465) CA24(14.336,3.305) CA25(14.336,4.145) CA27(14.582,5.069) CA28(14.582,5.719) CA29(14.582,6.369) CA30(14.582,7.019) CA31(14.582,7.669) CA32(14.582,8.32) CA34(14.451,9.365) CB3(14.645,-10.334) CB4(14.645,-9.325) CB5(14.781,-8.617) CB6(14.781,-7.967) CB7(14.781,-7.317) CB8(14.781,-6.668) CB9(14.781,-6.018) CB11(14.985,-5.093) CB12(14.985,-4.253) CB14(14.985,-3.413) CB15(14.985,-2.574) CB16(14.985,-1.734) CB18(14.985,-0.894) CB19(14.985,-0.054) CB20(14.985,0.786) CB22(14.985,1.626) CB23(14.985,2.465) CB24(14.985,3.305) CB25(14.985,4.145) CB33(15.102,9.04) CB34(15.102,9.69) CC4(15.302,-9.365) CC5(15.705,-8.617) CC6(15.705,-7.967) CC7(15.705,-7.317) CC8(15.705,-6.668) CC9(15.705,-6.018) CC11(15.635,-5.093) CC12(15.635,-4.253) CC14(15.635,-3.413) CC15(15.635,-2.574) CC16(15.635,-1.734) CC18(15.635,-0.894) CC19(15.635,-0.054) CC20(15.635,0.786) CC22(15.635,1.626) CC23(15.635,2.465) CC24(15.635,3.305) CC25(15.635,4.145) CC27(15.494,5.069) CC28(15.494,5.719) CC29(15.494,6.369) CC30(15.494,7.019) CC31(15.494,7.669) CC32(15.494,8.32) CC34(15.753,9.365) CD4(15.865,-9.69) CD11(16.285,-5.093) CD12(16.285,-4.253) CD14(16.285,-3.413) CD15(16.285,-2.574) CD16(16.285,-1.734) CD18(16.285,-0.894) CD19(16.285,-0.054) CD20(16.285,0.786) CD22(16.285,1.626) CD23(16.285,2.465) CD24(16.285,3.305) CD25(16.285,4.145) CE4(16.428,-9.365) CE5(16.628,-8.617) CE6(16.628,-7.967) CE7(16.628,-7.317) CE8(16.628,-6.668) CE9(16.628,-6.018) CE27(16.405,5.069) CE28(16.405,5.719) CE29(16.405,6.369) CE30(16.405,7.019) CE31(16.405,7.669) CE32(16.405,8.32) CE33(16.36,9.04) CE35(16.36,10.245) CF3(17.086,-10.334) CF4(17.086,-9.325) CF11(17.115,-5.37) CF12(17.115,-4.368) CF14(17.115,-3.33) CF15(17.115,-2.292) CF17(17.115,-1.254) CF19(17.115,-0.216) CF20(17.115,0.822) CF22(17.115,1.86) CF23(17.115,2.898) CF25(17.115,3.936) CF27(17.317,5.069) CF28(17.317,5.719) CF29(17.317,6.369) CF30(17.317,7.019) CF31(17.317,7.669) CF32(17.317,8.32) CF34(16.968,9.365) CG4(17.743,-9.365) CG5(17.552,-8.617) CG6(17.552,-7.967) CG7(17.552,-7.317) CG8(17.552,-6.668) CG9(17.552,-6.018) CG11(17.765,-5.37) CG12(17.765,-4.368) CG14(17.765,-3.33) CG15(17.765,-2.292) CG17(17.765,-1.254) CG19(17.765,-0.216) CG20(17.765,0.822) CG22(17.765,1.86) CG23(17.765,2.898) CG25(17.765,3.936) CG33(17.619,9.04) CG34(17.619,9.69) CH4(18.306,-9.69) CH5(18.476,-8.617) CH6(18.476,-7.967) CH7(18.476,-7.317) CH8(18.476,-6.668) CH9(18.476,-6.018) CH11(18.415,-5.37) CH12(18.415,-4.368) CH14(18.415,-3.33) CH15(18.415,-2.292) CH17(18.415,-1.254) CH19(18.415,-0.216) CH20(18.415,0.822) CH22(18.415,1.86) CH23(18.415,2.898) CH25(18.415,3.936) CH27(18.228,5.069) CH28(18.228,5.719) CH29(18.228,6.369) CH30(18.228,7.019) CH31(18.228,7.669) CH32(18.228,8.32) CH34(18.27,9.365) CJ4(18.869,-9.365) CJ11(19.065,-5.37) CJ12(19.065,-4.368) CJ14(19.065,-3.33) CJ15(19.065,-2.292) CJ17(19.065,-1.254) CJ19(19.065,-0.216) CJ20(19.065,0.822) CJ22(19.065,1.86) CJ23(19.065,2.898) CJ25(19.065,3.936) CJ27(19.139,5.069) CJ28(19.139,5.719) CJ29(19.139,6.369) CJ30(19.139,7.019) CJ31(19.139,7.669) CJ32(19.139,8.32) CJ33(18.833,9.04) CJ35(18.878,10.245) CK1(19.561,-11.315) CK3(19.83,-9.895) CK4(19.518,-9.325) CK5(19.4,-8.617) CK6(19.4,-7.967) CK7(19.4,-7.317) CK8(19.4,-6.668) CK9(19.4,-6.018) CK11(19.715,-5.37) CK12(19.715,-4.368) CK14(19.715,-3.33) CK15(19.715,-2.292) CK17(19.715,-1.254) CK19(19.715,-0.216) CK20(19.715,0.822) CK22(19.715,1.86) CK23(19.715,2.898) CK25(19.715,3.936) CK33(19.504,9.15) CK34(19.326,9.775) CK36(19.462,10.612) CK37(19.374,11.315) CL2(20.058,-10.896) CL35(19.91,10.061) CL36(20.019,10.948) CM1(20.555,-11.315) CM3(20.383,-10.333) CM4(20.343,-9.496) CM5(20.365,-8.782) CM6(20.371,-8.132) CM7(20.69,-7.565) CM8(20.371,-6.999) CM9(20.365,-6.305) CM10(20.371,-5.61) CM11(20.69,-5.044) CM12(20.371,-4.478) CM13(20.365,-3.783) CM14(20.371,-3.088) CM15(20.69,-2.522) CM16(20.371,-1.956) CM17(20.365,-1.261) CM18(20.371,-0.566) CM19(20.69,0) CM20(20.371,0.566) CM21(20.365,1.261) CM22(20.371,1.956) CM23(20.69,2.522) CM24(20.371,3.088) CM25(20.365,3.783) CM26(20.371,4.478) CM27(20.69,5.044) CM28(20.371,5.61) CM29(20.365,6.305) CM30(20.365,6.955) CM31(20.814,7.531) CM32(20.365,8.176) CM33(20.365,8.826) CM34(20.286,9.471) CM35(20.433,10.447) CM37(20.555,11.315) CN2(20.88,-10.752) CN3(20.946,-10.007) CN4(20.978,-9.358) CN5(21.367,-8.794) CN9(21.245,-6.305) CN13(21.245,-3.783) CN17(21.245,-1.261) CN21(21.245,1.261) CN25(21.245,3.783) CN29(21.245,6.305) CN33(21.245,8.826) CN34(20.932,9.396) CN35(21.037,10.037) CN36(21.037,10.687) CP3(21.687,-10.037) CP4(21.627,-9.39) CP5(22.099,-8.942) CP33(21.968,8.871) CP34(21.582,9.396) CP35(21.687,10.037) CR4(22.315,-9.555) CR6(22.315,-8.232) CR32(22.315,8.321) CR34(22.315,9.555) D2(-20.579,-10.64) D4(-20.605,-9.594) D5(-20.365,-8.782) D6(-20.371,-8.132) D7(-20.69,-7.565) D8(-20.371,-6.999) D9(-20.505,-6.305) D21(-20.595,1.275) D22(-20.365,1.883) D23(-20.69,2.534) D24(-20.365,3.184) D25(-20.595,3.792) D26(-20.365,4.4) D27(-20.69,5.051) D28(-20.365,5.701) D30(-20.365,6.917) D31(-20.69,7.568) D32(-20.365,8.218) D34(-20.282,9.396) D35(-20.433,10.447) D37(-20.555,11.315) E1(-20.096,-11.315) E3(-20.089,-10.008) E4(-19.995,-9.365) E9(-19.862,-6.21) E23(-20.04,2.621) E27(-20.04,5.051) E29(-20.04,6.309) E31(-20.04,7.568) E33(-20.04,8.781) E35(-19.91,10.061) E36(-20.019,10.948) F2(-19.527,-11.001) F3(-19.527,-10.334) F4(-19.432,-9.69) F5(-19.4,-8.617) F6(-19.4,-7.967) F7(-19.4,-7.317) F8(-19.4,-6.668) F21(-19.715,1.149) F22(-19.715,2.058) F24(-19.715,3.184) F25(-19.715,4.093) F33(-19.504,9.15) F34(-19.326,9.775) F36(-19.462,10.612) F37(-19.374,11.315) G1(-18.844,-11.315) G4(-18.869,-9.365) G9(-18.938,-6.21) G21(-19.065,1.149) G22(-19.065,2.058) G24(-19.065,3.184) G25(-19.065,4.093) G27(-19.139,5.069) G28(-19.139,5.719) G29(-19.139,6.369) G30(-19.139,7.019) G31(-19.139,7.669) G32(-19.139,8.32) G33(-18.833,9.04) G35(-18.878,10.245) H4(-18.306,-9.69) H5(-18.476,-8.617) H6(-18.476,-7.967) H7(-18.476,-7.317) H8(-18.476,-6.668) H9(-18.014,-6.21) H21(-18.415,1.149) H22(-18.415,2.058) H24(-18.415,3.184) H25(-18.415,4.093) H27(-18.228,5.069) H28(-18.228,5.719) H29(-18.228,6.369) H30(-18.228,7.019) H31(-18.228,7.669) H32(-18.228,8.32) H34(-18.27,9.365) J4(-17.743,-9.365) J5(-17.552,-8.617) J6(-17.552,-7.967) J7(-17.552,-7.317) J8(-17.552,-6.668) J21(-17.765,1.149) J22(-17.765,2.058) J24(-17.765,3.184) J25(-17.765,4.093) J33(-17.619,9.04) J34(-17.619,9.69) K3(-17.086,-10.334) K4(-17.086,-9.325) K9(-17.09,-6.21) K11(-17.115,-5.322) K12(-17.115,-4.38) K14(-17.115,-3.438) K15(-17.115,-2.496) K17(-17.115,-1.554) K18(-17.115,-0.613) K20(-17.115,0.329) K21(-17.115,1.149) K22(-17.115,2.058) K24(-17.115,3.184) K25(-17.115,4.093) K27(-17.317,5.069) K28(-17.317,5.719) K29(-17.317,6.369) K30(-17.317,7.019) K31(-17.317,7.669) K32(-17.317,8.32) K34(-16.968,9.365) L4(-16.428,-9.365) L5(-16.628,-8.617) L6(-16.628,-7.967) L7(-16.628,-7.317) L8(-16.628,-6.668) L10(-16.628,-5.753) L25(-16.405,4.142) L27(-16.405,5.069) L28(-16.405,5.719) L29(-16.405,6.369) L30(-16.405,7.019) L31(-16.405,7.669) L32(-16.405,8.32) L33(-16.36,9.04) L35(-16.36,10.245) M4(-15.865,-9.69) M9(-16.167,-6.21) M24(-15.949,3.679) M26(-15.949,4.606) N4(-15.302,-9.365) N5(-15.705,-8.617) N6(-15.705,-7.967) N7(-15.705,-7.317) N8(-15.705,-6.668) N9(-15.243,-6.21) N10(-15.705,-5.753) N25(-15.494,4.142) N27(-15.494,5.069) N28(-15.494,5.719) N29(-15.494,6.369) N30(-15.494,7.019) N31(-15.494,7.669) N32(-15.494,8.32) N34(-15.753,9.365) P3(-14.645,-10.334) P4(-14.645,-9.325) P5(-14.781,-8.617) P6(-14.781,-7.967) P7(-14.781,-7.317) P8(-14.781,-6.668) P10(-14.781,-5.753) P24(-15.038,3.679) P26(-15.038,4.606) P33(-15.102,9.04) P34(-15.102,9.69) R4(-13.988,-9.365) R9(-14.319,-6.21) R24(-14.127,3.679) R25(-14.582,4.142) R26(-14.127,4.606) R27(-14.582,5.069) R28(-14.582,5.719) R29(-14.582,6.369) R30(-14.582,7.019) R31(-14.582,7.669) R32(-14.582,8.32) R34(-14.451,9.365) T4(-13.424,-9.69) T5(-13.857,-8.617) T6(-13.857,-7.967) T7(-13.857,-7.317) T8(-13.857,-6.668) T9(-13.395,-6.21) T10(-13.857,-5.753) T25(-13.671,4.142) T27(-13.671,5.069) T28(-13.671,5.719) T29(-13.671,6.369) T30(-13.671,7.019) T31(-13.671,7.669) T32(-13.671,8.32) T33(-13.844,9.04) T35(-13.844,10.245) U4(-12.861,-9.365) U5(-12.933,-8.617) U6(-12.933,-7.967) U7(-12.933,-7.317) U8(-12.933,-6.668) U10(-12.933,-5.753) U24(-13.215,3.679) U26(-13.215,4.606) U34(-13.236,9.365) V3(-12.204,-10.334) V4(-12.204,-9.325) V9(-12.471,-6.21) V24(-12.304,3.679) V25(-12.76,4.142) V26(-12.304,4.606) V27(-12.76,5.069) V28(-12.76,5.719) V29(-12.76,6.369) V30(-12.76,7.019) V31(-12.76,7.669) V32(-12.76,8.32) V33(-12.585,9.04) V34(-12.585,9.69) W4(-11.547,-9.365) W5(-12.009,-8.617) W6(-12.009,-7.967) W7(-12.009,-7.317) W8(-12.009,-6.668) W9(-11.548,-6.21) W10(-12.009,-5.753) W25(-11.848,4.142) W27(-11.848,5.069) W28(-11.848,5.719) W29(-11.848,6.369) W30(-11.848,7.019) W31(-11.848,7.669) W32(-11.848,8.32) W34(-11.934,9.365) Y4(-10.984,-9.69) Y5(-11.086,-8.617) Y6(-11.086,-7.967) Y7(-11.086,-7.317) Y8(-11.086,-6.668) Y10(-11.086,-5.753) Y24(-11.392,3.679) Y25(-10.937,4.142) Y26(-11.392,4.606) Y27(-10.937,5.069) Y28(-10.937,5.719) Y29(-10.937,6.369) Y30(-10.937,7.019) Y31(-10.937,7.669) Y32(-10.937,8.32) Y33(-11.327,9.04) Y35(-11.327,10.245)
  oval 0.33x0.254 smd: A8(-22.315,-6.915) A22(-22.315,1.883) A24(-22.315,3.184) A26(-22.315,4.4) A28(-22.315,5.701) A30(-22.315,6.917) B6(-21.665,-8.216) B7(-21.99,-7.565) B8(-21.665,-6.915) B9(-21.895,-6.305) B21(-21.895,1.275) B22(-21.665,1.883) B23(-21.99,2.534) B24(-21.665,3.184) B25(-21.895,3.792) B26(-21.665,4.4) B27(-21.99,5.051) B28(-21.665,5.701) B29(-21.895,6.309) B30(-21.665,6.917) B31(-21.99,7.568) B32(-21.665,8.218) C6(-21.015,-8.216) C7(-21.34,-7.565) C8(-21.021,-6.999) C22(-21.015,1.883) C23(-21.34,2.534) C24(-21.015,3.184) C26(-21.015,4.4) C27(-21.34,5.051) C28(-21.015,5.701) C30(-21.015,6.917) C31(-21.34,7.568) C32(-21.015,8.218) CN6(21.015,-8.216) CN7(21.34,-7.565) CN8(21.021,-6.999) CN10(21.021,-5.61) CN11(21.34,-5.044) CN12(21.021,-4.478) CN14(21.021,-3.088) CN15(21.34,-2.522) CN16(21.021,-1.956) CN18(21.021,-0.566) CN19(21.34,0) CN20(21.021,0.566) CN22(21.021,1.956) CN23(21.34,2.522) CN24(21.021,3.088) CN27(21.34,5.044) CN28(21.021,5.61) CN30(21.014,6.912) CN31(21.461,7.605) CN32(21.014,8.219) CP6(21.665,-8.216) CP7(21.99,-7.565) CP8(21.665,-6.915) CP9(21.895,-6.305) CP10(21.665,-5.694) CP11(21.99,-5.044) CP12(21.665,-4.393) CP13(21.895,-3.783) CP14(21.665,-3.172) CP15(21.99,-2.522) CP16(21.665,-1.871) CP17(21.895,-1.261) CP18(21.665,-0.65) CP19(21.99,0) CP20(21.665,0.65) CP21(21.895,1.261) CP22(21.665,1.871) CP23(21.99,2.522) CP24(21.665,3.172) CP25(21.895,3.783) CP26(21.665,4.393) CP27(21.99,5.044) CP28(21.665,5.694) CP29(21.895,6.305) CP30(21.669,6.983) CP31(22.19,7.605) CP32(21.665,8.296) CR8(22.315,-6.915) CR10(22.315,-5.694) CR12(22.315,-4.393) CR14(22.315,-3.172) CR16(22.315,-1.871) CR18(22.315,-0.65) CR20(22.315,0.65) CR22(22.315,1.871) CR24(22.315,3.172) CR26(22.315,4.393) CR28(22.315,5.694) CR30(22.315,6.912)
  round 0.406 smd: A11(-22.315,-5.322) A12(-22.315,-4.38) A14(-22.315,-3.438) A15(-22.315,-2.496) A17(-22.315,-1.554) A18(-22.315,-0.613) A20(-22.315,0.329) B11(-21.665,-5.322) B12(-21.665,-4.38) B14(-21.665,-3.438) B15(-21.665,-2.496) B17(-21.665,-1.554) B18(-21.665,-0.613) B20(-21.665,0.329) C11(-21.015,-5.322) C12(-21.015,-4.38) C14(-21.015,-3.438) C15(-21.015,-2.496) C17(-21.015,-1.554) C18(-21.015,-0.613) C20(-21.015,0.329) D11(-20.365,-5.322) D12(-20.365,-4.38) D14(-20.365,-3.438) D15(-20.365,-2.496) D17(-20.365,-1.554) D18(-20.365,-0.613) D20(-20.365,0.329) F11(-19.715,-5.322) F12(-19.715,-4.38) F14(-19.715,-3.438) F15(-19.715,-2.496) F17(-19.715,-1.554) F18(-19.715,-0.613) F20(-19.715,0.329) G11(-19.065,-5.322) G12(-19.065,-4.38) G14(-19.065,-3.438) G15(-19.065,-2.496) G17(-19.065,-1.554) G18(-19.065,-0.613) G20(-19.065,0.329) H11(-18.415,-5.322) H12(-18.415,-4.38) H14(-18.415,-3.438) H15(-18.415,-2.496) H17(-18.415,-1.554) H18(-18.415,-0.613) H20(-18.415,0.329) J11(-17.765,-5.322) J12(-17.765,-4.38) J14(-17.765,-3.438) J15(-17.765,-2.496) J17(-17.765,-1.554) J18(-17.765,-0.613) J20(-17.765,0.329)
  oval 0.254x0.33 smd: AA1(-10.421,-11.315) AA2(-10.421,-10.665) AA3(-10.421,-10.015) AA35(-10.719,10.015) AA36(-10.719,10.665) AA37(-10.719,11.315) AB2(-9.763,-10.99) AB35(-10.068,10.34) AB36(-10.068,10.99) AC1(-9.106,-11.315) AC2(-9.106,-10.665) AC3(-9.106,-10.015) AC35(-9.417,10.015) AC36(-9.417,10.665) AC37(-9.417,11.315) AD3(-8.543,-10.34) AD36(-8.809,10.895) AE1(-7.98,-11.315) AE2(-7.98,-10.665) AE3(-7.98,-10.015) AE35(-8.202,10.015) AE36(-8.202,10.665) AE37(-8.202,11.315) AF2(-7.322,-10.99) AF35(-7.551,10.34) AF36(-7.551,10.99) AG1(-6.665,-11.315) AG2(-6.665,-10.665) AG3(-6.665,-10.015) AG35(-6.9,10.015) AG36(-6.9,10.665) AG37(-6.9,11.315) AH3(-6.102,-10.34) AH36(-6.293,10.895) AJ1(-5.539,-11.315) AJ2(-5.539,-10.665) AJ3(-5.539,-10.015) AJ35(-5.685,10.015) AJ36(-5.685,10.665) AJ37(-5.685,11.315) AK2(-4.882,-10.99) AK35(-5.034,10.34) AK36(-5.034,10.99) AL1(-4.224,-11.315) AL2(-4.224,-10.665) AL3(-4.224,-10.015) AL35(-4.383,10.015) AL36(-4.383,10.665) AL37(-4.383,11.315) AM3(-3.661,-10.34) AM36(-3.775,10.895) AN1(-3.098,-11.315) AN2(-3.098,-10.665) AN3(-3.098,-10.015) AN35(-3.168,10.015) AN36(-3.168,10.665) AN37(-3.168,11.315) AP2(-2.441,-10.99) AP35(-2.517,10.34) AP36(-2.517,10.99) AR1(-1.783,-11.315) AR2(-1.783,-10.665) AR3(-1.783,-10.015) AR35(-1.866,10.015) AR36(-1.866,10.665) AR37(-1.866,11.315) AT3(-1.22,-10.34) AT36(-1.259,10.895) AU1(-0.657,-11.315) AU2(-0.657,-10.665) AU3(-0.657,-10.015) AU35(-0.65,10.015) AU36(-0.65,10.665) AU37(-0.65,11.315) AV2(0,-10.99) AV35(0,10.34) AV36(0,10.99) AW1(0.657,-11.315) AW2(0.657,-10.665) AW3(0.657,-10.015) AW35(0.65,10.015) AW36(0.65,10.665) AW37(0.65,11.315) AY3(1.22,-10.34) AY36(1.259,10.895) BA1(1.783,-11.315) BA2(1.783,-10.665) BA3(1.783,-10.015) BA35(1.866,10.015) BA36(1.866,10.665) BA37(1.866,11.315) BB2(2.441,-10.99) BB35(2.517,10.34) BB36(2.517,10.99) BC1(3.098,-11.315) BC2(3.098,-10.665) BC3(3.098,-10.015) BC35(3.168,10.015) BC36(3.168,10.665) BC37(3.168,11.315) BD3(3.661,-10.34) BD36(3.775,10.895) BE1(4.224,-11.315) BE2(4.224,-10.665) BE3(4.224,-10.015) BE35(4.383,10.015) BE36(4.383,10.665) BE37(4.383,11.315) BF2(4.882,-10.99) BF35(5.034,10.34) BF36(5.034,10.99) BG1(5.539,-11.315) BG2(5.539,-10.665) BG3(5.539,-10.015) BG35(5.685,10.015) BG36(5.685,10.665) BG37(5.685,11.315) BH3(6.102,-10.34) BH36(6.293,10.895) BJ1(6.665,-11.315) BJ2(6.665,-10.665) BJ3(6.665,-10.015) BJ35(6.9,10.015) BJ36(6.9,10.665) BJ37(6.9,11.315) BK2(7.322,-10.99) BK35(7.551,10.34) BK36(7.551,10.99) BL1(7.98,-11.315) BL2(7.98,-10.665) BL3(7.98,-10.015) BL35(8.202,10.015) BL36(8.202,10.665) BL37(8.202,11.315) BM3(8.543,-10.34) BM36(8.809,10.895) BN1(9.106,-11.315) BN2(9.106,-10.665) BN3(9.106,-10.015) BN35(9.417,10.015) BN36(9.417,10.665) BN37(9.417,11.315) BP2(9.763,-10.99) BP35(10.068,10.34) BP36(10.068,10.99) BR1(10.421,-11.315) BR2(10.421,-10.665) BR3(10.421,-10.015) BR35(10.719,10.015) BR36(10.719,10.665) BR37(10.719,11.315) BT3(10.984,-10.34) BT36(11.327,10.895) BU1(11.547,-11.315) BU2(11.547,-10.665) BU3(11.547,-10.015) BU35(11.934,10.015) BU36(11.934,10.665) BU37(11.934,11.315) BV2(12.204,-10.99) BV35(12.585,10.34) BV36(12.585,10.99) BW1(12.861,-11.315) BW2(12.861,-10.665) BW3(12.861,-10.015) BW35(13.236,10.015) BW36(13.236,10.665) BW37(13.236,11.315) BY3(13.424,-10.34) BY36(13.844,10.895) CA1(13.988,-11.315) CA2(13.988,-10.665) CA3(13.988,-10.015) CA35(14.451,10.015) CA36(14.451,10.665) CA37(14.451,11.315) CB2(14.645,-10.99) CB35(15.102,10.34) CB36(15.102,10.99) CC1(15.302,-11.315) CC2(15.302,-10.665) CC3(15.302,-10.015) CC35(15.753,10.015) CC36(15.753,10.665) CC37(15.753,11.315) CD3(15.865,-10.34) CE1(16.428,-11.315) CE2(16.428,-10.665) CE3(16.428,-10.015) CE36(16.36,10.895) CF2(17.086,-10.99) CF35(16.968,10.015) CF36(16.968,10.665) CF37(16.968,11.315) CG1(17.743,-11.315) CG2(17.743,-10.665) CG3(17.743,-10.015) CG35(17.619,10.34) CG36(17.619,10.99) CH3(18.306,-10.34) CH35(18.27,10.015) CH36(18.27,10.665) CH37(18.27,11.315) CJ1(18.869,-11.315) CJ2(18.869,-10.665) CJ3(18.869,-10.015) CJ36(18.878,10.895) CK2(19.555,-10.485) CN26(21.021,4.478) G2(-18.869,-10.665) G3(-18.869,-10.015) G36(-18.878,10.895) H3(-18.306,-10.34) H35(-18.27,10.015) H36(-18.27,10.665) H37(-18.27,11.315) J1(-17.743,-11.315) J2(-17.743,-10.665) J3(-17.743,-10.015) J35(-17.619,10.34) J36(-17.619,10.99) K2(-17.086,-10.99) K35(-16.968,10.015) K36(-16.968,10.665) K37(-16.968,11.315) L1(-16.428,-11.315) L2(-16.428,-10.665) L3(-16.428,-10.015) L36(-16.36,10.895) M3(-15.865,-10.34) N1(-15.302,-11.315) N2(-15.302,-10.665) N3(-15.302,-10.015) N35(-15.753,10.015) N36(-15.753,10.665) N37(-15.753,11.315) P2(-14.645,-10.99) P35(-15.102,10.34) P36(-15.102,10.99) R1(-13.988,-11.315) R2(-13.988,-10.665) R3(-13.988,-10.015) R35(-14.451,10.015) R36(-14.451,10.665) R37(-14.451,11.315) T3(-13.424,-10.34) T36(-13.844,10.895) U1(-12.861,-11.315) U2(-12.861,-10.665) U3(-12.861,-10.015) U35(-13.236,10.015) U36(-13.236,10.665) U37(-13.236,11.315) V2(-12.204,-10.99) V35(-12.585,10.34) V36(-12.585,10.99) W1(-11.547,-11.315) W2(-11.547,-10.665) W3(-11.547,-10.015) W35(-11.934,10.015) W36(-11.934,10.665) W37(-11.934,11.315) Y3(-10.984,-10.34) Y36(-11.327,10.895)
