# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ5: length 52.2
  TOP w0.102: U6.D7 v1(44.27,87.36)
  IN3 w0.089: v2(81.51,74.46) 81.51,74.5 80.94,75.07 80.94,75.86 78.07,78.73 77.05,78.73 76.37,79.41 76.06,79.41 75.22,80.25 73.72,80.25 73.42,80.55 73.24,80.55 73.15,80.46 73.15,80.21 73.06,80.12 72.89,80.12 72.8,80.21 72.8,80.46 72.71,80.55 72.53,80.55 72.44,80.46 72.44,80.21 72.35,80.12 72.18,80.12 72.09,80.21 72.09,80.46 72,80.55 71.82,80.55 71.73,80.46 71.73,80.21 71.64,80.12 71.46,80.12 71.38,80.21 71.38,80.46 71.29,80.55 71.11,80.55 71.02,80.46 71.02,80.21 70.93,80.12 70.75,80.12 70.66,80.21 70.66,80.46 70.58,80.55 67.6,80.55 66.58,81.57 59.39,81.57 58.57,82.39 49.71,82.39 49.15,82.95 48.57,82.95 48.48,83.03 48.48,83.37 48.39,83.45 48.21,83.45 48.12,83.37 48.12,83.03 48.04,82.95 47.86,82.95 47.77,83.03 47.77,83.37 47.68,83.45 47.5,83.45 47.41,83.37 47.41,83.03 47.32,82.95 47.15,82.95 47.06,83.03 47.06,83.37 46.97,83.45 46.79,83.45 46.7,83.37 46.7,83.03 46.61,82.95 44.18,82.95 43.87,83.25 43.87,86.96 v1(44.27,87.36)
  BOTTOM w0.079: U1.J25 81.81,74.77 v2(81.51,74.46)
M_B_DQ6: length 51.2
  TOP w0.102: U6.C7 v1(45.07,87.36)
  IN3 w0.089: v1(45.07,87.36) 45.47,86.96 46.84,86.96 47.41,86.39 47.41,85.89 47.32,85.81 47.16,85.81 47.07,85.72 47.07,85.54 47.16,85.45 47.65,85.45 47.74,85.36 47.74,85.21 47.63,85.09 46.62,85.09 46.5,84.98 46.5,84.83 46.6,84.73 48.92,84.73 49.01,84.64 49.01,84.51 49.1,84.43 49.27,84.43 49.36,84.51 49.36,84.64 49.45,84.73 49.63,84.73 49.72,84.64 49.72,83.98 49.81,83.89 49.99,83.89 50.08,83.98 50.08,84.64 50.16,84.73 50.41,84.73 51.41,83.72 61.69,83.72 62.11,83.31 62.11,82.54 62.36,82.29 66.88,82.29 67.9,81.27 72.22,81.27 72.31,81.36 72.31,81.48 72.4,81.57 72.58,81.57 72.67,81.48 72.67,81.36 72.76,81.27 72.93,81.27 73.02,81.36 73.02,81.48 73.11,81.57 73.29,81.57 73.38,81.48 73.38,81.36 73.47,81.27 73.65,81.27 73.77,81.39 76.16,81.39 76.76,80.79 76.76,79.8 77.31,79.26 78.37,79.26 79.13,78.5 79.86,78.5 81.03,77.33 81.6,77.33 81.88,77.05 81.88,75.96 81.66,75.74 v2(81.52,75.74)
  BOTTOM w0.102: U1.G25 81.85,76.07 v2(81.52,75.74)
M_B_DQ7: length 50.9
  TOP w0.102: U6.D3 43.87,89.68 v1(44.94,88.61)
  IN3 w0.089: v2(83.46,75.97) 83.67,75.97 83.87,76.18 83.87,77.59 82.62,78.84 80.7,78.84 80.05,79.49 79.56,79.49 78.17,80.89 78.17,81.75 77.84,82.08 74.63,82.08 73.94,82.76 68.12,82.76 65.77,85.11 60.63,85.11 60.22,85.52 58.74,85.52 58.65,85.43 58.65,85.2 58.56,85.11 58.39,85.11 58.3,85.2 58.3,85.43 58.21,85.52 58.03,85.52 57.94,85.43 57.94,85.2 57.85,85.11 57.68,85.11 57.59,85.2 57.59,85.43 57.5,85.52 51.31,85.52 50.35,86.47 49.01,86.47 46.88,88.61 v1(44.94,88.61)
  BOTTOM w0.079: v2(83.46,75.97) 83.48,75.97 84,76.49 U1.F22
M_B_DQ8: length 63.6
  TOP w0.102: U6.H3 v1(41.07,90.56)
  IN3 w0.089: v2(84.36,83.55) 84.52,83.7 84.52,84.74 82.38,86.88 80.27,86.88 78.75,88.4 76.22,88.4 73.98,86.15 73.35,86.15 73.06,85.87 69.45,85.87 69.27,86.04 69.27,86.16 69.63,86.52 69.63,86.64 69.5,86.77 69.38,86.77 69.02,86.41 68.9,86.41 68.77,86.54 68.77,86.67 69.13,87.02 69.13,87.15 69,87.27 68.87,87.27 68.52,86.92 68.39,86.92 66.43,88.88 61.43,88.88 61,89.31 59.52,89.31 58.76,90.07 55.4,90.07 55.21,90.27 55.21,90.69 54.81,91.09 54.56,91.09 54.48,91 54.48,90.87 54.39,90.78 54.21,90.78 54.12,90.87 54.12,91 54.03,91.09 51.22,91.09 51.13,91 51.13,90.87 51.04,90.78 50.87,90.78 50.78,90.87 50.78,91 50.69,91.09 50.38,91.09 49.84,91.64 48.53,91.64 46.99,93.17 46.49,93.17 46.39,93.07 46.39,92.7 46.25,92.56 45.12,92.56 45.03,92.65 45.03,92.74 44.94,92.83 44.76,92.83 44.67,92.74 44.67,92.65 44.58,92.56 44.4,92.56 44.32,92.65 44.32,92.74 44.23,92.83 44.05,92.83 43.96,92.74 43.96,92.65 43.87,92.56 43.69,92.56 43.6,92.65 43.6,92.74 43.52,92.83 43.34,92.83 43.25,92.74 43.25,92.65 43.16,92.56 42.5,92.56 42.27,92.32 42.27,91.99 42.04,91.76 42.01,91.76 42.01,91.75 41.67,91.75 41.47,91.56 41.47,90.97 41.07,90.57 v1(41.07,90.56)
  BOTTOM w0.076: U1.D22 83.97,77.57 83.97,77.78 83.92,77.93 83.92,78.1 83.95,78.26 83.95,78.49 83.92,78.55 83.92,78.76 83.95,78.83 83.95,79.08 83.92,79.21 83.92,79.53 84.14,79.74 84.14,80.3 84.01,80.43 84.01,83.2 v2(84.36,83.55)
M_B_DQ9: length 63.2
  TOP w0.102: U6.G2 v1(41.87,92.16)
  IN3 w0.089: v1(41.87,92.16) 41.87,92.26 42.28,92.67 42.28,93.13 42.8,93.65 44.96,93.65 45.04,93.57 45.04,93.2 45.13,93.11 45.31,93.11 45.4,93.2 45.4,93.57 45.49,93.65 45.67,93.65 45.76,93.57 45.76,92.89 45.84,92.8 46,92.8 46.11,92.91 46.11,93.57 46.2,93.65 46.85,93.65 48.63,91.88 49.94,91.88 50.48,91.33 50.72,91.33 50.81,91.42 50.81,91.64 50.9,91.73 51.08,91.73 51.17,91.64 51.17,91.42 51.26,91.33 51.44,91.33 51.52,91.42 51.52,91.64 51.61,91.73 51.79,91.73 51.88,91.64 51.88,91.42 51.97,91.33 52.15,91.33 52.24,91.42 52.24,91.64 52.32,91.73 52.5,91.73 52.59,91.64 52.59,91.42 52.68,91.33 54.91,91.33 55.92,90.31 58.86,90.31 59.62,89.55 61.1,89.55 61.53,89.12 66.55,89.12 67.84,87.84 67.96,87.84 68.31,88.18 68.43,88.18 68.56,88.05 68.56,87.93 68.22,87.58 68.22,87.46 68.34,87.33 68.47,87.33 68.81,87.68 68.94,87.68 70.51,86.11 72.96,86.11 73.25,86.4 73.88,86.4 76.12,88.64 78.86,88.64 80.37,87.12 82.48,87.12 84.79,84.81 84.79,82.78 v2(84.39,82.38)
  BOTTOM w0.076: U1.C22 84.51,78.34 84.51,78.98 84.97,79.83 84.97,81.8 v2(84.39,82.38)
M_B_DQ10: length 62.1
  TOP w0.102: v1(41.07,88.16) 40.83,87.92 40.83,87.87 40.72,87.76 U6.H7
  IN3 w0.089: v1(41.07,88.16) 41.07,88.49 41.45,88.87 43.76,88.87 43.95,89.06 43.95,89.44 45.23,90.71 47.03,90.71 47.86,89.88 49.56,89.88 51.65,87.79 51.9,87.79 51.99,87.88 51.99,88.21 52.07,88.3 52.25,88.3 52.34,88.21 52.34,87.88 52.43,87.79 52.61,87.79 52.7,87.88 52.7,88.21 52.79,88.3 52.96,88.3 53.05,88.21 53.05,87.88 53.14,87.79 53.32,87.79 53.41,87.88 53.41,88.21 53.5,88.3 53.67,88.3 53.76,88.21 53.76,87.88 53.85,87.79 55.58,87.79 56.12,88.33 57.15,88.33 57.41,88.07 57.41,87.53 57.82,87.12 57.95,87.12 58.03,87.21 58.03,87.67 58.15,87.79 58.3,87.79 58.39,87.7 58.39,87.21 58.48,87.12 58.66,87.12 58.75,87.21 58.75,87.67 58.86,87.79 59.01,87.79 59.1,87.7 59.1,87.21 59.19,87.12 59.37,87.12 59.46,87.21 59.46,87.36 59.55,87.44 59.72,87.44 59.81,87.36 59.81,87.21 59.9,87.12 60.08,87.12 60.17,87.21 60.17,87.36 60.26,87.44 60.43,87.44 60.52,87.36 60.52,87.21 60.61,87.12 60.79,87.12 60.88,87.21 60.88,87.36 60.97,87.44 61.15,87.44 61.23,87.36 61.23,87.21 61.32,87.12 61.5,87.12 61.59,87.21 61.59,87.36 61.68,87.44 61.86,87.44 61.95,87.36 61.95,87.21 62.03,87.12 62.21,87.12 62.3,87.21 62.3,87.36 62.39,87.44 62.57,87.44 62.66,87.36 62.66,87.21 62.75,87.12 62.92,87.12 63.01,87.21 63.01,87.36 63.1,87.44 63.28,87.44 63.37,87.36 63.37,87.21 63.46,87.12 66.16,87.12 68.92,84.36 73.59,84.36 73.95,84.72 75.28,84.72 76,85.44 81.71,85.44 82.68,84.48 82.68,81.94 v2(82.21,81.47)
  BOTTOM w0.079: v2(82.21,81.47) 82.21,81.44 82.41,81.24 82.41,79.18 82.49,79.11 82.52,79.02 82.52,78.9 82.62,78.8 82.62,78.27 U1.C24
M_B_DQ11: length 63.2
  TOP w0.076: v1(39.99,88.43) 39.87,88.31 U6.J7
  IN3 w0.089: v1(39.99,88.43) 39.99,87.79 40.17,87.62 40.58,87.62 40.67,87.7 40.67,88.67 41.14,89.14 43.31,89.14 45.13,90.96 47.13,90.96 47.96,90.12 49.66,90.12 51.25,88.54 54,88.54 54.09,88.45 54.09,88.12 54.18,88.03 54.36,88.03 54.45,88.12 54.45,88.45 54.54,88.54 54.72,88.54 54.8,88.45 54.8,88.12 54.89,88.03 55.07,88.03 55.16,88.12 55.16,88.45 55.28,88.57 57.59,88.57 57.68,88.48 57.68,87.99 57.77,87.9 57.92,87.9 58.04,88.02 58.04,88.68 58.13,88.77 58.37,88.77 58.44,88.7 58.44,88.12 58.53,88.03 59.11,88.03 59.45,87.69 63.74,87.69 63.83,87.6 63.83,87.45 63.92,87.36 64.1,87.36 64.18,87.45 64.18,87.6 64.27,87.69 64.45,87.69 64.54,87.6 64.54,87.45 64.63,87.36 64.81,87.36 64.9,87.45 64.9,87.6 64.98,87.69 65.16,87.69 65.25,87.6 65.25,87.45 65.34,87.36 65.52,87.36 65.61,87.45 65.61,87.6 65.7,87.69 65.94,87.69 68.95,84.67 73.56,84.67 73.85,84.96 75.18,84.96 75.9,85.69 81.81,85.69 82.97,84.53 82.97,80.94 83.26,80.65 v2(83.53,80.65)
  BOTTOM w0.079: v2(83.53,80.65) 83.97,80.2 83.97,79.81 83.75,79.6 83.75,79.19 83.78,79.06 83.78,78.86 83.75,78.79 83.75,78.51 83.79,78.45 83.79,78.31 83.75,78.11 83.75,77.91 83.81,77.75 83.81,77.57 83.6,77.37 U1.D24
M_B_DQ12: length 62.1
  TOP w0.102: v1(41.21,89.9) 40.92,89.9 U6.J3
  IN3 w0.089: v2(84.39,80.6) 85.27,81.48 85.27,85.01 82.68,87.6 80.57,87.6 79.05,89.13 75.93,89.13 73.68,86.88 73.05,86.88 72.76,86.59 70.71,86.59 67.69,89.6 61.73,89.6 61.3,90.04 59.82,90.04 59.06,90.8 56.12,90.8 54.17,92.75 48.66,92.75 47.27,94.14 42.6,94.14 42.15,93.68 41.69,93.68 40.64,92.64 40.64,90.34 41.08,89.9 v1(41.21,89.9)
  BOTTOM w0.079: U1.A22 84.39,79.53 v2(84.39,80.6)
M_B_DQ13: length 62.4
  TOP w0.102: U6.H2 v1(41.07,91.36)
  IN3 w0.089: v1(41.07,91.36) 41.07,91.57 41.46,91.97 41.46,91.98 41.47,91.99 41.47,93.12 41.79,93.44 42.25,93.44 42.7,93.9 47.17,93.9 48.56,92.51 49.74,92.51 49.83,92.42 49.83,92.25 49.92,92.16 50.1,92.16 50.19,92.25 50.19,92.42 50.27,92.51 50.45,92.51 50.54,92.42 50.54,92.25 50.63,92.16 50.81,92.16 50.9,92.25 50.9,92.42 50.99,92.51 51.16,92.51 51.25,92.42 51.25,92.25 51.34,92.16 51.52,92.16 51.61,92.25 51.61,92.42 51.7,92.51 51.87,92.51 51.96,92.42 51.96,92.25 52.05,92.16 52.23,92.16 52.32,92.25 52.32,92.42 52.41,92.51 52.59,92.51 52.68,92.42 52.68,92.12 52.76,92.04 52.94,92.04 53.03,92.12 53.03,92.42 53.12,92.51 53.3,92.51 53.39,92.42 53.39,92.12 53.48,92.04 53.65,92.04 53.74,92.12 53.74,92.42 53.83,92.51 54.07,92.51 56.02,90.56 58.96,90.56 59.72,89.79 61.2,89.79 61.63,89.36 67.59,89.36 70.61,86.35 72.86,86.35 73.15,86.64 73.78,86.64 76.02,88.88 78.96,88.88 80.47,87.36 82.58,87.36 85.03,84.91 85.03,82.42 v2(84.39,81.77)
  BOTTOM w0.079: v2(84.39,81.77) 84.8,81.37 84.8,79.85 84.34,79.02 84.34,78.83 U1.B22
M_B_DQ14: length 62.6
  TOP w0.102: U6.F7 v1(41.87,88.16)
  IN3 w0.089: v2(82.18,83.25) 81.81,83.62 81.81,85 81.61,85.2 81.37,85.2 81.28,85.11 81.28,84.44 81.19,84.35 81.01,84.35 80.93,84.44 80.93,85.11 80.84,85.2 80.66,85.2 80.57,85.11 80.57,84.44 80.48,84.35 80.3,84.35 80.21,84.44 80.21,85.11 80.13,85.2 79.95,85.2 79.86,85.11 79.86,84.44 79.77,84.35 79.59,84.35 79.5,84.44 79.5,85.11 79.41,85.2 79.24,85.2 79.15,85.11 79.15,84.44 79.06,84.35 78.88,84.35 78.79,84.44 78.79,85.11 78.7,85.2 78.53,85.2 78.44,85.11 78.44,84.61 78.35,84.52 78.17,84.52 78.08,84.61 78.08,85.11 77.99,85.2 76.1,85.2 75.38,84.48 74.05,84.48 73.69,84.12 68.82,84.12 66.06,86.88 57.72,86.88 57.07,87.53 55.64,87.53 55.55,87.44 55.55,86.97 55.46,86.88 55.28,86.88 55.19,86.97 55.19,87.44 55.11,87.53 54.93,87.53 54.84,87.44 54.84,86.97 54.75,86.88 54.57,86.88 54.48,86.97 54.48,87.44 54.39,87.53 54.22,87.53 54.13,87.44 54.13,86.97 54.04,86.88 53.86,86.88 53.77,86.97 53.77,87.44 53.66,87.55 51.55,87.55 49.46,89.64 47.76,89.64 46.93,90.47 45.33,90.47 44.19,89.34 44.19,88.71 44.12,88.63 43.88,88.63 43.79,88.54 43.79,88.09 43.7,88 43.52,88 43.43,88.09 43.43,88.54 43.34,88.63 42.35,88.63 v1(41.87,88.16)
  BOTTOM w0.076: U1.A24 82.88,79.42 82.74,79.55 82.74,82.67 82.18,83.22 v2(82.18,83.25)
M_B_DQ15: length 62.6
  TOP w0.102: U6.H8 v1(41.07,87.36)
  IN3 w0.089: v1(41.07,87.36) 41.47,87.76 43.07,87.76 43.16,87.67 43.16,87.12 43.25,87.04 43.42,87.04 43.51,87.13 43.51,87.67 43.6,87.76 44.14,87.76 44.44,88.05 44.44,89.24 45.43,90.23 46.83,90.23 47.66,89.4 49.36,89.4 51.45,87.3 53.26,87.3 53.5,87.07 53.5,86.78 53.64,86.64 55.71,86.64 55.82,86.75 55.82,87 55.93,87.1 57.15,87.1 57.62,86.64 63.7,86.64 63.79,86.55 63.79,86.37 63.91,86.26 64.06,86.26 64.15,86.35 64.15,86.55 64.24,86.64 64.42,86.64 64.5,86.55 64.5,86.37 64.62,86.26 64.77,86.26 64.86,86.35 64.86,86.55 64.95,86.64 65.13,86.64 65.22,86.55 65.22,86.37 65.33,86.26 65.48,86.26 65.57,86.35 65.57,86.55 65.66,86.64 65.96,86.64 68.72,83.88 73.79,83.88 74.15,84.24 75.48,84.24 76.2,84.96 77.46,84.96 77.74,84.68 77.74,84.39 77.9,84.24 78.29,84.24 78.38,84.15 78.38,83.91 78.29,83.82 77.8,83.82 77.71,83.73 77.71,83.55 77.8,83.46 78.29,83.46 78.38,83.37 78.38,83.13 78.47,83.04 78.64,83.04 78.73,83.13 78.73,84.02 78.82,84.11 79.48,84.11 79.57,84.02 79.57,83.05 79.66,82.97 79.84,82.97 79.93,83.05 79.93,84.02 80.01,84.11 80.19,84.11 80.28,84.02 80.28,83.34 80.37,83.25 80.55,83.25 80.64,83.34 80.64,84.02 80.73,84.11 81.24,84.11 81.57,83.78 81.57,83.28 v2(82.18,82.66)
  BOTTOM w0.076: U1.B24 82.88,78.87 82.69,79.06 82.61,79.23 82.57,79.27 82.57,82.27 v2(82.18,82.66)
M_B_DQ16: length 50.2
  TOP w0.102: U7.G2 41.47,78.46 v1(41.87,78.85)
  IN3 w0.089: v1(41.87,78.85) 41.46,79.26 41.46,79.82 41.82,80.17 41.82,80.47 41.91,80.55 42.03,80.55 42.25,80.34 42.37,80.34 42.5,80.47 42.5,80.59 42.32,80.77 42.32,80.89 42.44,81.01 42.59,81.01 42.75,80.84 42.88,80.84 43,80.97 43,81.09 42.75,81.35 42.75,81.48 43.2,81.92 43.37,81.92 43.46,81.83 43.46,81.16 43.55,81.07 43.73,81.07 43.82,81.16 43.82,81.82 43.96,81.97 47.51,81.97 47.6,81.88 47.6,81.64 47.71,81.53 47.86,81.53 47.95,81.62 47.95,81.88 48.04,81.97 48.28,81.97 48.43,81.82 48.43,81.25 48.58,81.1 49.12,81.1 49.59,80.62 49.83,80.62 49.92,80.71 49.92,81.23 50.01,81.32 50.19,81.32 50.28,81.23 50.28,80.71 50.37,80.62 50.55,80.62 50.63,80.71 50.63,81.23 50.72,81.32 50.9,81.32 50.99,81.23 50.99,80.71 51.08,80.62 53.91,80.62 54.01,80.73 54.01,81.11 54.1,81.2 58.3,81.2 58.8,80.69 66.21,80.69 66.77,80.14 66.77,79.41 66.94,79.24 73.55,79.24 74.15,78.64 76.08,78.64 76.56,78.16 77.49,78.16 78.15,77.5 v2(78.15,76.63)
  BOTTOM w0.079: v2(78.15,76.63) 78.39,76.38 U1.G31
M_B_DQ17: length 52.6
  TOP w0.102: U7.H3 v1(41.07,77.26)
  IN3 w0.089: v2(77.47,76.61) 77.66,76.8 77.66,77.74 77.41,77.98 76.49,77.98 76.01,78.46 73.99,78.46 73.45,79 66.71,79 66.53,79.18 66.53,80.04 66.11,80.45 59.45,80.45 59.29,80.29 59.29,80.04 59.2,79.95 59.05,79.95 58.94,80.06 58.94,80.29 58.85,80.38 58.67,80.38 58.58,80.29 58.58,79.79 58.47,79.67 58.31,79.67 58.22,79.76 58.22,80.87 58.14,80.95 57.98,80.95 57.87,80.84 57.87,79.79 57.75,79.67 57.6,79.67 57.51,79.76 57.51,80.29 57.42,80.38 57.25,80.38 57.16,80.29 57.16,80.11 57.07,80.02 56.9,80.02 56.8,80.11 56.8,80.32 56.71,80.41 56.54,80.41 56.45,80.32 56.45,80.12 56.36,80.03 56.18,80.03 56.09,80.12 56.09,80.32 56,80.41 55.82,80.41 55.74,80.32 55.74,80.12 55.65,80.03 55.47,80.03 55.38,80.12 55.38,80.58 55.29,80.66 55.11,80.66 55.02,80.57 55.02,80.12 54.94,80.03 54.76,80.03 54.67,80.12 54.67,80.86 54.57,80.95 54.34,80.95 54.25,80.87 54.25,80.54 54.09,80.38 49.49,80.38 49.02,80.86 48.49,80.86 48.4,80.77 48.4,80.54 48.31,80.45 48.16,80.45 48.04,80.57 48.04,80.77 47.95,80.86 47.75,80.86 47.67,80.94 47.67,81.23 47.17,81.73 44.73,81.73 43.78,80.78 43.15,80.78 42.37,79.99 42.37,78.78 42.05,78.47 42.04,78.45 41.7,78.45 41.47,78.23 41.47,77.66 v1(41.07,77.26)
  BOTTOM w0.079: U1.G32 77.74,76.33 v2(77.47,76.61)
M_B_DQ18: length 51.4
  TOP w0.102: U7.H8 v1(41.07,74.06)
  IN3 w0.089: v1(41.07,74.06) 41.47,74.46 42.95,74.46 43.07,74.34 43.07,73.13 42.98,73.04 42.59,73.04 42.51,72.95 42.51,72.78 42.59,72.69 42.98,72.69 43.07,72.6 43.07,72.31 43.32,72.06 43.62,72.06 43.81,72.24 43.81,74.16 44.51,74.86 44.51,76.44 45.31,77.25 45.31,78.1 45.67,78.46 46.84,78.46 47.63,77.66 49.71,77.66 50.16,78.12 54.12,78.12 55.44,76.8 58.91,76.8 59,76.88 59,77.28 59.09,77.37 59.27,77.37 59.35,77.28 59.35,76.88 59.44,76.8 65.54,76.8 66.18,76.16 72.15,76.16 72.83,76.84 73.31,76.84 73.41,76.94 73.72,76.94 74.01,76.66 75.28,76.66 77,74.94 79.2,74.94 79.3,74.84 v2(79.3,74.79)
  BOTTOM w0.079: U1.H29 79.69,75.18 v2(79.3,74.79)
M_B_DQ19: length 51.1
  TOP w0.102: U7.F7 v1(41.87,74.86)
  IN3 w0.089: v2(80.02,74.77) 80.02,74.84 79.69,75.17 79.06,75.17 79.01,75.12 77.1,75.12 75.32,76.9 74.11,76.9 73.82,77.18 73.31,77.18 73.21,77.08 72.73,77.08 72.05,76.4 66.28,76.4 65.64,77.04 62.01,77.04 61.44,77.61 58.73,77.61 58.64,77.52 58.64,77.13 58.55,77.04 58.38,77.04 58.29,77.13 58.29,77.52 58.2,77.61 58.02,77.61 57.93,77.52 57.93,77.13 57.84,77.04 57.67,77.04 57.58,77.13 57.58,77.52 57.49,77.61 56.67,77.61 56.58,77.52 56.58,77.13 56.49,77.04 56.31,77.04 56.23,77.13 56.23,77.52 56.14,77.61 55.96,77.61 55.87,77.52 55.87,77.13 55.78,77.04 55.6,77.04 55.51,77.13 55.51,77.52 55.43,77.61 54.97,77.61 54.22,78.36 50.06,78.36 49.61,77.9 47.73,77.9 47.07,78.56 47.07,79.15 46.96,79.26 46.5,79.26 46.1,78.85 45.65,78.85 45.02,78.22 45.02,77.37 44.22,76.56 44.22,74.91 43.75,74.44 43.31,74.44 43.14,74.61 43.14,75.45 42.92,75.67 42.68,75.67 v1(41.87,74.86)
  BOTTOM w0.079: U1.H28 80.34,75.09 v2(80.02,74.77)
M_B_DQ20: length 49.7
  TOP w0.102: U7.J3 39.87,77.5 40.65,76.72 41.03,76.72 v1(41.18,76.57)
  IN3 w0.089: v1(41.18,76.57) 40.65,77.1 40.65,78.04 40.32,78.37 40.32,80.59 42.29,82.55 48.99,82.55 49.54,82 58.41,82 59.23,81.18 66.41,81.18 67.87,79.72 73.71,79.72 74.44,78.99 76.23,78.99 76.71,78.51 77.63,78.51 78.95,77.19 78.95,77.18 v2(79.51,76.62)
  BOTTOM w0.079: v2(79.51,76.62) 79.82,76.62 80.3,76.14 U1.G28
M_B_DQ21: length 51.5
  TOP w0.102: U7.H2 v1(41.07,78.06)
  IN3 w0.089: v2(78.88,76.6) 78.6,76.87 78.6,77.3 77.56,78.34 76.63,78.34 76.16,78.81 74.36,78.81 73.7,79.48 67.18,79.48 67.01,79.65 67.01,80.24 66.31,80.94 59.05,80.94 58.24,81.75 57.99,81.75 57.91,81.67 57.91,81.53 57.82,81.44 57.64,81.44 57.55,81.53 57.55,81.67 57.46,81.75 57.28,81.75 57.19,81.67 57.19,81.53 57.11,81.44 56.93,81.44 56.84,81.53 56.84,81.67 56.75,81.75 56.57,81.75 56.48,81.67 56.48,81.53 56.39,81.44 56.22,81.44 56.13,81.53 56.13,81.67 56.04,81.75 55.86,81.75 55.77,81.67 55.77,81.53 55.68,81.44 55.5,81.44 55.42,81.53 55.42,81.67 55.33,81.75 55.15,81.75 55.06,81.67 55.06,81.53 54.97,81.44 54.79,81.44 54.7,81.53 54.7,81.67 54.62,81.75 54.44,81.75 54.35,81.67 54.35,81.53 54.26,81.44 54.08,81.44 53.99,81.53 53.99,81.67 53.9,81.75 53.02,81.75 52.89,81.62 52.66,81.62 52.53,81.75 52.31,81.75 52.17,81.62 51.95,81.62 51.82,81.75 51.6,81.75 51.46,81.62 51.24,81.62 51.11,81.75 50.88,81.75 50.75,81.62 50.53,81.62 50.4,81.75 50.17,81.75 50.04,81.62 49.82,81.62 49.68,81.75 49.44,81.75 48.99,82.21 42.9,82.21 42.81,82.12 42.81,82 42.69,81.87 42.58,81.87 42.36,82.09 42.23,82.09 42.11,81.96 42.11,81.83 42.46,81.48 42.46,81.35 42.34,81.23 42.21,81.23 41.86,81.58 41.73,81.58 40.61,80.47 40.61,80.03 40.7,79.94 41.08,79.94 41.17,79.85 41.17,79.67 41.08,79.58 40.7,79.58 40.61,79.49 40.61,78.49 41.05,78.06 v1(41.07,78.06)
  BOTTOM w0.079: v2(78.88,76.6) 79,76.6 79.46,76.14 U1.G29
M_B_DQ22: length 51.6
  TOP w0.102: U7.H7 v1(41.07,74.86)
  IN3 w0.089: v1(41.07,74.86) 41.07,74.91 41.82,75.66 42.05,75.66 42.65,76.25 42.77,76.25 43.7,75.33 43.8,75.33 43.92,75.46 43.92,75.61 43.02,76.51 43.02,76.63 43.15,76.76 43.28,76.76 43.65,76.39 43.8,76.39 43.92,76.51 43.92,76.61 43.53,77.01 43.53,77.13 43.73,77.34 43.9,77.34 44.18,77.06 44.3,77.06 44.67,77.43 44.67,77.44 44.67,79.02 44.9,79.26 46.16,79.26 46.4,79.5 47.06,79.5 47.7,78.86 49.97,78.86 50.23,78.6 54.32,78.6 54.47,78.45 55.07,77.85 62.27,77.85 62.35,77.76 62.35,77.37 62.44,77.28 62.62,77.28 62.71,77.37 62.71,77.76 62.8,77.85 62.98,77.85 63.07,77.76 63.07,77.37 63.15,77.28 63.33,77.28 63.42,77.37 63.42,77.76 63.51,77.85 63.69,77.85 63.78,77.76 63.78,77.37 63.87,77.28 64.04,77.28 64.13,77.37 64.13,77.76 64.22,77.85 64.4,77.85 64.49,77.76 64.49,77.37 64.58,77.28 64.75,77.28 64.84,77.37 64.84,77.76 64.93,77.85 65.17,77.85 66.38,76.64 71.95,76.64 72.63,77.32 73.11,77.32 73.21,77.42 73.92,77.42 74.16,77.19 75.28,77.19 77.18,75.3 77.79,75.3 78.15,75.66 v2(78.15,75.68)
  BOTTOM w0.079: U1.H31 78.24,75.38 78.24,75.59 v2(78.15,75.68)
M_B_DQ23: length 53
  TOP w0.102: v1(41.06,75.53) 40.94,75.53 U7.J7
  IN3 w0.089: v2(77.49,75.69) 77.04,75.69 75.25,77.48 74.21,77.48 74.02,77.67 73.11,77.67 73.01,77.56 72.53,77.56 72.47,77.51 71.92,77.51 71.83,77.42 71.83,76.97 71.74,76.88 71.56,76.88 71.47,76.97 71.47,77.42 71.38,77.51 71.21,77.51 71.12,77.42 71.12,76.97 71.03,76.88 70.85,76.88 70.76,76.97 70.76,77.42 70.67,77.51 67.03,77.51 66.94,77.42 66.94,76.97 66.85,76.88 66.67,76.88 66.58,76.97 66.58,77.42 66.49,77.51 65.86,77.51 65.27,78.09 65.03,78.09 64.94,78.18 64.94,78.39 64.85,78.48 64.68,78.48 64.59,78.39 64.59,78.18 64.5,78.09 64.32,78.09 64.23,78.18 64.23,78.39 64.14,78.48 63.97,78.48 63.88,78.39 63.88,78.18 63.79,78.09 63.61,78.09 63.52,78.18 63.52,78.39 63.43,78.48 63.25,78.48 63.17,78.39 63.17,78.18 63.08,78.09 62.9,78.09 62.81,78.18 62.81,78.39 62.72,78.48 62.54,78.48 62.45,78.39 62.45,78.18 62.37,78.09 62.19,78.09 62.1,78.18 62.1,78.39 62.01,78.48 61.83,78.48 61.74,78.39 61.74,78.18 61.65,78.09 61.48,78.09 61.39,78.18 61.39,78.39 61.3,78.48 61.12,78.48 61.03,78.39 61.03,78.18 60.94,78.09 60.77,78.09 60.68,78.18 60.68,78.39 60.59,78.48 60.41,78.48 60.32,78.39 60.32,78.18 60.23,78.09 60.05,78.09 59.97,78.18 59.97,78.39 59.88,78.48 59.7,78.48 59.61,78.39 59.61,78.18 59.52,78.09 59.34,78.09 59.25,78.18 59.25,78.39 59.17,78.48 58.99,78.48 58.9,78.39 58.9,78.18 58.81,78.09 58.63,78.09 58.54,78.18 58.54,78.39 58.45,78.48 58.28,78.48 58.19,78.39 58.19,78.18 58.1,78.09 57.92,78.09 57.83,78.18 57.83,78.39 57.74,78.48 57.57,78.48 57.48,78.39 57.48,78.18 57.39,78.09 57.21,78.09 57.12,78.18 57.12,78.26 57.03,78.35 56.85,78.35 56.76,78.26 56.76,78.18 56.68,78.09 56.5,78.09 56.41,78.18 56.41,78.26 56.32,78.35 56.14,78.35 56.05,78.26 56.05,78.18 55.96,78.09 55.17,78.09 54.57,78.69 54.42,78.84 50.33,78.84 50.07,79.1 47.8,79.1 47.16,79.74 46.3,79.74 46.06,79.5 44.29,79.5 43.87,79.08 43.87,77.89 42.05,76.07 41.36,76.07 41.06,75.76 v1(41.06,75.53)
  BOTTOM w0.079: U1.H32 77.59,75.38 77.59,75.59 v2(77.49,75.69)
M_B_DQ24: length 42.4
  TOP w0.102: U7.D3 43.87,77.09 v1(45.07,75.89)
  IN3 w0.089: v1(45.07,75.89) 45.33,76.15 49.93,76.15 50,76.08 50,75.73 50.07,75.66 50.32,75.66 50.38,75.72 50.38,76.95 50.47,77.04 50.65,77.04 50.74,76.95 50.74,76.24 50.83,76.15 51.3,76.15 51.68,76.52 54.04,76.52 54.24,76.33 54.24,76.08 54.41,75.92 64.68,75.92 65.31,75.28 73.02,75.28 73.21,75.47 73.78,75.47 73.87,75.39 73.87,75.08 73.96,74.99 74.13,74.99 74.22,75.08 74.22,75.39 74.31,75.47 74.49,75.47 74.58,75.39 74.58,75.08 74.67,74.99 74.85,74.99 74.93,75.08 74.93,75.39 75.02,75.47 75.58,75.47 76.64,74.41 78.42,74.41 78.77,74.06 v2(78.77,73.86)
  BOTTOM w0.079: v2(78.77,73.86) 78.39,73.49 U1.L31
M_B_DQ25: length 43.2
  TOP w0.102: v1(45.78,75.73) 45.78,75.85 44.67,76.96 U7.C3
  IN3 w0.089: v2(78.1,73.87) 78.1,73.94 77.81,74.23 76.49,74.23 76.02,74.7 75.66,74.7 75.57,74.79 75.57,75.01 75.49,75.1 75.31,75.1 75.22,75.01 75.22,74.79 75.13,74.7 73.18,74.7 73.1,74.78 73.1,74.97 73.02,75.04 72.54,75.04 72.45,74.95 72.45,74.84 72.36,74.75 72.19,74.75 72.1,74.84 72.1,74.95 72.01,75.04 71.83,75.04 71.74,74.95 71.74,74.84 71.65,74.75 71.47,74.75 71.39,74.84 71.39,74.95 71.3,75.04 67.56,75.04 67.47,74.95 67.47,74.84 67.38,74.75 67.2,74.75 67.11,74.84 67.11,74.95 67.02,75.04 65.21,75.04 64.58,75.68 54.62,75.68 54.53,75.59 54.53,75.37 54.45,75.28 54.16,75.28 54.07,75.37 54.07,75.47 53.98,75.55 53.8,75.55 53.71,75.47 53.71,75.37 53.62,75.28 53.45,75.28 53.36,75.37 53.36,75.47 53.27,75.55 53.09,75.55 53,75.47 53,75.37 52.91,75.28 52.73,75.28 52.65,75.37 52.65,75.47 52.56,75.55 52.38,75.55 52.29,75.47 52.29,75.37 52.2,75.28 52.02,75.28 51.93,75.37 51.93,75.47 51.85,75.55 51.67,75.55 51.58,75.47 51.58,75.37 51.49,75.28 51.31,75.28 51.22,75.37 51.22,75.77 51.13,75.86 50.96,75.86 50.87,75.77 50.87,75.37 50.78,75.28 50.03,75.28 49.46,75.86 49.17,75.86 49.08,75.77 49.08,75.65 48.99,75.56 48.81,75.56 48.73,75.65 48.73,75.77 48.64,75.86 48.46,75.86 48.37,75.77 48.37,75.65 48.28,75.56 48.1,75.56 48.01,75.65 48.01,75.77 47.93,75.86 47.75,75.86 47.66,75.77 47.66,75.3 47.57,75.21 47.39,75.21 47.3,75.3 47.3,75.77 47.21,75.86 47.04,75.86 46.95,75.77 46.95,75.53 46.86,75.44 46.68,75.44 46.59,75.53 46.59,75.77 46.5,75.86 45.91,75.86 v1(45.78,75.73)
  BOTTOM w0.079: v2(78.1,73.87) 77.74,73.51 U1.L32
M_B_DQ26: length 41.2
  TOP w0.102: U7.C8 v1(45.07,73.26)
  IN3 w0.089: v2(79.41,72.01) 79.09,71.69 77.35,71.69 76.8,72.25 75.82,72.25 75.75,72.31 75.75,72.53 75.6,72.69 75.42,72.69 75.33,72.6 75.33,71.87 75.24,71.78 75.06,71.78 74.97,71.87 74.97,72.6 74.88,72.69 74.64,72.69 74.5,72.55 74.29,72.55 74.15,72.69 73.93,72.69 73.79,72.55 73.58,72.55 73.44,72.69 73.22,72.69 73.08,72.55 72.86,72.55 72.73,72.69 71.37,72.69 71.28,72.6 71.28,72.42 71.19,72.33 71.01,72.33 70.92,72.42 70.92,72.6 70.83,72.69 67.52,72.69 67.37,72.84 54.51,72.84 54.44,72.92 54.44,73.28 54.35,73.37 54.17,73.37 54.08,73.28 54.08,72.92 53.99,72.83 53.81,72.83 53.72,72.92 53.72,73.28 53.64,73.37 53.46,73.37 53.37,73.28 53.37,72.92 53.28,72.83 52.99,72.83 52.89,72.93 52.89,73.27 52.78,73.37 51.17,73.37 50.95,73.15 47.36,73.15 47.06,72.86 45.47,72.86 v1(45.07,73.26)
  BOTTOM w0.079: U1.N29 79.69,72.29 v2(79.41,72.01)
M_B_DQ27: length 41.4
  TOP w0.102: U7.D7 v1(44.27,74.06)
  IN3 w0.089: v2(80.07,72.01) 79.96,72.01 79.44,71.49 77.21,71.49 76.69,72.01 76.01,72.01 75.54,71.54 72.39,71.54 71.84,72.09 70.86,72.09 70.55,72.4 67.28,72.4 67.16,72.52 50.95,72.52 50.86,72.6 50.86,72.82 50.77,72.91 50.6,72.91 50.51,72.82 50.51,72.6 50.42,72.52 50.24,72.52 50.15,72.6 50.15,72.82 50.06,72.91 49.88,72.91 49.8,72.82 49.8,72.6 49.71,72.52 49.47,72.52 49.12,72.86 47.48,72.86 47.12,72.5 47.12,72.33 46.84,72.06 44.88,72.06 44.67,72.27 44.67,73.66 v1(44.27,74.06)
  BOTTOM w0.079: v2(80.07,72.01) 80.34,72.28 U1.N28
M_B_DQ28: length 39.5
  TOP w0.102: v1(45.83,76.55) 45.07,77.31 45.07,78.06 U7.C2
  IN3 w0.089: v1(45.83,76.55) 46.55,77.27 49.87,77.27 50.33,77.72 53.95,77.72 55.28,76.4 65.09,76.4 65.73,75.77 72.79,75.77 73.03,76.01 75.63,76.01 76.87,74.76 78.8,74.76 79.16,74.41 79.44,74.41 79.99,73.86 v2(80.06,73.86)
  BOTTOM w0.079: U1.L28 80.34,73.57 v2(80.06,73.86)
M_B_DQ29: length 40.4
  TOP w0.102: v1(46.62,76.6) 46.32,76.9 46.32,77.61 U7.A3
  IN3 w0.089: v1(46.62,76.6) 47.05,77.02 47.37,77.02 47.46,76.94 47.46,76.53 47.55,76.44 47.73,76.44 47.82,76.53 47.82,76.94 47.91,77.02 48.09,77.02 48.17,76.94 48.17,76.53 48.26,76.44 48.44,76.44 48.53,76.53 48.53,76.94 48.62,77.02 48.8,77.02 48.89,76.94 48.89,76.53 48.97,76.44 49.15,76.44 49.24,76.53 49.24,76.94 49.33,77.02 49.51,77.02 49.6,76.94 49.6,76.53 49.69,76.44 49.86,76.44 49.95,76.53 49.95,76.94 50.45,77.43 53.83,77.43 55.1,76.16 64.92,76.16 65.56,75.53 72.89,75.53 73.13,75.77 75.54,75.77 76.72,74.59 78.73,74.59 79.35,73.96 v2(79.35,73.84)
  BOTTOM w0.079: v2(79.35,73.84) 79.69,73.5 U1.L29
M_B_DQ30: length 41.3
  TOP w0.102: U7.B8 v1(45.87,73.26)
  IN3 w0.089: v1(45.87,73.26) 46.03,73.1 46.96,73.1 47.31,73.44 50.83,73.44 51.05,73.66 54.68,73.66 54.77,73.57 54.77,73.21 54.86,73.12 55.04,73.12 55.13,73.21 55.13,73.57 55.22,73.66 55.4,73.66 55.49,73.57 55.49,73.21 55.57,73.12 55.75,73.12 55.84,73.21 55.84,73.57 55.93,73.66 57.49,73.66 57.58,73.57 57.58,73.17 57.66,73.08 57.84,73.08 57.93,73.17 57.93,73.57 58.02,73.66 58.2,73.66 58.29,73.57 58.29,73.17 58.38,73.08 58.55,73.08 58.64,73.17 58.64,73.57 58.73,73.66 58.91,73.66 59,73.57 59,73.17 59.09,73.08 59.27,73.08 59.35,73.17 59.35,73.57 59.44,73.66 59.62,73.66 59.71,73.57 59.71,73.27 59.9,73.08 67.47,73.08 67.62,72.93 70.05,72.93 70.14,73.02 70.14,73.23 70.23,73.32 70.41,73.32 70.49,73.23 70.49,73.02 70.58,72.93 70.76,72.93 70.85,73.02 70.85,73.23 70.94,73.32 71.12,73.32 71.21,73.23 71.21,73.02 71.3,72.93 71.47,72.93 71.56,73.02 71.56,73.23 71.65,73.32 71.83,73.32 71.92,73.23 71.92,73.02 72.01,72.93 72.18,72.93 72.27,73.02 72.27,73.1 72.36,73.19 72.54,73.19 72.63,73.1 72.63,73.02 72.72,72.93 72.9,72.93 72.98,73.02 72.98,73.1 73.07,73.19 73.25,73.19 73.34,73.1 73.34,73.02 73.43,72.93 75.7,72.93 76.13,72.49 77.62,72.49 v2(78.03,72.9)
  BOTTOM w0.079: v2(78.03,72.9) 78.39,72.54 U1.N31
M_B_DQ31: length 42.7
  TOP w0.102: U7.C7 v1(45.07,74.06)
  IN3 w0.089: v2(77.18,72.89) 77.01,72.73 76.21,72.73 75.71,73.24 75.58,73.24 75.49,73.33 75.49,73.42 75.4,73.51 75.23,73.51 75.14,73.42 75.14,73.33 75.05,73.24 74.87,73.24 74.78,73.33 74.78,73.42 74.69,73.51 74.51,73.51 74.43,73.42 74.43,73.33 74.34,73.24 73.72,73.24 73.45,73.51 72.48,73.51 72.43,73.56 69.88,73.56 69.75,73.43 69.75,73.26 69.66,73.17 69.47,73.17 69.39,73.24 69.39,73.49 69.33,73.56 69.15,73.56 69.06,73.47 69.06,73.26 68.97,73.17 68.8,73.17 68.71,73.26 68.71,73.47 68.62,73.56 68.44,73.56 68.35,73.47 68.35,73.26 68.26,73.17 68.09,73.17 68,73.26 68,73.47 67.91,73.56 67.73,73.56 67.64,73.47 67.64,73.41 67.55,73.32 67.37,73.32 67.29,73.41 67.29,73.47 67.2,73.56 67.02,73.56 66.93,73.47 66.93,73.41 66.84,73.32 66.66,73.32 66.57,73.41 66.57,73.47 66.49,73.56 66.31,73.56 66.22,73.47 66.22,73.41 66.13,73.32 65.95,73.32 65.86,73.41 65.86,73.47 65.77,73.56 65.6,73.56 65.51,73.47 65.51,73.41 65.42,73.32 65.24,73.32 65.15,73.41 65.15,73.47 65.06,73.56 64.88,73.56 64.8,73.47 64.8,73.41 64.71,73.32 64.53,73.32 64.44,73.41 64.44,73.47 64.35,73.56 64.11,73.56 63.88,73.32 60.08,73.32 59.97,73.43 59.97,73.72 59.64,74.04 59.64,74.4 59.56,74.48 59.38,74.48 59.29,74.4 59.29,74.04 59.2,73.95 59.02,73.95 58.93,74.04 58.93,74.4 58.84,74.48 58.67,74.48 58.58,74.4 58.58,74.04 58.49,73.95 58.31,73.95 58.22,74.04 58.22,74.4 58.13,74.48 57.96,74.48 57.87,74.4 57.87,74.04 57.78,73.95 50.92,73.95 50.71,73.73 50.47,73.73 50.38,73.82 50.38,73.98 50.29,74.07 50.11,74.07 50.02,73.98 50.02,73.82 49.93,73.73 49.76,73.73 49.67,73.82 49.67,73.98 49.58,74.07 49.4,74.07 49.31,73.98 49.31,73.82 49.22,73.73 49.04,73.73 48.96,73.82 48.96,73.93 48.87,74.02 48.69,74.02 48.6,73.93 48.6,73.82 48.51,73.73 46.95,73.73 46.86,73.65 46.86,73.43 46.77,73.34 46.6,73.34 46.51,73.43 46.51,73.76 46.35,73.91 45.21,73.91 v1(45.07,74.06)
  BOTTOM w0.079: U1.N32 77.57,72.49 v2(77.18,72.89)
M_B_DQ32: length 43.9
  TOP w0.102: U5.C2 v1(45.07,56.63)
  IN3 w0.089: v1(45.07,56.63) 45.14,56.63 45.52,57.01 45.68,57.01 45.7,57.03 46.84,57.03 47.31,56.55 47.31,55.45 48.56,54.2 49.42,54.2 50.52,53.1 58.64,53.1 60.12,54.59 64.53,54.59 65.38,55.45 65.38,55.7 65.87,56.18 65.87,56.72 66.33,57.19 68.82,57.19 70.55,58.91 71.99,58.91 73.52,60.44 73.8,60.44 74.61,61.25 74.61,61.96 76.07,63.42 79.52,63.42 v2(80.02,62.92)
  BOTTOM w0.079: v2(80.02,62.92) 79.69,62.6 U1.AJ29
M_B_DQ33: length 43.7
  TOP w0.102: v1(44.3,55.83) 44.27,55.83 U5.D3
  IN3 w0.089: v2(79.37,62.92) 78.78,62.34 76,62.34 75.3,61.63 75.3,61.18 74.23,60.11 74.23,59.39 73.98,59.14 73.05,59.14 71.95,58.04 71.39,58.04 69.07,55.73 66.44,55.73 66.11,55.4 66.11,54.71 65.26,53.87 60.46,53.87 58.98,52.38 54.38,52.38 53.69,51.69 50.9,51.69 49.12,53.47 48.23,53.47 46.3,55.41 44.72,55.41 v1(44.3,55.83)
  BOTTOM w0.079: v2(79.37,62.92) 79.04,62.6 U1.AJ30
M_B_DQ34: length 43.7
  TOP w0.102: U5.C7 v1(45.1,53.46)
  IN3 w0.089: v1(45.1,53.46) 45.23,53.32 45.4,53.32 45.61,53.11 46.91,53.11 48.16,51.85 48.77,51.85 50.5,50.13 50.66,50.13 50.77,50.24 50.77,50.41 50.86,50.5 51.08,50.5 51.17,50.41 51.17,50.24 51.3,50.11 51.6,50.11 51.73,50.24 52,50.24 52.13,50.11 53,50.11 53.39,50.5 54.62,50.5 54.78,50.66 54.78,50.97 55,51.19 57.48,51.19 57.57,51.1 57.57,50.89 57.66,50.8 57.84,50.8 57.92,50.89 57.92,51.1 58.01,51.19 58.19,51.19 58.28,51.1 58.28,50.89 58.37,50.8 58.55,50.8 58.64,50.89 58.64,51.1 58.72,51.19 59.47,51.19 60.62,52.34 61.63,52.34 61.72,52.42 61.72,52.56 61.81,52.65 61.99,52.65 62.08,52.56 62.08,52.42 62.17,52.34 62.34,52.34 62.43,52.42 62.43,52.56 62.52,52.65 62.7,52.65 62.79,52.56 62.79,52.42 62.88,52.34 63.12,52.34 63.43,52.65 65.73,52.65 66.24,53.15 69.07,53.15 69.63,53.72 69.63,53.87 70.89,55.13 70.89,55.25 70.76,55.38 70.76,55.51 70.89,55.63 71.01,55.63 71.14,55.51 71.27,55.51 71.39,55.63 71.39,55.76 71.27,55.89 71.27,56.01 71.39,56.14 71.52,56.14 71.65,56.01 71.77,56.01 71.87,56.11 72.19,56.11 73.72,57.64 73.82,57.64 75.21,59.03 75.21,59.75 76.03,60.58 76.76,60.58 77.21,61.03 v2(77.42,61.03)
  BOTTOM w0.079: U1.AM32 77.74,60.71 v2(77.42,61.03)
M_B_DQ35: length 44.3
  TOP w0.102: U5.D7 44.41,53.58 v1(44.47,53.58)
  IN3 w0.089: v2(78.07,61.04) 77.96,61.04 77.54,60.62 77.06,60.62 76.85,60.4 76.13,60.4 75.39,59.65 75.39,58.94 73.86,57.42 73.74,57.42 72.02,55.69 71.84,55.69 69.97,53.81 69.97,53.67 69.21,52.91 66.35,52.91 66.23,52.79 66.23,52.55 66.09,52.41 63.53,52.41 63.18,52.06 61.53,52.06 61.42,51.94 61.29,51.94 61.17,52.06 60.69,52.06 59.57,50.94 59.04,50.94 58.85,50.76 58.85,50.22 58.72,50.09 58.48,50.09 58.39,50.18 58.39,50.41 58.3,50.5 58.13,50.5 58.04,50.41 58.04,50.18 57.95,50.09 57.77,50.09 57.68,50.18 57.68,50.41 57.59,50.5 57.42,50.5 57.33,50.41 57.33,50.18 57.24,50.09 57.06,50.09 56.97,50.18 56.97,50.25 56.88,50.34 56.7,50.34 56.62,50.25 56.62,50.18 56.53,50.09 56.35,50.09 56.26,50.18 56.26,50.25 56.17,50.34 55.99,50.34 55.9,50.25 55.9,50.18 55.81,50.09 55.64,50.09 55.55,50.18 55.55,50.24 55.46,50.33 55.23,50.33 55.03,50.13 54.88,50.13 54.74,50.26 53.49,50.26 53.1,49.87 50.42,49.87 48.67,51.61 48.06,51.61 46.86,52.81 45.49,52.81 45.27,53.03 44.86,53.03 44.47,53.42 v1(44.47,53.58)
  BOTTOM w0.079: v2(78.07,61.04) 78.39,60.71 U1.AM31
M_B_DQ36: length 44.5
  TOP w0.102: v1(45.07,52.63) 45.47,52.23 U5.B8
  IN3 w0.089: v2(78.72,61.1) 78.72,60.86 78.52,60.67 77.84,60.67 77.61,60.44 77.14,60.44 76.92,60.22 76.24,60.22 75.61,59.6 75.61,58.92 73.91,57.21 73.79,57.21 70.31,53.73 70.31,53.6 69.38,52.67 66.72,52.67 66.21,52.16 63.68,52.16 63.29,51.78 61.61,51.78 61.47,51.64 61.23,51.64 61.1,51.78 60.75,51.78 59.85,50.88 59.85,50.77 60.16,50.46 60.16,50.33 60.07,50.24 59.89,50.24 59.43,50.7 59.33,50.7 59.18,50.56 59.18,50.47 59.54,50.1 59.54,49.98 59.42,49.85 59.29,49.85 59.12,50.02 58.99,50.02 58.82,49.85 54.8,49.85 54.66,49.99 54.41,49.99 54.32,49.9 54.32,49.71 54.23,49.62 54.05,49.62 53.96,49.71 53.96,49.93 53.87,50.02 53.66,50.02 53.57,49.93 53.57,49.69 53.5,49.62 50.32,49.62 48.57,51.37 47.96,51.37 46.81,52.52 45.18,52.52 v1(45.07,52.63)
  BOTTOM w0.079: v2(78.72,61.1) 79.04,60.78 U1.AM30
M_B_DQ37: length 44.8
  TOP w0.102: U5.C8 v1(45.07,51.83)
  IN3 w0.089: v1(45.07,51.83) 45.07,52.11 45.19,52.23 46.76,52.23 47.86,51.13 48.47,51.13 50.22,49.38 54.71,49.38 54.94,49.61 57.46,49.61 57.55,49.52 57.55,49.44 57.64,49.35 57.82,49.35 57.91,49.44 57.91,49.52 58,49.61 58.17,49.61 58.26,49.52 58.26,49.44 58.35,49.35 58.53,49.35 58.62,49.44 58.62,49.52 58.71,49.61 58.89,49.61 58.97,49.52 58.97,49.44 59.06,49.35 59.24,49.35 59.33,49.44 59.33,49.52 59.42,49.61 59.79,49.61 61.04,50.86 61.04,50.99 60.72,51.31 60.72,51.41 60.85,51.53 61,51.53 61.29,51.24 61.42,51.24 61.71,51.54 63.39,51.54 63.78,51.92 66.38,51.92 66.89,52.43 69.65,52.43 70.65,53.43 70.65,53.8 73.88,57.03 73.98,57.03 75.87,58.92 75.87,59.44 76.45,60.02 76.97,60.02 77.21,60.26 77.68,60.26 77.91,60.49 78.83,60.49 78.89,60.55 79.41,60.55 79.53,60.67 79.53,60.94 v2(79.37,61.1)
  BOTTOM w0.079: v2(79.37,61.1) 79.69,60.78 U1.AM29
M_B_DQ38: length 41.4
  TOP w0.102: U5.A3 v1(46.67,55.83)
  IN3 w0.089: v1(46.67,55.83) 46.67,55.38 48.33,53.71 49.22,53.71 51,51.94 53.59,51.94 54.28,52.62 58.84,52.62 60.32,54.11 65.16,54.11 65.87,54.81 65.87,55.5 66.39,56.02 68.95,56.02 69.43,56.5 69.43,56.62 69.29,56.77 69.29,56.9 69.41,57.02 69.53,57.02 69.68,56.87 69.81,56.87 71.26,58.33 71.97,58.33 73.57,59.93 73.8,59.93 75.12,61.25 75.12,61.85 76.22,62.95 76.72,62.95 77.15,62.52 78.53,62.52 78.72,62.7 v2(78.72,62.92)
  BOTTOM w0.079: v2(78.72,62.92) 78.39,62.6 U1.AJ31
M_B_DQ39: length 42.7
  TOP w0.102: U5.C3 v1(45.07,55.83)
  IN3 w0.089: v2(78.07,62.92) 77.75,63.24 76.26,63.24 74.86,61.84 74.86,61.25 73.8,60.18 73.54,60.18 71.98,58.62 70.67,58.62 70.53,58.48 70.53,58.36 70.64,58.24 70.64,58.12 70.52,57.99 70.39,57.99 70.28,58.11 70.15,58.11 70.03,57.98 70.03,57.85 70.14,57.74 70.14,57.62 70.01,57.49 69.89,57.49 69.77,57.6 69.65,57.6 68.94,56.89 66.45,56.89 66.16,56.6 66.16,56.13 65.63,55.6 65.63,54.91 65.06,54.35 60.22,54.35 58.74,52.86 50.42,52.86 49.32,53.95 48.46,53.95 47.07,55.35 47.07,56.1 46.94,56.23 45.26,56.23 45.07,56.04 v1(45.07,55.83)
  BOTTOM w0.079: v2(78.07,62.92) 77.74,62.6 U1.AJ32
M_B_DQ40: length 50.1
  TOP w0.102: U5.G2 v1(41.87,56.63)
  IN3 w0.089: v1(41.87,56.63) 41.87,56.24 41.96,56.16 43.57,56.16 43.85,55.88 43.85,52.46 44.88,51.43 46.84,51.43 47.53,50.74 48.31,50.74 50.06,48.99 54.07,48.99 54.49,48.58 57.71,48.58 57.79,48.67 57.79,48.81 57.88,48.9 58.06,48.9 58.15,48.81 58.15,48.67 58.24,48.58 58.42,48.58 58.51,48.67 58.51,48.81 58.59,48.9 58.77,48.9 58.86,48.81 58.86,48.67 58.95,48.58 59.31,48.58 61.87,51.14 63.49,51.14 63.62,51.01 65.31,51.01 65.77,51.47 68.95,51.47 71.35,53.87 71.35,54.25 73.63,56.53 74.69,56.53 75.75,57.59 75.75,58.43 77.18,59.85 77.74,59.85 77.91,59.68 78.32,59.68 v2(78.72,59.28)
  BOTTOM w0.079: U1.AR31 78.39,58.95 v2(78.72,59.28)
M_B_DQ41: length 49.9
  TOP w0.102: U5.H2 v1(41.07,56.63)
  IN3 w0.089: v1(41.07,56.63) 41.07,56.4 41.6,55.87 43.45,55.87 43.56,55.76 43.56,52.34 44.07,51.83 44.07,51.64 44.28,51.43 44.44,51.43 44.67,51.2 44.67,50.75 44.92,50.49 48.21,50.49 49.96,48.75 53.97,48.75 54.38,48.34 59.41,48.34 61.97,50.9 63.32,50.9 63.49,50.72 65.36,50.72 65.87,51.23 69.01,51.23 71.55,53.77 71.55,54.2 73.7,56.35 74.76,56.35 75.98,57.57 75.98,58.41 77.25,59.68 77.66,59.68 78.06,59.28 v2(78.07,59.28)
  BOTTOM w0.076: U1.AR32 77.74,58.95 v2(78.07,59.28)
M_B_DQ42: length 52.9
  TOP w0.102: U5.H8 41.13,51.77 41.13,51.24 41.34,51.04 v1(41.34,50.28)
  IN3 w0.089: v1(41.34,50.28) 41.4,50.34 41.8,50.34 42.1,50.04 42.1,49.84 41.79,49.53 41.79,49.39 42.24,48.95 42.36,48.95 42.44,49.03 42.63,49.03 42.7,48.95 42.7,48.79 42.61,48.7 42.61,48.57 42.74,48.44 42.86,48.44 42.94,48.52 43.13,48.52 43.23,48.42 43.23,48.31 43.12,48.19 43.12,48.07 43.24,47.94 43.37,47.94 43.45,48.02 43.63,48.02 43.73,47.92 43.73,47.81 43.62,47.69 43.62,47.56 43.83,47.36 44.12,47.36 44.21,47.45 44.21,47.57 44.3,47.66 44.47,47.66 44.56,47.57 44.56,47.45 44.65,47.36 47.5,47.36 48.82,46.04 49.44,46.04 50.22,45.26 54.53,45.26 55.12,45.85 55.76,45.85 55.85,45.76 55.85,45.35 55.94,45.26 56.11,45.26 56.2,45.35 56.2,45.76 56.29,45.85 56.47,45.85 56.56,45.76 56.56,45.35 56.65,45.26 56.83,45.26 56.91,45.35 56.91,45.76 57,45.85 60.54,45.85 62.26,47.57 66.87,47.57 67.58,48.28 67.77,48.28 67.87,48.38 68.38,48.38 68.59,48.59 70.33,48.59 72.32,50.59 72.32,51.48 76.03,55.18 76.62,55.18 77.06,55.62 77.06,56.23 77.91,57.09 78.65,57.09 78.78,57.22 v2(78.78,57.45)
  BOTTOM w0.079: U1.AV30 79.04,57.22 78.81,57.45 v2(78.78,57.45)
M_B_DQ43: length 53.5
  TOP w0.102: v1(41.07,52.63) 40.27,52.63 U5.J7
  IN3 w0.089: v1(41.07,52.63) 41.07,51.41 40.94,51.27 40.94,49.82 43.69,47.06 47.45,47.06 48.72,45.8 49.34,45.8 50.12,45.02 57.07,45.02 57.16,45.11 57.16,45.52 57.24,45.61 57.42,45.61 57.51,45.52 57.51,45.11 57.6,45.02 57.78,45.02 57.87,45.11 57.87,45.52 57.96,45.61 58.13,45.61 58.22,45.52 58.22,45.11 58.31,45.02 58.49,45.02 58.58,45.11 58.58,45.52 58.67,45.61 60.64,45.61 62.31,47.28 66.99,47.28 67.7,47.99 67.98,47.99 68.08,48.09 68.5,48.09 68.71,48.3 70.29,48.3 72.5,50.51 72.5,51.4 74.75,53.65 75.05,53.65 76.38,54.98 76.67,54.98 77.28,55.58 77.28,56.2 77.99,56.91 78.82,56.91 v2(79.37,57.46)
  BOTTOM w0.089: U1.AV29 79.69,57.13 v2(79.37,57.46)
M_B_DQ44: length 51.5
  TOP w0.102: U5.H3 v1(41.07,55.83)
  IN3 w0.089: v2(79.37,59.28) 79.29,59.28 78.93,58.91 77.58,58.91 74.78,56.11 73.71,56.11 71.8,54.2 71.8,53.72 69.07,50.99 65.97,50.99 65.44,50.47 65.34,50.43 63.37,50.43 63.14,50.66 62.07,50.66 59.51,48.1 54.89,48.1 54.6,47.81 51.33,47.81 51.24,47.9 51.24,48.42 51.15,48.51 50.97,48.51 50.89,48.42 50.89,47.9 50.8,47.81 50.55,47.81 48.11,50.25 44.49,50.25 44.11,50.63 44.1,50.63 43.87,50.86 43.87,50.87 43.27,51.47 43.27,55.48 43.18,55.57 41.33,55.57 v1(41.07,55.83)
  BOTTOM w0.079: v2(79.37,59.28) 79.04,58.95 U1.AR30
M_B_DQ45: length 52.3
  TOP w0.102: U5.J3 40.83,55.27 40.83,55 v1(40.96,54.88)
  IN3 w0.089: v2(80.02,59.28) 79.47,58.74 77.68,58.74 74.15,55.21 73.57,55.21 69.11,50.75 66.07,50.75 65.46,50.14 63.25,50.14 63.02,50.37 62.2,50.37 59.68,47.85 54.99,47.85 54.7,47.57 50.45,47.57 48.01,50.01 44.31,50.01 43.99,50.34 43.98,50.34 43.58,50.74 43.58,50.75 42.97,51.36 42.97,55.22 42.91,55.28 41.12,55.28 40.96,55.12 v1(40.96,54.88)
  BOTTOM w0.079: U1.AR29 79.69,58.95 v2(80.02,59.28)
M_B_DQ46: length 51.1
  TOP w0.102: U5.H7 v1(41.07,53.43)
  IN3 w0.089: v1(41.07,53.43) 41.41,53.43 41.47,53.37 41.47,50.78 41.62,50.63 41.85,50.63 44.24,48.25 44.53,48.25 44.62,48.33 44.62,48.39 44.71,48.48 44.88,48.48 44.97,48.39 44.97,48.33 45.06,48.25 45.24,48.25 45.33,48.33 45.33,48.39 45.42,48.48 45.59,48.48 45.68,48.39 45.68,48.33 45.77,48.25 45.95,48.25 46.04,48.33 46.04,48.39 46.13,48.48 46.31,48.48 46.39,48.39 46.39,48.33 46.48,48.25 46.8,48.25 46.89,48.33 46.89,48.66 46.98,48.75 47.16,48.75 47.25,48.66 47.25,48.33 47.33,48.25 48.09,48.25 50.29,46.04 50.53,46.04 50.62,46.13 50.62,46.28 50.71,46.37 50.89,46.37 50.98,46.28 50.98,46.13 51.06,46.04 53.67,46.04 53.96,46.33 57.41,46.33 57.5,46.42 57.5,46.57 57.59,46.66 57.76,46.66 57.85,46.57 57.85,46.42 57.94,46.33 58.12,46.33 58.21,46.42 58.21,46.57 58.3,46.66 58.48,46.66 58.56,46.57 58.56,46.42 58.65,46.33 58.83,46.33 58.92,46.42 58.92,46.57 59.01,46.66 59.19,46.66 59.28,46.57 59.28,46.42 59.36,46.33 59.54,46.33 59.63,46.42 59.63,46.57 59.72,46.66 59.9,46.66 59.99,46.57 59.99,46.42 60.08,46.33 60.32,46.33 62.15,48.16 65.28,48.16 65.98,48.86 67.53,48.86 67.63,48.96 68.14,48.96 68.4,49.22 69.49,49.22 70.43,50.16 70.43,50.65 71.74,51.95 72.3,51.95 74.64,54.29 74.64,54.6 v2(77.49,57.45)
  BOTTOM w0.079: U1.AV32 77.74,57.2 v2(77.49,57.45)
M_B_DQ47: length 52
  TOP w0.102: U5.F7 42.27,52.98 42.66,52.59 42.66,49.77 v1(42.39,49.5)
  IN3 w0.089: v2(78.11,57.46) 78.03,57.46 77.61,57.04 77.33,57.04 76.88,56.6 76.88,55.71 76.54,55.37 75.66,55.37 74.81,54.53 74.81,54.22 72.15,51.55 72.15,50.66 70.37,48.88 70.06,48.88 69.82,49.12 69.75,49.12 69.51,48.88 68.47,48.88 68.26,48.67 67.75,48.67 67.65,48.57 67.45,48.57 67.31,48.42 67.09,48.42 66.95,48.57 66.1,48.57 65.77,48.24 65.77,47.94 65.7,47.87 62.21,47.87 60.44,46.09 54.7,46.09 54.52,45.91 54.52,45.6 54.43,45.5 54.18,45.5 54.09,45.59 54.09,45.71 54.01,45.8 53.83,45.8 53.74,45.71 53.74,45.59 53.65,45.5 53.47,45.5 53.38,45.59 53.38,45.71 53.29,45.8 53.12,45.8 53.03,45.71 53.03,45.59 52.94,45.5 52.76,45.5 52.67,45.59 52.67,45.71 52.58,45.8 52.41,45.8 52.32,45.71 52.32,45.59 52.23,45.5 52.05,45.5 51.96,45.59 51.96,45.71 51.87,45.8 51.69,45.8 51.61,45.71 51.61,45.59 51.52,45.5 51.34,45.5 51.25,45.59 51.25,45.71 51.16,45.8 50.98,45.8 50.89,45.71 50.89,45.59 50.81,45.5 50.49,45.5 48.04,47.95 46.85,47.95 46.76,47.87 46.76,47.69 46.67,47.6 46.49,47.6 46.41,47.69 46.41,47.87 46.32,47.95 46.14,47.95 46.05,47.87 46.05,47.69 45.96,47.6 45.78,47.6 45.69,47.69 45.69,47.87 45.61,47.95 45.43,47.95 45.34,47.87 45.34,47.69 45.25,47.6 45.07,47.6 44.98,47.69 44.98,47.87 44.89,47.95 44.11,47.95 42.56,49.5 v1(42.39,49.5)
  BOTTOM w0.079: U1.AV31 78.39,57.18 v2(78.11,57.46)
M_B_DQ48: length 47.5
  TOP w0.102: U4.H2 41.07,44.28 v1(41.07,44.31)
  IN3 w0.089: v1(41.07,44.31) 41.07,45.31 41.53,45.77 46.5,45.77 46.59,45.68 46.59,45.25 46.68,45.16 46.86,45.16 46.94,45.25 46.94,45.68 47.03,45.77 47.21,45.77 47.3,45.68 47.3,45.25 47.39,45.16 49.08,45.16 49.86,44.39 61.88,44.39 63.65,46.16 70.72,46.16 73.01,48.45 73.01,48.88 73.98,49.85 73.98,50.15 73.85,50.28 73.85,50.79 74.92,51.86 74.92,52.99 76.55,54.62 76.92,54.62 77.93,55.63 v2(78.07,55.63)
  BOTTOM w0.079: v2(78.07,55.63) 77.74,55.31 U1.BA32
M_B_DQ49: length 48.4
  TOP w0.102: U4.H3 v1(41.07,42.68)
  IN3 w0.089: v2(78.07,54.72) 77.66,54.72 77.15,54.22 76.65,54.22 75.27,52.84 75.27,51.66 74.86,51.25 74.86,50.23 73.37,48.73 73.37,47.98 71.03,45.64 63.82,45.64 62.03,43.85 58.05,43.85 57.45,43.25 50.3,43.25 49.44,44.12 48.88,44.12 48.79,44.21 48.79,44.59 48.7,44.68 48.53,44.68 48.44,44.59 48.44,44.21 48.35,44.12 48.17,44.12 48.08,44.21 48.08,44.59 47.99,44.68 47.81,44.68 47.73,44.59 47.73,44.21 47.64,44.12 47.39,44.12 47.27,44.25 47.27,44.64 47.23,44.68 42.9,44.68 42.1,43.88 41.7,43.88 41.47,43.65 41.47,43.31 41.46,43.31 41.46,43.09 41.07,42.7 v1(41.07,42.68)
  BOTTOM w0.079: v2(78.07,54.72) 78.39,55.05 U1.BA31
M_B_DQ50: length 50.1
  TOP w0.102: U4.F7 v1(41.87,40.28)
  IN3 w0.089: v2(78.72,52.9) 78.34,53.27 77.9,53.27 77.66,53.03 77.66,52.67 76.77,51.78 76.77,51.28 76.13,50.65 76.13,49.78 75.17,48.81 75.17,48.1 72.68,45.61 72.68,45.23 71.31,43.86 67.39,43.86 66.3,42.78 64.88,42.78 63.54,41.43 61.36,41.43 61.27,41.52 61.27,41.91 61.18,42 61,42 60.91,41.91 60.91,41.52 60.82,41.43 60.64,41.43 60.56,41.52 60.56,41.91 60.47,42 60.29,42 60.2,41.91 60.2,41.52 60.11,41.43 59.93,41.43 59.84,41.52 59.84,41.91 59.76,42 59.58,42 59.49,41.91 59.49,41.52 59.4,41.43 58.97,41.43 57.14,39.61 54.97,39.61 54.66,39.91 51.13,39.91 49.49,41.55 48.75,41.55 48.27,42.04 44.26,42.04 43.79,41.57 42.88,41.57 41.87,40.56 v1(41.87,40.28)
  BOTTOM w0.079: v2(78.72,52.9) 78.39,53.22 U1.BD31
M_B_DQ51: length 50.1
  TOP w0.102: U4.J7 v1(40.27,40.28)
  IN3 w0.089: v2(78.07,53.81) 77.94,53.81 77.28,53.15 77.28,52.82 76.07,51.61 76.07,51.23 75.78,50.93 75.78,49.93 74.81,48.96 74.81,48.25 71.02,44.45 66.51,44.45 66.42,44.36 66.42,43.81 66.33,43.72 66.16,43.72 66.07,43.81 66.07,44.36 65.98,44.45 65.8,44.45 65.71,44.36 65.71,43.99 65.62,43.9 65.45,43.9 65.36,43.99 65.36,44.36 65.27,44.45 65,44.45 63.21,42.66 59.23,42.66 57.58,41.01 55.04,41.01 54.53,40.5 51.37,40.5 48.96,42.91 46.7,42.91 46.3,42.52 43.92,42.52 43.55,42.15 42.37,42.15 40.5,40.28 v1(40.27,40.28)
  BOTTOM w0.079: U1.BD32 77.74,53.49 v2(78.07,53.81)
M_B_DQ52: length 50.2
  TOP w0.102: U4.J3 40.93,42.02 v1(41.08,42.02)
  IN3 w0.089: v2(78.72,55.63) 78.35,56 77.92,56 77.46,55.54 77.46,55.51 76.75,54.8 76.46,54.8 74.74,53.07 74.74,51.93 74.23,51.42 73.98,51.42 70.22,47.66 69.12,47.66 67.86,46.4 63.55,46.4 62.88,45.73 61.67,45.73 60.57,44.63 49.96,44.63 49.18,45.4 48.56,45.4 47.9,46.06 41.46,46.06 40.68,45.28 40.68,44.48 40.67,44.47 40.67,42.51 40.68,42.51 40.68,42.43 v1(41.08,42.02)
  BOTTOM w0.079: v2(78.72,55.63) 79.04,55.31 U1.BA30
M_B_DQ53: length 50.9
  TOP w0.102: U4.G2 v1(41.07,43.48)
  IN3 w0.089: v1(41.07,43.48) 41.07,43.66 41.46,44.06 41.46,44.13 41.47,44.14 41.47,44.47 41.46,44.48 41.46,45.24 41.7,45.48 45.45,45.48 45.53,45.4 45.53,45.01 45.62,44.92 45.83,44.92 45.93,45.02 45.93,45.42 46.05,45.53 46.28,45.53 46.35,45.46 46.35,45.15 46.58,44.92 48.98,44.92 50.35,43.55 50.69,43.55 50.78,43.64 50.78,43.84 50.87,43.93 51.04,43.93 51.13,43.84 51.13,43.64 51.22,43.55 53.97,43.55 54.06,43.64 54.06,43.86 54.15,43.95 54.33,43.95 54.41,43.86 54.41,43.64 54.5,43.55 57.26,43.55 57.86,44.14 61.98,44.14 63.75,45.92 70.89,45.92 73.19,48.21 73.19,48.81 74.66,50.28 74.66,51.3 75.09,51.73 75.09,52.92 76.62,54.44 77.13,54.44 77.91,55.23 79.06,55.23 79.37,55.54 v2(79.37,55.63)
  BOTTOM w0.089: U1.BA29 79.69,55.31 v2(79.37,55.63)
M_B_DQ54: length 51.3
  TOP w0.102: U4.H8 v1(41.07,39.48)
  IN3 w0.089: v1(41.07,39.48) 41.47,39.88 42.04,39.88 42.27,40.11 42.27,40.54 42.41,40.68 43.08,40.68 43.62,41.22 43.86,41.22 44.44,41.79 48.17,41.79 48.65,41.31 49.32,41.31 51,39.63 51,39.34 51.29,39.05 51.92,39.05 52.49,39.62 54.54,39.62 54.85,39.32 57.26,39.32 58.7,40.75 59.09,40.75 59.18,40.84 59.18,41.05 59.26,41.14 59.44,41.14 59.53,41.05 59.53,40.84 59.62,40.75 59.8,40.75 59.89,40.84 59.89,41.05 59.98,41.14 60.15,41.14 60.24,41.05 60.24,40.84 60.33,40.75 60.51,40.75 60.6,40.84 60.6,41.05 60.69,41.14 60.86,41.14 60.95,41.05 60.95,40.84 61.04,40.75 61.22,40.75 61.31,40.84 61.31,41.05 61.4,41.14 63.66,41.14 65,42.49 66.42,42.49 67.51,43.57 71.44,43.57 73.08,45.22 73.08,45.76 75.35,48.03 75.35,48.74 76.31,49.71 76.31,50.57 76.95,51.21 76.95,51.65 77.83,52.53 78.99,52.53 v2(79.37,52.9)
  BOTTOM w0.089: v2(79.37,52.9) 79.69,53.22 U1.BD29
M_B_DQ55: length 51.2
  TOP w0.102: U4.H7 v1(41.07,40.28)
  IN3 w0.089: v1(41.07,40.28) 41.18,40.28 42.76,41.86 43.67,41.86 44.09,42.28 46.68,42.28 46.77,42.37 46.77,42.58 46.86,42.67 47.04,42.67 47.13,42.58 47.13,42.37 47.22,42.28 47.39,42.28 47.48,42.37 47.48,42.58 47.57,42.67 47.75,42.67 47.84,42.58 47.84,42.37 47.93,42.28 48.1,42.28 48.19,42.37 48.19,42.58 48.28,42.67 48.86,42.67 50.31,41.22 51.32,40.21 54.65,40.21 55.16,40.71 55.56,40.71 55.65,40.63 55.65,40.56 55.74,40.47 55.92,40.47 56,40.56 56,40.63 56.09,40.71 56.27,40.71 56.36,40.63 56.36,40.56 56.45,40.47 56.63,40.47 56.72,40.56 56.72,40.63 56.8,40.71 57.7,40.71 59.41,42.42 61.29,42.42 61.98,41.72 63.42,41.72 64.71,43.02 66.13,43.02 67.27,44.16 71.19,44.16 72.29,45.25 72.29,45.47 74.99,48.17 74.99,48.89 75.96,49.85 75.96,50.72 76.59,51.35 76.59,51.85 77.48,52.74 77.48,53.1 77.83,53.45 79.18,53.45 79.37,53.64 v2(79.37,53.81)
  BOTTOM w0.089: U1.BD30 79.04,53.49 v2(79.37,53.81)
M_B_DQ56: length 47.9
  TOP w0.102: v1(46.67,40.41) 46.62,40.46 46.62,42.73 U4.A3
  IN3 w0.089: v2(78.72,51.99) 78.72,51.97 78.37,51.62 77.84,51.62 77.48,51.27 77.48,50.99 76.85,50.35 76.85,49.46 75.88,48.5 75.88,47.8 73.95,45.87 73.95,44.77 71.57,42.39 68.76,42.39 67.99,41.62 67.22,41.62 66.65,41.05 65.23,41.05 64.15,39.96 62.1,39.96 61.71,39.57 59.19,39.57 57.48,37.86 56.71,37.86 56.62,37.77 56.62,37.74 56.54,37.65 56.36,37.65 56.27,37.74 56.27,37.77 56.18,37.86 56,37.86 55.91,37.77 55.91,37.74 55.82,37.65 55.65,37.65 55.56,37.74 55.56,37.77 55.47,37.86 55.29,37.86 55.2,37.77 55.2,37.74 55.11,37.65 54.94,37.65 54.85,37.74 54.85,37.77 54.76,37.86 54.46,37.86 53.78,37.18 51.3,37.18 50.85,37.64 50.72,37.64 50.59,37.5 50.46,37.5 50.34,37.63 50.34,37.76 50.55,37.97 50.55,38.12 50.45,38.22 50.3,38.22 50.09,38.01 49.96,38.01 49.83,38.13 49.83,38.26 50.05,38.47 50.05,38.63 49.92,38.75 49.83,38.75 49.58,38.51 49.46,38.51 49.33,38.64 49.33,38.76 49.63,39.06 49.63,39.33 49.08,39.88 47.54,39.88 47.02,40.41 v1(46.67,40.41)
  BOTTOM w0.079: v2(78.72,51.99) 78.39,51.66 U1.BG31
M_B_DQ57: length 47.8
  TOP w0.102: U4.C3 44.67,41.23 45.49,40.41 v1(45.87,40.41)
  IN3 w0.089: v2(78.07,51.99) 77.95,51.99 77.3,51.34 77.3,51.06 76.67,50.43 76.67,49.54 75.7,48.57 75.7,47.88 73.67,45.85 73.67,44.93 71.42,42.68 67.88,42.68 66.53,41.34 65.11,41.34 64.03,40.25 61.98,40.25 61.59,39.86 59.07,39.86 57.31,38.11 54.8,38.11 54.18,38.73 53.41,38.73 53.33,38.64 53.33,38.43 53.41,38.34 53.69,38.34 53.96,38.07 53.96,37.78 53.66,37.48 51.42,37.48 51.14,37.75 51.14,37.94 50.12,38.97 50.12,39.26 49.14,40.23 47.7,40.23 47.05,40.88 46.34,40.88 v1(45.87,40.41)
  BOTTOM w0.079: v2(78.07,51.99) 77.74,51.66 U1.BG32
M_B_DQ58: length 47.4
  TOP w0.102: U4.B8 v1(45.87,38.68)
  IN3 w0.089: v2(78.07,49.25) 78.07,48.79 75.44,46.17 75.44,44.56 74.24,43.36 74.24,42.96 72.16,40.88 71.29,40.88 70.68,40.28 69.48,40.28 69.39,40.37 69.39,40.55 69.3,40.64 69.12,40.64 69.04,40.55 69.04,40.37 68.95,40.28 68.76,40.28 68.54,40.06 68.54,39.94 68.7,39.78 68.7,39.66 68.57,39.53 68.45,39.53 68.29,39.69 68.17,39.69 67.89,39.41 66,39.41 64.3,37.71 60.2,37.71 60.11,37.8 60.11,38 60.02,38.09 59.84,38.09 59.75,38 59.75,37.8 59.67,37.71 59.43,37.71 57.02,35.3 54.81,35.3 54.54,35.57 54.2,35.57 53.92,35.3 51,35.3 50.91,35.39 50.91,35.55 50.82,35.63 50.64,35.63 50.55,35.55 50.55,35.39 50.47,35.3 50.29,35.3 50.2,35.39 50.2,35.55 50.11,35.63 49.93,35.63 49.84,35.55 49.84,35.39 49.75,35.3 49.46,35.3 49.21,35.55 49.21,35.99 49.1,36.1 49.1,36.71 49,36.81 48.82,36.81 48.74,36.72 48.74,36.54 48.64,36.45 48.37,36.45 48.28,36.35 47.93,36.35 47.84,36.44 47.84,36.8 47.71,36.93 47.59,36.93 47.41,36.75 47.28,36.75 47.16,36.88 47.16,37 47.34,37.18 47.34,37.3 47.16,37.48 46.98,37.48 46.79,37.29 46.37,37.29 46.27,37.39 46.27,38.11 45.87,38.51 v1(45.87,38.68)
  BOTTOM w0.079: U1.BK32 77.74,49.58 v2(78.07,49.25)
