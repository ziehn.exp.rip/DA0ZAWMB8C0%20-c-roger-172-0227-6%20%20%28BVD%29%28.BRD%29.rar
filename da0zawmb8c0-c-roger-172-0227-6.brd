# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_A9: length 159.3
  TOP w0.076: U6.R7 33.99,88.84 v1(32.83,88.84) 32.83,89.72 31.17,91.38 R283.2 ; v1(31.61,53.33) 31.81,53.33 32.02,53.53 33.97,53.53 34.12,53.38 34.43,53.38 34.77,53.03 U5.R7 ; U7.R7 34.77,74.46 34.43,74.8 31.67,74.8 v1(31.53,74.66) ; U4.R7 34.75,39.88 34.39,40.25 32.4,40.25 v1(31.89,39.74)
  IN1 w0.089: v1(31.89,39.74) 31.81,39.74 31.46,40.09 31.46,40.35 31.53,40.42 31.73,40.42 31.81,40.5 31.81,40.61 31.73,40.69 31.53,40.69 31.46,40.77 31.46,40.88 31.53,40.96 31.73,40.96 31.81,41.04 31.81,41.15 31.73,41.22 31.53,41.22 31.46,41.3 31.46,42.05 32.12,42.71 32.12,44.44 31.99,44.56 31.56,44.56 31.23,44.89 31.23,46.26 31.41,46.44 32.1,46.44 32.19,46.53 32.19,47.66 31.08,48.78 31.08,50.96 31.19,51.08 31.59,51.08 31.96,51.44 31.96,51.81 31.61,52.16 31.61,52.41 31.53,52.49 31.36,52.49 31.28,52.57 31.28,52.68 31.36,52.76 31.53,52.76 31.61,52.83 v1(31.61,53.33) 31.28,53.65 31.28,55.86 31.88,56.46 31.88,59.63 32.14,59.89 32.14,63.14 32.06,63.22 31.84,63.22 31.76,63.3 31.76,63.41 31.84,63.49 32.06,63.49 32.14,63.57 32.14,63.68 32.06,63.75 31.84,63.75 31.76,63.83 31.76,63.94 31.84,64.02 32.06,64.02 32.14,64.1 32.14,64.21 32.06,64.29 31.84,64.29 31.76,64.37 31.76,64.48 31.84,64.55 32.07,64.55 32.15,64.63 32.15,64.74 32.07,64.82 31.84,64.82 31.76,64.9 31.76,65.01 31.84,65.09 32.14,65.09 32.22,65.16 32.22,65.28 32.14,65.35 31.84,65.35 31.76,65.43 31.76,72.67 31.96,72.88 31.96,73.23 31.7,73.49 31.7,74.49 v1(31.53,74.66) 31.28,74.91 31.28,77.29 31.88,77.89 31.88,79.63 32.33,80.07 32.33,82.55 31.49,83.39 31.49,83.91 32.15,84.57 32.15,86.51 32.4,86.76 32.4,88 32.21,88.19 32.21,88.45 32.59,88.84 v1(32.83,88.84)
  IN3 w0.089: 76.13,69.16 76.87,68.41 76.87,68.06 77.08,67.85 78.86,67.85 v2(79.24,67.48)
  IN3 w0.14: 76.13,69.16 75.25,69.16 75.19,69.22 72.08,69.22 71.74,69.56 66.8,69.56 66.13,70.23 47.68,70.23 47.07,69.63 35.38,69.63 26.47,60.72 26.47,60.09 26.01,59.64 26.01,44.64 30.92,39.74 v1(31.89,39.74)
  BOTTOM w0.079: v2(79.24,67.48) 79.69,67.03 U1.AB29
M_B_A10: length 164.1
  TOP w0.076: U5.M3 37.47,54.8 37.39,54.72 37.21,54.72 37.14,54.8 37.14,56 37.07,56.07 v1(37.07,56.64) ; R284.2 39.25,96.2 38.03,94.98 v1(38.03,94.47) ; U6.M3 37.47,90.97 v1(37.07,91.36) ; U7.M3 37.47,77.69 37.1,78.06 v1(37.07,78.06) ; v1(36.87,41.87) 37.04,41.69 37.04,41.29 37.22,41.11 37.37,41.11 37.47,41.2 U4.M3
  IN1 w0.089: v1(37.07,91.36) 37.66,90.78 37.66,88.88 38.02,88.53 38.02,87.22 37.78,86.98 36.8,86.98 36.59,86.77 36.59,83.25 37.51,82.33 37.51,78.48 37.1,78.06 v1(37.07,78.06) 37.07,77.07 36.81,76.81 36.81,76.32 36.51,76.02 36.51,73.77 36.39,73.65 36.39,70.32 36.47,70.24 37.12,70.24 37.2,70.16 37.2,70.05 37.12,69.97 36.47,69.97 36.39,69.89 36.39,69.78 36.47,69.7 37.12,69.7 37.2,69.63 37.2,69.51 37.12,69.44 36.47,69.44 36.39,69.36 36.39,68.69 37.76,67.33 37.76,62.02 37.83,61.94 38.31,61.94 38.39,61.86 38.39,61.75 38.31,61.67 37.83,61.67 37.76,61.59 37.76,61.48 37.83,61.41 38.31,61.41 38.39,61.33 38.39,60.44 37.51,59.56 37.51,57.05 37.1,56.64 v1(37.07,56.64) 37.07,55.64 36.81,55.38 36.81,54.9 36.51,54.59 36.51,52.34 36.39,52.22 36.39,50.4 36.84,49.95 37.26,49.95 37.53,50.21 37.53,50.39 37.63,50.49 37.81,50.49 37.91,50.39 37.91,49.8 37.82,49.72 37.57,49.72 37.48,49.63 37.48,49.45 37.57,49.36 37.82,49.36 37.91,49.27 37.91,49.09 37.82,49 37.57,49 37.48,48.92 37.48,48.74 37.57,48.65 37.82,48.65 37.91,48.56 37.91,46.29 36.64,45.02 36.64,42.15 36.87,41.92 v1(36.87,41.87)
  IN3 w0.089: v1(37.07,91.36) 36.64,91.8 36.64,92.64 36.82,92.82 36.82,93.26 v1(38.03,94.47)
  IN3 w0.14: v1(36.87,41.87) 36.61,42.12 36.61,43.56 36.5,43.67 35.92,43.67 35.78,43.81 35.78,44.76 35.23,45.31 35.23,45.54 35.37,45.68 35.59,45.68 35.73,45.82 35.73,46.06 35.62,46.18 35.1,46.18 34.97,46.04 34.62,46.04 33.34,47.33 33.34,51.53 33.48,51.67 34.25,51.67 34.37,51.79 34.37,51.96 34.25,52.08 33.71,52.08 33.58,52.21 33.58,52.38 33.71,52.5 34.25,52.5 34.37,52.63 34.37,52.8 34.25,52.92 33.81,52.92 33.69,53.05 33.69,54.76 34.04,55.11 34.04,55.6 34.43,55.99 34.43,56.26 34.27,56.42 34.18,56.42 34.04,56.56 34.04,56.95 34.2,57.11 34.52,57.11 34.62,57.21 34.62,57.64 34.48,57.78 34.11,57.78 33.99,57.9 33.99,58.08 34.11,58.2 34.48,58.2 34.62,58.34 34.62,59.16 37.34,61.87 37.34,62.62 37.92,63.2 38.48,63.2 38.97,62.71 39.52,62.71 39.82,62.41 46.54,62.41 47.3,61.64 50.6,61.64 51.22,61.03 51.22,60.67 51.45,60.43 52.79,60.43 52.91,60.31 52.91,59.94 53.03,59.82 53.21,59.82 53.33,59.94 53.33,60.61 53.45,60.73 53.63,60.73 53.75,60.61 53.75,59.94 53.87,59.82 54.05,59.82 54.17,59.94 54.17,60.58 54.32,60.73 54.58,60.73 54.72,60.59 54.72,59.45 54.86,59.31 55.09,59.31 55.21,59.44 55.21,59.94 55.34,60.06 55.51,60.06 55.63,59.94 55.63,59.44 55.76,59.31 55.91,59.31 56.07,59.47 56.39,59.47 56.54,59.33 57.14,59.33 57.23,59.42 57.23,59.96 57.36,60.08 57.53,60.08 57.65,59.96 57.65,59.76 57.79,59.62 57.99,59.62 59.29,60.92 59.29,61.72 60.43,62.86 60.94,62.86 61.07,62.98 61.07,63.2 61.19,63.32 61.36,63.32 61.49,63.2 61.49,62.98 61.61,62.86 61.78,62.86 61.9,62.98 61.9,63.2 62.03,63.32 62.2,63.32 62.32,63.2 62.32,62.98 62.45,62.86 62.62,62.86 62.74,62.98 62.74,63.2 62.87,63.32 63.04,63.32 63.16,63.2 63.16,62.98 63.28,62.86 63.46,62.86 63.58,62.98 63.58,63.2 63.7,63.32 63.88,63.32 64,63.2 64,62.98 64.12,62.86 64.3,62.86 64.42,62.98 64.42,63.2 64.54,63.32 64.72,63.32 64.84,63.2 64.84,62.98 64.96,62.86 65.13,62.86 65.26,62.98 65.26,63.09 65.38,63.21 65.55,63.21 65.68,63.09 65.68,62.98 65.8,62.86 65.97,62.86 66.1,62.98 66.1,63.09 66.22,63.21 66.39,63.21 66.51,63.09 66.51,62.98 66.64,62.86 67.36,62.86 67.65,63.15 67.65,63.56 67.8,63.71 68.69,63.71 v2(69.24,63.16)
  BOTTOM w0.076: U1.AG34 76.48,63.9 76.23,63.65 75.21,63.65 74.9,63.48 74.89,63.47 74.54,63.47 74.42,63.59 74.3,63.59 74.22,63.51 74.07,63.51 74,63.59 73.88,63.59 73.8,63.51 73.66,63.51 73.6,63.58 73.44,63.58 73.38,63.51 73.24,63.51 73.18,63.57 73.18,63.78 73.12,63.83 72.95,63.83 72.89,63.77 72.89,63.58 72.83,63.52 72.67,63.52 72.61,63.59 72.61,63.78 72.55,63.83 72.4,63.83 72.32,63.75 72.32,63.7 72.25,63.63 72.12,63.63 72.04,63.7 72.04,63.75 71.97,63.83 71.84,63.83 71.76,63.75 71.76,63.7 71.69,63.63 71.56,63.63 71.48,63.7 71.48,63.75 71.41,63.83 71.28,63.83 71.2,63.75 71.2,63.7 71.13,63.63 71,63.63 70.92,63.7 70.92,63.75 70.85,63.83 70.72,63.83 70.65,63.75 70.65,63.7 70.57,63.63 70.44,63.63 70.37,63.7 70.37,63.75 70.29,63.83 70.16,63.83 70.09,63.75 70.09,63.7 70.01,63.63 69.88,63.63 69.81,63.7 69.81,63.75 69.73,63.83 69.6,63.83 69.53,63.75 69.53,63.7 69.45,63.63 69.32,63.63 69.25,63.7 69.25,63.75 69.17,63.83 68.39,63.83 68.33,63.77 68.33,63.61 68.39,63.55 69,63.55 69.24,63.32 v2(69.24,63.16)
M_B_A11: length 165.8
  TOP w0.076: v1(30.52,43.75) 34.14,43.75 U4.T2 ; v1(30.69,57.39) 32.42,57.39 32.81,57 34.24,57 U5.T2 ; U6.T2 34.15,91.76 33.46,92.44 v1(33.44,92.44) 33.01,92.87 33.01,94.77 R285.2 ; v1(30.69,78.82) 31.1,78.41 32.59,78.41 32.96,78.04 33.85,78.04 U7.T2
  IN1 w0.089: v1(33.44,92.44) 33.02,92.02 33.02,91.49 32.36,90.84 32.09,90.84 32.01,90.91 32.01,91.35 31.94,91.43 31.83,91.43 31.75,91.35 31.75,90.91 31.67,90.84 31.56,90.84 31.48,90.91 31.48,91.35 31.4,91.43 31.29,91.43 31.21,91.35 31.21,90.91 31.14,90.84 31.06,90.84 30.73,90.5 30.73,78.85 v1(30.69,78.82) 30.27,78.39 30.27,64.89 30.35,64.8 30.66,64.8 30.75,64.72 30.75,64.6 30.66,64.51 30.35,64.51 30.27,64.42 30.27,64.3 30.35,64.22 30.66,64.22 30.75,64.13 30.75,64.01 30.66,63.93 30.35,63.93 30.27,63.84 30.27,63.72 30.35,63.63 30.66,63.63 30.75,63.55 30.75,63.43 30.66,63.34 30.35,63.34 30.27,63.26 30.27,61.69 30.92,61.04 30.92,60.11 30.72,59.9 30.72,57.42 v1(30.69,57.39) 30.64,57.39 30.06,56.81 30.06,51.7 29.59,51.23 29.59,50.98 29.67,50.9 29.98,50.9 30.06,50.82 30.06,50.71 29.98,50.63 29.67,50.63 29.59,50.55 29.59,50.44 29.67,50.36 29.98,50.36 30.06,50.29 30.06,50.18 29.98,50.1 29.67,50.1 29.59,50.02 29.59,49.91 29.67,49.83 29.98,49.83 30.06,49.75 30.06,49.64 29.98,49.56 29.67,49.56 29.59,49.49 29.59,49.38 29.67,49.3 29.98,49.3 30.06,49.22 30.06,49.11 29.98,49.03 29.67,49.03 29.59,48.95 29.59,48.84 29.67,48.76 29.98,48.76 30.06,48.69 30.06,48.58 29.98,48.5 29.67,48.5 29.59,48.42 29.59,48.31 29.67,48.23 29.98,48.23 30.06,48.15 30.06,48.04 29.98,47.96 29.67,47.96 29.59,47.89 29.59,47.78 29.67,47.7 29.98,47.7 30.06,47.62 30.06,47.51 29.98,47.43 29.67,47.43 29.59,47.35 29.59,44.68 v1(30.52,43.75)
  IN3 w0.089: v2(80.07,66.54) 79.77,66.24 77.85,66.24 77.43,66.66
  IN3 w0.14: 77.43,66.66 77.07,66.66 76.01,67.72 75.04,67.72 74.92,67.84 74.92,68.5 74.8,68.62 74.62,68.62 74.5,68.5 74.5,67.84 74.38,67.72 74.2,67.72 74.08,67.84 74.08,68.01 73.96,68.13 73.78,68.13 73.66,68.01 73.66,67.84 73.54,67.72 73.36,67.72 73.24,67.84 73.24,67.94 73.12,68.06 72.94,68.06 72.82,67.94 72.82,67.84 72.7,67.72 72.53,67.72 72.4,67.84 72.4,67.89 72.28,68.01 72.11,68.01 71.98,67.89 71.98,67.84 71.86,67.72 71.69,67.72 71.57,67.84 71.57,67.89 71.44,68.01 71.27,68.01 71.15,67.89 71.15,67.77 70.72,67.34 70.72,67 70.49,66.77 70.03,66.77 69.91,66.89 69.91,67.03 69.78,67.16 69.61,67.16 69.49,67.03 69.49,66.89 69.37,66.77 69.19,66.77 69.07,66.89 68.65,66.89 68.53,66.77 66.06,66.77 65.19,67.65 59.69,67.65 59.43,67.91 52.69,67.91 52.02,67.24 40,67.24 39.88,67.12 39.88,66.96 39.76,66.83 39.58,66.83 39.46,66.96 39.46,67.12 39.34,67.24 39.16,67.24 39.04,67.12 39.04,66.96 38.92,66.83 38.74,66.83 38.62,66.96 38.62,67.12 38.5,67.24 38.33,67.24 38.2,67.12 38.2,66.96 38.08,66.83 37.91,66.83 37.78,66.96 37.78,67.12 37.66,67.24 37.49,67.24 37.36,67.12 37.36,66.96 37.24,66.83 37.07,66.83 36.95,66.96 36.95,67.12 36.82,67.24 36.65,67.24 36.53,67.12 36.53,66.96 36.4,66.83 36.23,66.83 36.11,66.96 36.11,67.12 35.98,67.24 35.69,67.24 29.91,61.46 29.74,61.46 29.59,61.6 29.42,61.6 29.29,61.48 29.29,61.3 29.44,61.16 29.44,60.99 29.31,60.86 29.14,60.86 28.99,61 28.82,61 28.46,60.64 28.46,60.4 29.02,59.84 29.02,59.67 28.9,59.54 28.73,59.54 28.25,60.02 28.07,60.02 27.95,59.9 27.95,59.73 28.43,59.25 28.43,59.07 28.31,58.95 28.13,58.95 27.86,59.23 27.68,59.23 27.5,59.05 27.5,58.85 27.73,58.63 27.73,58.37 27.47,58.12 27.47,45.32 28.86,43.94 29.57,43.94 29.71,43.8 29.71,43.51 29.85,43.37 30.13,43.37 v1(30.52,43.75)
  BOTTOM w0.079: U1.AC28 80.34,66.27 v2(80.07,66.54)
M_B_A12: length 163.3
  TOP w0.076: U5.M7 37.19,53.03 37.02,53.2 37.02,53.83 36.77,54.08 36.25,54.08 35.7,54.64 35.7,54.98 36.13,55.41 v1(36.13,55.43) ; U6.M7 37.39,87.76 36.76,88.38 36.76,89.39 37.02,89.65 v1(37.23,89.65) ; U7.M7 37.31,74.46 35.7,76.06 35.7,76.4 36.13,76.83 v1(36.13,76.86) ; v1(35.6,94.47) 35.39,94.68 R286.2 ; U4.M7 37.33,39.88 36.82,40.4 v1(36.82,40.42)
  IN1 w0.089: v1(37.23,89.65) 36.81,89.22 36.81,87.71 36.09,86.98 36.09,82.75 37.01,81.83 37.01,78.97 36.39,78.36 36.39,77.12 v1(36.13,76.86) 35.7,76.43 35.7,76.05 36,75.76 36,73.98 35.88,73.85 35.88,68.49 37.25,67.12 37.25,60.92 37.19,60.87 36.72,60.87 36.64,60.79 36.64,60.68 36.72,60.6 37.19,60.6 37.27,60.52 37.27,60.41 37.19,60.33 36.72,60.33 36.64,60.25 36.64,60.14 36.72,60.07 37.03,60.07 37.11,59.99 37.11,59.88 37.03,59.8 36.72,59.8 36.64,59.72 36.64,59.61 36.72,59.53 36.93,59.53 37.01,59.45 37.01,57.55 36.39,56.93 36.39,55.7 v1(36.13,55.43) 35.7,55.01 35.7,54.62 36,54.33 36,52.55 35.88,52.43 35.88,50.19 36.87,49.2 36.87,45.97 36.13,45.23 36.13,41.34 36.05,41.26 36.05,40.68 36.31,40.42 v1(36.82,40.42)
  IN3 w0.089: v1(35.6,94.47) 35.6,93.94 35.32,93.66 35.32,91.88 36.89,90.31 36.89,89.99 v1(37.23,89.65)
  IN3 w0.14: v1(36.82,40.42) 36.31,40.42 35.88,39.99 35.88,39.23 35.65,39 34.33,39 33.67,39.66 33.41,39.66 32.91,40.17 30.9,40.17 26.31,44.76 26.31,59.52 26.76,59.97 26.76,60.6 35.5,69.33 48.97,69.33 49.58,69.94 66.01,69.94 66.68,69.27 71.62,69.27 71.96,68.93 75.07,68.93 75.86,68.14 76.04,68.14 77.14,67.04 79.39,67.04 v2(79.82,67.48)
  BOTTOM w0.079: U1.AB28 80.28,67.03 v2(79.82,67.48)
M_B_A13: length 158
  TOP w0.076: U4.T8 33.61,39.08 33.54,39.15 v1(33.46,39.15) ; v1(31.7,89.51) 31.63,89.44 R287.2 ; U7.T8 33.22,73.66 v1(33.08,73.8) ; v1(33.16,52.31) 34.19,52.31 U5.T8 ; U6.T8 34,86.96 v1(33.34,87.62)
  IN1 w0.089: v1(33.34,87.62) 33.34,86.55 33.54,86.35 33.54,81.7 33.7,81.54 33.7,80.01 32.9,79.21 32.9,77.46 32.81,77.38 32.81,76.61 32.42,76.22 32.42,75.54 32.72,75.24 32.72,74.16 v1(33.08,73.8) 33.31,73.57 33.31,70.91 32.78,70.38 32.78,68.26 32.86,68.17 33.22,68.17 33.31,68.09 33.31,67.96 33.22,67.88 32.86,67.88 32.78,67.79 32.78,67.68 32.86,67.6 33.23,67.6 33.31,67.52 33.31,64.41 33.16,64.26 33.16,60.65 33.7,60.11 33.7,58.95 32.9,58.15 32.9,56.04 32.81,55.95 32.81,55.18 32.42,54.8 32.42,54.24 32.81,53.86 32.81,52.66 v1(33.16,52.31) 33.03,52.18 33.03,51.08 32.88,50.93 32.88,50.71 33.03,50.56 33.03,49.96 32.78,49.7 32.39,49.7 32.24,49.85 32.17,49.85 32.09,49.77 32.09,49.29 32.18,49.2 32.49,49.2 32.57,49.11 32.57,48.72 33.21,48.08 33.21,46.23 33.4,46.04 33.4,45.21 32.9,44.72 32.9,42.25 32.68,42.02 32.68,41.41 32.32,41.06 32.32,40.25 32.65,39.91 33.38,39.91 34.68,38.61 34.68,38.49 34.58,38.39 33.67,38.39 33.56,38.49 33.56,39.05 v1(33.46,39.15)
  IN3 w0.089: v1(33.34,87.62) 33.34,89.01 32.84,89.51 v1(31.7,89.51)
  IN3 w0.14: v2(67.78,61.35) 67.78,61.41 68,61.63 68,61.77 67.79,61.98 67.38,61.98 67.18,61.78 67.01,61.78 66.81,61.98 63.16,61.98 62.81,61.63 62.81,61.18 62.99,61 64.13,61 64.27,60.86 64.27,60.67 64.03,60.44 62.38,60.44 62.26,60.56 62.26,60.99 62.14,61.11 61.96,61.11 61.84,60.99 61.84,60.56 61.72,60.44 61.54,60.44 61.42,60.56 61.42,60.99 61.3,61.11 61.12,61.11 61,60.99 61,60.56 60.88,60.44 60.71,60.44 60.58,60.56 60.58,60.99 60.46,61.11 60.29,61.11 60.16,60.99 60.16,60.56 58.04,58.44 54.45,58.44 53.94,58.95 50.58,58.95 50.34,59.18 50.34,60.67 50.24,60.77 46.94,60.77 46.18,61.53 40.18,61.53 40,61.35 39.63,61.35 39.15,61.84 38.65,61.84 38.44,61.62 38.32,61.62 37.01,60.3 37.01,57.71 36.32,57.03 36.32,56.23 35.68,55.59 35.68,54.51 35.82,54.37 36.16,54.37 36.32,54.2 36.32,49.56 36.16,49.4 35.83,49.4 35.63,49.19 35.63,48.63 35.88,48.38 36.27,48.38 36.36,48.29 36.36,47.97 36.53,47.8 36.73,47.8 37.11,47.43 37.11,44.83 37.15,44.79 37.15,42.64 37.76,42.03 37.76,40.64 38.27,40.14 38.27,39.7 39.69,38.29 39.69,36.99 39.04,36.35 36.02,36.35 35.14,37.22 35.14,38.1 35,38.24 33.68,38.24 33.46,38.45 v1(33.46,39.15)
  BOTTOM w0.076: v2(67.78,61.35) 67.43,61 66.68,61 66.6,60.91 66.6,60.52 66.67,60.44 68.02,60.44 68.21,60.63 68.21,61.97 68.43,62.19 72.62,62.19 72.84,62.41 74.27,62.41 74.42,62.26 74.89,62.26 74.96,62.29 75.15,62.29 75.23,62.26 75.49,62.26 U1.AK35
M_B_ACT#: length 160.8
  TOP w0.076: R292.2 41.32,94.45 v1(40.78,94.45) ; U4.L3 38.28,43.08 v1(38.67,43.48) ; v1(39.46,77.25) 39.44,77.27 38.92,77.27 38.53,77.66 U7.L3 ; U5.L3 38.59,56.23 38.67,56.15 38.67,54.74 38.75,54.66 38.97,54.66 39.05,54.74 39.05,55.74 39.13,55.82 v1(39.46,55.82) ; v1(39.22,90.3) 38.93,90.3 U6.L3
  IN1 w0.089: v1(39.22,90.3) 39.22,86.91 39.03,86.73 39.03,86.37 39.31,86.09 39.31,83.47 39.91,82.87 39.91,79.9 39.04,79.03 39.04,78.68 39.46,78.26 v1(39.46,77.25) 39.46,76.81 38.03,75.39 38.03,74.25 38.73,73.55 38.73,69.94 38.81,69.86 39.3,69.86 39.36,69.81 39.36,69.68 39.27,69.6 38.81,69.6 38.73,69.52 38.73,68.51 39.31,67.93 39.81,67.93 39.91,67.83 39.91,67.58 39.84,67.5 39.36,67.5 39.28,67.42 39.28,67.31 39.36,67.23 39.84,67.23 39.91,67.15 39.91,67.04 39.84,66.96 39.36,66.96 39.28,66.89 39.28,66.78 39.36,66.7 39.84,66.7 39.91,66.62 39.91,66.51 39.84,66.43 39.36,66.43 39.28,66.35 39.28,66.24 39.36,66.16 39.84,66.16 39.91,66.09 39.91,58.48 39.04,57.61 39.04,57.25 39.46,56.83 v1(39.46,55.82) 39.46,55.39 38.03,53.96 38.03,52.83 38.95,51.9 39.41,51.9 39.56,51.75 39.56,44.45 39.44,44.33 39.28,44.33 39.18,44.44 39.18,44.59 39.05,44.72 38.49,44.72 38.24,44.47 38.24,43.59 38.36,43.48 v1(38.67,43.48)
  IN3 w0.089: 77.17,65.48 77.36,65.29 82.29,65.29 82.45,65.46 82.45,65.6 82.37,65.69 81.65,65.69 81.57,65.78 81.57,65.9 81.65,65.98 82.37,65.98 82.45,66.07 82.45,66.19 82.37,66.27 81.65,66.27 81.57,66.36 81.57,66.48 81.65,66.57 82.37,66.57 82.45,66.65 82.45,66.77 82.37,66.86 81.65,66.86 81.57,66.94 81.57,67.06 81.65,67.15 82.37,67.15 82.45,67.24 82.45,67.36 82.37,67.44 81.65,67.44 81.57,67.53 81.57,67.65 81.65,67.73 82.37,67.73 82.45,67.82 82.45,67.94 82.37,68.03 81.65,68.03 81.57,68.11 81.57,68.23 81.65,68.32 82.37,68.32 82.45,68.4 82.45,68.53 82.37,68.61 82.07,68.61 81.99,68.7 81.99,68.93 81.72,69.19 80.71,69.19 v2(80.67,69.23) ; v1(39.22,90.3) 39.45,90.3 39.94,90.79 39.94,93.61 v1(40.78,94.45)
  IN3 w0.14: 77.17,65.48 76.87,65.79 76.87,65.89 75.64,67.11 75.06,67.11 74.94,67 74.94,66.77 75.07,66.65 75.53,66.65 75.65,66.53 75.65,66.36 75.53,66.23 75.07,66.23 74.94,66.11 74.94,65.91 75.04,65.81 75.85,65.81 76.01,65.65 76.01,65.44 75.87,65.3 75.12,65.3 74.01,64.19 73.78,64.19 73.66,64.07 73.66,63.88 73.43,63.65 73.24,63.65 73.01,63.42 73.01,63.22 72.88,63.09 72.68,63.09 72.59,63 72.59,62.79 72.5,62.71 72.5,62.03 71.27,60.8 70.92,60.8 70.72,61 70.53,61 70.29,60.75 69.79,60.75 68.27,59.23 64.98,59.23 64.67,58.91 60.67,58.91 59.81,58.05 59.81,57.65 57.75,55.59 53.52,55.59 53.13,55.98 50.49,55.98 49.37,57.1 49.37,57.95 49.12,58.2 48.38,58.2 47.46,59.12 46.05,59.12 45.49,59.68 42.03,59.68 41.87,59.52 41.66,59.52 41.51,59.68 41.04,59.68 40.91,59.54 40.91,59.27 40.77,59.12 40.17,59.12 39.65,58.59 39.21,58.59 38.82,58.2 38.82,57.87 38.63,57.68 38.63,55.36 38.75,55.24 38.99,55.24 39.11,55.12 39.11,54.95 38.99,54.82 38.61,54.82 38.49,54.7 38.49,54.52 38.61,54.4 39.02,54.4 39.11,54.3 39.11,54.09 38.91,53.88 38.8,53.88 38.63,53.72 38.63,44.84 38.21,44.43 38.21,43.94 v1(38.67,43.48)
  BOTTOM w0.079: U1.W28 80.67,69.18 v2(80.67,69.23)
M_B_ALERT#: length 133.3
  TOP w0.076: v1(35.62,37.71) 35.87,37.95 U4.P9 ; v1(33.11,84.17) 33.44,84.49 33.89,84.49 35.18,85.78 35.49,85.78 U6.P9 ; v1(32.6,50.13) 34.25,50.13 35.18,51.06 35.49,51.06 U5.P9 ; v1(32.88,71.11) 33.8,71.11 35.18,72.48 35.49,72.48 U7.P9
  TOP w0.165: v1(33.11,84.17) 33.11,83.19 R271.1
  IN1 w0.089: v1(33.11,84.17) 33.29,83.99 33.29,81.6 33.44,81.44 33.44,80.11 32.64,79.31 32.64,77.57 32.55,77.48 32.55,76.71 32.17,76.33 32.17,75.43 32.47,75.14 32.47,73.8 32.73,73.54 32.73,73.37 32.83,73.27 32.93,73.27 33.06,73.14 33.06,72.95 32.98,72.87 32.8,72.87 32.73,72.8 32.73,72.68 32.8,72.61 32.98,72.61 33.06,72.53 33.06,72.42 32.98,72.34 32.8,72.34 32.73,72.26 32.73,72.15 32.8,72.07 32.98,72.07 33.06,72 33.06,71.49 32.88,71.31 v1(32.88,71.11) 32.88,70.84 32.52,70.49 32.52,67.35 32.6,67.27 32.98,67.27 33.06,67.19 33.06,67.08 32.98,67 32.6,67 32.52,66.92 32.52,66.81 32.6,66.74 32.98,66.74 33.06,66.66 33.06,64.52 32.9,64.37 32.9,60.5 33.44,59.96 33.44,59.05 32.64,58.25 32.64,56.14 32.55,56.06 32.55,55.34 32.45,55.23 32.26,55.23 32.17,55.14 32.17,54.14 32.55,53.75 32.55,52.32 32.73,52.14 32.73,51.13 32.51,50.92 32.51,50.72 32.78,50.46 32.78,50.3 v1(32.6,50.13) 32.22,50.5 32.1,50.5 31.84,50.25 31.84,49.1 32.95,47.98 32.95,46.13 33.15,45.94 33.15,45.34 32.65,44.84 32.65,42.38 32.42,42.15 32.42,41.62 32.07,41.26 32.07,40.14 32.54,39.66 32.8,39.66 32.89,39.57 32.89,38.73 33.49,38.14 34.9,38.14 35.11,37.92 35.11,37.08 35.2,36.99 35.53,36.99 35.62,37.08 v1(35.62,37.71)
  IN3 w0.089: 79.59,69.25 80.26,68.58 80.26,68.2 80.11,68.05 79.64,68.05 v2(79.29,68.4)
  IN3 w0.14: 79.59,69.25 79.59,70.06 79.06,70.6 77.25,70.6 76.57,71.28 76.12,71.28 75.75,70.92 72.13,70.92 71.58,71.46 67.34,71.46 66.91,71.89 47.55,71.89 47.09,71.43 41.54,71.43 41.42,71.32 40.91,71.32 40.45,71.77 40.45,75.17 38.67,76.95 38.67,82.52 38.53,82.66 34.94,82.66 33.44,84.17 v1(33.11,84.17)
  BOTTOM w0.079: U1.Y29 79.69,67.99 v2(79.29,68.4)
M_B_BG#0: length 159.1
  TOP w0.076: U6.M2 37.47,92.02 37.07,92.42 37.07,93.51 37.4,93.84 v1(37.4,94.47) 37.4,94.86 38.29,95.74 R270.2 ; v1(36.21,81.08) 37.07,80.21 37.07,79.12 37.47,78.72 U7.M2 ; v1(36.21,59.65) 37.07,58.79 37.07,57.69 37.47,57.3 U5.M2 ; v1(35.22,41.41) 35.65,41.41 37.07,42.84 37.07,43.48 U4.M2
  IN1 w0.089: v1(37.4,94.47) 37.27,94.35 37.27,93.97 37.4,93.84 37.65,93.84 37.78,93.71 37.78,93.59 37.3,93.1 37.3,92.92 36.56,92.18 36.56,87.81 35.83,87.09 35.83,82.65 36,82.47 36,81.28 v1(36.21,81.08) 36.58,80.7 36.58,78.91 36.14,78.46 36.14,77.47 35.45,76.78 35.45,75.94 35.74,75.65 35.74,74.08 35.62,73.96 35.62,68.38 36.94,67.07 36.94,61.72 36.33,61.12 36.33,59.78 v1(36.21,59.65) 36.75,59.1 36.75,57.65 36.14,57.04 36.14,56.04 35.45,55.36 35.45,54.52 35.74,54.22 35.74,52.66 35.62,52.53 35.62,50.09 36.61,49.1 36.61,46.07 35.88,45.33 35.88,41.9 35.39,41.41 v1(35.22,41.41)
  IN3 w0.089: 77.28,66.28 77.53,66.28 77.76,66.05 80.1,66.05 80.45,66.4 80.45,68.87 80.07,69.25 v2(80.07,69.33)
  IN3 w0.14: 77.28,66.28 76.95,66.28 75.78,67.46 73.26,67.46 72.69,66.88 70.93,66.88 70.56,66.51 65.9,66.51 65.07,67.35 59.57,67.35 59.36,67.57 52.76,67.57 52.1,66.9 41.12,66.9 40.76,66.54 35.41,66.54 29.51,60.64 29.51,59.74 27.77,58 27.77,45.51 29,44.28 30.59,44.28 30.94,43.93 30.94,43.57 30.67,43.29 30.67,42.2 31.73,41.13 33.31,41.13 33.54,40.91 34.02,40.91 34.38,41.26 34.99,41.26 35.14,41.41 v1(35.22,41.41)
  BOTTOM w0.079: v2(80.07,69.33) 79.69,68.95 U1.W29
M_B_BG#1: length 83.9
  TOP w0.165: v2(29.02,40.58) 29.42,40.58 29.5,40.5 R252.1 R294.2
  IN3 w0.089: v2(79.89,68.42) 79.49,68.82 77.08,68.82 76.09,69.81 75.63,69.81
  IN3 w0.14: v2(29.02,40.58) 28.82,40.58 25.43,43.97 25.43,59.88 25.89,60.34 25.89,60.96 35.14,70.22 43.47,70.22 44.03,70.78 47.25,70.78 47.29,70.82 71.31,70.82 72.32,69.81 75.63,69.81
  BOTTOM w0.079: v2(79.89,68.42) 79.96,68.42 80.34,68.04 U1.Y28
M_B_BG#1_R: length 92.6
  TOP w0.076: v1(31.18,81.88) 31.59,82.29 33.2,82.29 35.56,84.64 37.35,84.64 37.53,84.82 37.53,86.1 U6.M9 ; 31.43,39.36 31.56,39.36 32.22,38.7 37.05,38.7 U4.M9 ; 34.48,71.23 34.5,71.26 37.18,71.26 37.6,71.68 37.6,72.72 U7.M9
  TOP w0.102: v2(30.14,39.94) 30.14,40.08 R252.2 R257.2 31.43,39.36 ; 34.48,71.23 33.01,69.76 31.63,69.76 v1(30.69,68.82) ; U5.M9 37.6,51.3 37.6,50.05 36.84,49.29 32.98,49.29 v1(31.11,47.42)
  IN1 w0.089: v1(31.18,81.88) 30.98,81.68 30.98,81.41 31.06,81.33 31.49,81.33 31.56,81.26 31.56,81.15 31.49,81.07 31.06,81.07 30.98,80.99 30.98,79.28 31.12,79.15 31.12,78.46 31.02,78.36 30.67,78.36 30.52,78.21 30.52,69.71 30.6,69.63 30.92,69.63 31,69.55 31,69.44 30.92,69.36 30.6,69.36 30.52,69.28 30.52,68.99 v1(30.69,68.82) 30.52,68.65 30.52,65.78 30.6,65.7 30.92,65.7 31,65.62 31,65.51 30.92,65.43 30.6,65.43 30.52,65.35 30.52,65.24 30.6,65.17 30.92,65.17 31,65.09 31,61.32 31.25,61.07 31.25,60.08 31.12,59.95 31.12,57.03 31.02,56.93 30.75,56.93 30.31,56.5 30.31,48.22 v1(31.11,47.42) 30.96,47.42 29.86,46.32 29.86,45.02 30.95,43.93 30.95,43.19 30.86,43.1 29.59,43.1 29.5,43.01 29.5,42.84 29.59,42.75 30.86,42.75 30.95,42.66 30.95,42.48 30.86,42.39 29.59,42.39 29.5,42.3 29.5,42.12 29.59,42.04 30.86,42.04 30.95,41.95 30.95,41.77 30.86,41.68 29.59,41.68 29.5,41.59 29.5,41.41 29.59,41.32 30.86,41.32 30.95,41.24 30.95,40.98 30.14,40.17 v2(30.14,39.94)
M_B_BS#0: length 161.6
  TOP w0.076: U6.N2 36.67,91.76 36.23,92.19 36.23,92.95 v1(36.1,93.08) 36.1,93.76 36.89,94.55 36.89,95.11 37.32,95.54 R268.2 ; v1(36.1,58.36) 36.23,58.23 36.23,57.73 36.46,57.5 36.46,57.36 36.23,57.14 36.23,56.86 36.06,56.68 36.06,56.55 36.2,56.4 36.34,56.4 36.59,56.65 36.59,56.95 U5.N2 ; v1(36.13,46.85) 36.28,46.85 37.04,46.09 37.04,45.15 37.04,44.36 36.67,43.99 U4.N2 ; v1(36.1,79.78) 36.23,79.65 36.23,78.89 36.67,78.46 U7.N2
  IN1 w0.089: v1(36.1,93.08) 36.33,93.31 36.53,93.31 36.76,93.08 36.76,92.95 36.3,92.49 36.3,87.92 35.58,87.19 35.58,82.54 35.73,82.39 35.73,80.16 v1(36.1,79.78) 35.88,79.56 35.88,77.57 35.2,76.89 35.2,75.84 35.49,75.54 35.49,74.19 35.37,74.07 35.37,68.28 36.68,66.96 36.68,64.31 36.6,64.23 36.16,64.23 36.08,64.15 36.08,64.04 36.16,63.96 36.6,63.96 36.68,63.88 36.68,63.77 36.6,63.7 36.16,63.7 36.08,63.62 36.08,63.51 36.16,63.43 36.6,63.43 36.68,63.35 36.68,63.24 36.6,63.16 36.16,63.16 36.08,63.08 36.08,62.35 36.16,62.27 36.6,62.27 36.68,62.2 36.68,62.08 36.6,62.01 36.16,62.01 36.08,61.93 36.08,61.82 36.16,61.74 36.31,61.74 36.38,61.66 36.38,61.55 36.31,61.47 36.16,61.47 36.08,61.4 36.08,60.46 35.73,60.11 35.73,58.73 v1(36.1,58.36) 36.16,58.41 36.41,58.41 36.5,58.32 36.5,57.81 36.23,57.54 36.11,57.54 35.74,57.9 35.6,57.9 35.44,57.74 35.44,57.54 35.53,57.45 35.77,57.45 35.88,57.34 35.88,56.15 35.2,55.46 35.2,54.41 35.49,54.12 35.49,52.76 35.37,52.64 35.37,51.4 35.19,51.22 35.19,51.07 35.35,50.91 35.35,50.73 35.26,50.64 35.16,50.64 35.08,50.55 35.08,50.35 35.17,50.26 35.27,50.26 35.36,50.17 35.36,50 35.27,49.91 35.16,49.91 35.08,49.82 35.08,49.7 35.16,49.61 35.74,49.61 35.83,49.52 35.83,49.4 35.74,49.31 35.17,49.31 35.08,49.22 35.08,49.09 35.17,49 35.53,49 35.62,48.91 35.62,48.79 35.53,48.7 35.34,48.7 35.26,48.61 35.26,48.49 35.34,48.4 35.86,48.4 35.88,48.38 36.22,48.38 36.31,48.29 36.31,48.1 36.23,48.02 35.99,48.02 35.9,47.93 35.9,47.79 36.04,47.65 36.27,47.65 36.36,47.56 36.36,47.46 36.26,47.36 35.96,47.36 35.87,47.27 35.87,46.94 35.96,46.85 v1(36.13,46.85)
  IN3 w0.14: v2(68.66,63.12) 68.46,62.92 68.46,62.79 68.55,62.7 69.98,62.7 70.08,62.6 70.08,62.41 69.94,62.27 68.36,62.27 68.06,62.57 60.55,62.57 60.23,62.25 60.23,61.89 59.58,61.23 59.58,60.8 57.8,59.02 54.69,59.02 54.18,59.53 51.06,59.53 50.93,59.66 50.93,60.91 50.48,61.35 47.18,61.35 46.42,62.11 39.7,62.11 39.39,62.42 38.77,62.42 38.33,62.86 38.06,62.86 37.68,62.48 37.68,61.8 36.15,60.27 35.58,59.71 35.58,59.16 35.46,59.04 35.03,59.04 34.91,58.92 34.91,58.74 35.03,58.62 35.56,58.62 35.68,58.5 35.68,58.33 35.56,58.2 35.03,58.2 34.91,58.08 34.91,57.91 35.03,57.78 35.62,57.78 35.74,57.66 35.74,57.49 35.62,57.36 35.03,57.36 34.91,57.24 34.91,57.07 35.03,56.95 35.61,56.95 35.74,56.82 35.74,56.53 35.6,56.39 35.03,56.39 34.89,56.25 34.89,56.04 35.1,55.83 35.1,55.73 34.94,55.57 34.42,55.57 34.33,55.48 34.33,54.99 34.05,54.71 34.05,53.56 34.23,53.38 34.47,53.38 34.66,53.19 34.66,51.36 34.54,51.24 33.8,51.24 33.68,51.12 33.68,50.94 33.8,50.82 34.54,50.82 34.66,50.7 34.66,50.52 34.54,50.4 33.8,50.4 33.68,50.28 33.68,50.11 33.8,49.98 34.54,49.98 34.66,49.86 34.66,49.69 34.54,49.56 33.8,49.56 33.68,49.44 33.68,49.27 33.8,49.14 34.54,49.14 34.66,49.02 34.66,48.85 34.54,48.73 33.8,48.73 33.68,48.6 33.68,48.43 33.8,48.31 35.12,48.31 35.25,48.18 35.25,48.01 35.12,47.89 33.8,47.89 33.68,47.76 33.68,47.47 33.83,47.32 35.42,47.32 35.53,47.21 35.53,46.99 35.44,46.9 34.62,46.9 34.54,46.82 34.54,46.61 34.68,46.47 35.75,46.47 v1(36.13,46.85)
  BOTTOM w0.076: U1.AJ37 74.69,62.74 72.7,62.74 72.48,62.52 66.69,62.52 66.53,62.67 66.53,63.37 66.67,63.51 66.97,63.51 67.09,63.39 67.09,62.88 67.17,62.8 67.37,62.8 67.51,62.94 67.51,63.37 67.65,63.51 68.19,63.51 68.59,63.12 v2(68.66,63.12)
M_B_BS#1: length 162.6
  TOP w0.076: R269.2 30.47,85.38 v1(31.68,85.38) ; U4.N8 36.67,39.12 v1(36.3,39.48) ; v1(37.07,50.37) 36.26,51.19 36.26,51.75 36.67,52.16 U5.N8 ; v1(37.02,85.08) 37.02,85.15 36.26,85.91 36.26,86.48 36.67,86.89 U6.N8 ; U7.N8 36.67,73.59 36.26,73.18 36.26,72.61 v1(37.07,71.8)
  IN1 w0.089: v1(37.02,85.08) 37.48,85.08 37.77,84.78 37.77,78.16 37.36,77.74 37.36,76.99 37.06,76.7 37.06,76.22 36.76,75.91 36.76,73.66 36.64,73.54 36.64,72.23 v1(37.07,71.8) 37.34,71.8 37.46,71.68 37.46,71.46 37.27,71.28 37.27,71.11 37.46,70.92 37.46,67.99 38.01,67.43 38.01,63.18 38.19,63 38.52,63 38.64,62.88 38.64,60.34 38.18,59.87 38.18,59.66 38.07,59.55 37.86,59.55 37.77,59.46 37.77,59.21 37.85,59.12 38.09,59.12 38.18,59.03 38.18,58.91 38.09,58.83 37.85,58.83 37.77,58.74 37.77,56.51 37.63,56.37 37.43,56.37 37.36,56.29 37.36,55.57 37.06,55.28 37.06,54.79 36.76,54.49 36.76,52.23 36.64,52.12 36.64,50.8 v1(37.07,50.37) 37.44,50.75 37.91,50.75 38.16,50.5 38.16,46.18 36.89,44.91 36.89,42.45 37.46,41.88 37.46,41.08 37.58,40.96 37.58,38.98 37.49,38.89 37.03,38.89 36.94,38.8 36.94,38.62 37.03,38.53 37.49,38.53 37.58,38.44 37.58,38.19 37.45,38.06 36.43,38.06 36.31,38.19 36.31,39.48 v1(36.3,39.48)
  IN3 w0.089: v1(37.02,85.08) 36.99,85.1 31.97,85.1 v1(31.68,85.38)
  IN3 w0.14: v1(36.3,39.48) 36.48,39.31 36.48,38.81 36.34,38.67 35.95,38.67 35.82,38.53 35.82,38.24 36.05,38 36.84,38 36.94,38.1 36.94,38.9 37.25,39.2 37.25,41.21 37.02,41.44 36.69,41.44 36.35,41.78 36.35,43.13 36.22,43.25 35.94,43.25 35.44,43.75 35.44,44.69 33.05,47.09 33.05,51.82 32.71,52.16 32.71,53.43 32.83,53.55 33.28,53.55 33.4,53.68 33.4,53.85 33.28,53.97 32.83,53.97 32.71,54.09 32.71,54.7 32.95,54.95 33.46,54.95 33.75,55.23 33.75,56.14 33.63,56.26 33.46,56.26 33.34,56.39 33.34,56.56 33.46,56.68 33.6,56.68 33.72,56.81 33.72,56.98 33.6,57.1 33.46,57.1 33.34,57.22 33.34,57.85 34.21,58.72 34.21,59.16 37.04,61.99 37.04,62.74 37.79,63.49 38.6,63.49 39.09,63 39.64,63 39.92,62.72 49.4,62.72 49.52,62.59 49.52,62.06 49.65,61.94 49.82,61.94 49.94,62.06 49.94,62.59 50.06,62.72 50.61,62.72 50.79,62.53 50.79,61.87 51.64,61.02 52.18,61.02 52.3,60.9 52.3,60.85 52.42,60.72 52.6,60.72 52.72,60.85 52.72,60.9 52.84,61.02 54.46,61.02 54.58,61.14 54.58,61.58 54.67,61.68 57.9,61.68 58.15,61.43 58.15,61.02 57.95,60.83 55.24,60.83 55.1,60.69 55.1,60.55 55.27,60.39 58.11,60.39 59,61.28 59,61.84 60.82,63.66 65.29,63.66 65.44,63.51 66.51,63.51 66.87,63.15 67.24,63.15 67.36,63.27 67.36,63.77 67.59,64 69,64 69.1,63.9 69.1,63.71 69.2,63.61 69.41,63.61 69.51,63.71 69.51,63.9 69.62,64 69.83,64 69.93,63.9 69.93,63.71 70.03,63.61 70.25,63.61 70.35,63.71 70.35,63.9 70.45,64 70.79,64 70.86,63.93 70.86,63.62 70.46,63.21 v2(70.42,63.21)
  BOTTOM w0.076: v2(70.42,63.21) 70.35,63.21 69.99,62.84 69.99,62.75 70.05,62.69 70.54,62.69 70.67,62.81 70.82,62.81 70.95,62.69 71.1,62.69 71.23,62.81 71.38,62.81 71.51,62.69 72.41,62.69 72.63,62.91 74.57,62.91 74.6,62.94 74.83,62.94 75.09,62.84 75.24,62.84 U1.AJ36
M_B_CAS#: length 161.7
  TOP w0.076: R289.2 30.14,86.02 v1(31.68,86.02) ; U6.M8 v1(37.07,86.56) ; v1(37.78,36.92) 37.81,36.94 37.81,38.7 37.47,39.03 U4.M8 ; U7.M8 v1(37.07,73.26) ; U5.M8 v1(37.07,51.83)
  IN1 w0.089: v1(37.78,36.92) 38.16,36.54 39.14,36.54 39.71,37.11 39.71,37.48 39.63,37.57 39.52,37.57 39.43,37.65 39.43,37.78 39.52,37.86 39.63,37.86 39.71,37.95 39.71,38.07 39.63,38.15 39.52,38.15 39.43,38.24 39.43,38.36 39.52,38.44 39.63,38.44 39.71,38.53 39.71,38.78 39.43,39.06 38.58,39.06 37.84,39.8 37.84,41.07 37.71,41.2 37.71,41.67 37.9,41.86 37.9,42.06 37.15,42.81 37.15,44.81 38.42,46.08 38.42,51 37.59,51.83 v1(37.07,51.83) 37.01,51.88 37.01,54.38 37.32,54.68 37.32,55.17 37.61,55.46 37.61,55.99 37.74,56.12 37.9,56.12 38.02,56.25 38.02,58.28 38.1,58.36 38.19,58.36 38.43,58.6 38.43,59.76 38.9,60.23 38.9,63.31 38.8,63.41 38.34,63.41 38.26,63.49 38.26,63.63 38.34,63.71 38.82,63.71 38.9,63.79 38.9,63.9 38.82,63.98 38.34,63.98 38.26,64.05 38.26,64.22 38.39,64.35 38.39,64.5 38.26,64.63 38.26,67.54 37.71,68.09 37.71,72.07 37.5,72.27 37.5,72.67 37.71,72.88 37.71,73.13 37.45,73.39 37.21,73.39 v1(37.07,73.26) 37.01,73.31 37.01,75.81 37.32,76.11 37.32,76.6 37.61,76.89 37.61,77.64 38.02,78.05 38.02,85.85 37.32,86.56 v1(37.07,86.56)
  IN3 w0.089: v1(31.68,86.02) 32.4,86.02 32.88,85.53 36.05,85.53 v1(37.07,86.56)
  IN3 w0.14: v2(69.98,61.53) 69.58,61.93 68.26,61.93 67.91,62.27 62.6,62.27 62.47,62.15 62.47,61.52 62.35,61.4 62.18,61.4 62.06,61.52 62.06,62.15 61.93,62.27 61.76,62.27 61.64,62.15 61.64,62.01 61.51,61.89 61.34,61.89 61.22,62.01 61.22,62.15 61.09,62.27 60.67,62.27 60.53,62.13 60.53,61.77 59.87,61.11 59.87,60.68 57.92,58.73 54.57,58.73 54.06,59.24 50.76,59.24 50.63,59.36 50.63,60.79 50.36,61.06 47.06,61.06 46.3,61.82 39.58,61.82 39.27,62.13 38.53,62.13 38.31,61.91 38.2,61.91 36.71,60.42 36.71,57.84 36.52,57.64 36.22,57.64 36.03,57.45 36.03,56.35 35.39,55.71 35.39,54.82 34.96,54.38 34.96,54.03 35.08,53.91 35.91,53.91 36.03,53.79 36.03,53.62 35.91,53.49 35.08,53.49 34.96,53.37 34.96,53.2 35.08,53.07 35.91,53.07 36.03,52.95 36.03,52.78 35.91,52.65 35.08,52.65 34.96,52.53 34.96,52.36 35.08,52.24 35.91,52.24 36.03,52.11 36.03,51.94 35.91,51.82 35.08,51.82 34.96,51.69 34.96,51.52 35.08,51.4 35.91,51.4 36.03,51.27 36.03,51.1 35.91,50.98 35.08,50.98 34.96,50.86 34.96,50.68 35.08,50.56 35.91,50.56 36.03,50.44 36.03,50.26 35.91,50.14 35.08,50.14 34.96,50.02 34.96,49.84 35.08,49.72 35.32,49.72 35.45,49.6 35.45,49.42 35.32,49.3 35.08,49.3 34.96,49.18 34.96,48.89 36.82,47.03 36.82,46.49 36.69,46.36 36.68,46.36 36.56,46.24 36.56,46.07 36.68,45.94 36.69,45.94 36.82,45.82 36.82,45.65 36.69,45.52 35.89,45.52 35.77,45.4 35.77,45.23 35.89,45.11 36.69,45.11 36.82,44.98 36.82,44.81 36.69,44.69 36.25,44.69 36.13,44.56 36.13,44.39 36.25,44.27 36.69,44.27 36.82,44.14 36.82,43.93 36.88,43.86 36.88,42.57 37.52,41.93 37.52,40.54 37.9,40.17 37.9,39.68 37.77,39.56 37.62,39.56 37.5,39.44 37.5,39.26 37.62,39.14 37.77,39.14 37.9,39.02 37.9,38.85 37.77,38.72 37.42,38.72 37.3,38.6 37.3,38.43 37.42,38.3 37.77,38.3 37.9,38.18 37.9,38.01 37.77,37.88 37.42,37.88 37.3,37.76 37.3,37.59 37.42,37.47 37.77,37.47 37.9,37.34 37.9,37.03 v1(37.78,36.92)
  BOTTOM w0.076: v2(69.98,61.53) 69.74,61.76 69.74,61.97 69.8,62.03 70.03,62.03 70.19,61.86 70.33,61.86 70.5,62.03 72.79,62.03 73.12,61.7 73.52,61.7 73.63,61.81 74.9,61.81 74.97,61.78 75.2,61.78 75.27,61.81 75.55,61.81 75.63,61.78 75.82,61.78 75.9,61.81 76.14,61.81 U1.AK34
M_B_CKE0: length 146.7
  TOP w0.076: R272.2 42.15,95.69 41.44,94.98 40.47,94.98 v1(39.94,94.45) ; v1(39.47,57.43) 39.47,56.87 39.66,56.68 39.66,56.53 39.53,56.4 39.4,56.4 39.23,56.58 39.15,56.58 39.07,56.66 U5.K2 ; U4.K2 v1(38.67,44.28) ; U7.K2 v1(39.47,78.86) ; v1(39.47,91.36) U6.K2
  IN1 w0.089: v1(38.67,44.28) 38.95,44.28 39.18,44.06 39.18,42.83 39.29,42.72 39.49,42.72 39.81,43.04 39.81,51.93 39.57,52.17 39.04,52.17 38.28,52.93 38.28,53.85 39.93,55.5 39.93,56.97 v1(39.47,57.43) 39.73,57.43 39.86,57.57 39.86,58.07 40.17,58.38 40.17,68.08 39.98,68.27 39.33,68.27 38.98,68.62 38.98,69 39.1,69.12 40.14,69.12 40.3,69.28 40.3,70.04 40.13,70.2 39.06,70.2 38.98,70.28 38.98,73.66 38.28,74.36 38.28,75.28 39.93,76.92 39.93,78.4 v1(39.47,78.86) 40.17,79.56 40.17,82.98 39.57,83.58 39.57,85.72 39.94,86.09 39.94,87.49 39.51,87.91 39.51,88.84 39.66,88.99 39.66,90.42 39.8,90.56 40.46,90.56 40.55,90.64 40.55,90.77 40.46,90.85 39.91,90.85 39.82,90.94 39.82,91.06 39.91,91.14 40.46,91.14 40.55,91.23 40.55,91.35 40.46,91.44 40.15,91.44 40.07,91.52 40.07,91.78 39.98,91.86 39.84,91.86 39.47,91.49 v1(39.47,91.36)
  IN3 w0.089: v1(39.47,91.36) 38.8,92.03 38.8,93.31 v1(39.94,94.45) ; 77.21,65.11 82.36,65.11 82.63,65.39 82.63,69.33 82.55,69.41 81.47,69.41 81.38,69.5 81.38,69.62 81.47,69.71 81.72,69.71 81.8,69.79 81.8,69.92 81.72,70 81.47,70 81.38,70.08 81.38,70.2 81.47,70.29 81.69,70.29 81.78,70.38 81.78,70.51 81.71,70.58 80.95,70.58 v2(80.58,70.22)
  IN3 w0.14: v1(38.67,44.28) 38.92,44.53 38.92,52.39 39.03,52.49 39.03,53.59 39.41,53.97 39.41,55.27 39.03,55.65 39.03,57.59 39.18,57.74 39.18,58.04 39.36,58.22 39.77,58.22 40.32,58.77 47.28,58.77 50.37,55.69 53.01,55.69 53.4,55.3 57.87,55.3 60.1,57.53 60.1,57.93 60.79,58.62 64.79,58.62 65.1,58.93 68.36,58.93 69.89,60.46 71.41,60.46 72.84,61.89 72.84,62.37 75.5,65.04 76.16,65.04 76.54,65.42 76.78,65.42 77.09,65.11 77.21,65.11
  BOTTOM w0.079: v2(80.58,70.22) 80.34,70.46 U1.T28
M_B_CLKN0: length 162.1
  TOP w0.076: U4.K8 39.26,39.27 39.34,39.27 39.55,39.48 39.55,41.08 39.6,41.12 40.08,41.12 v1(40.27,40.93) ; v1(40.32,89.01) 40.31,89 39.6,89 39.55,88.95 39.55,87.35 39.34,87.14 39.26,87.14 U6.K8
  TOP w0.102: R266.1 30.03,87.83 30.44,87.83 C310.1 31,87.93 31.68,87.93 v1(31.68,87.94) ; U5.K8 v1(39.47,52.63) ; U7.K8 v1(39.47,74.06)
  IN1 w0.089: v1(40.27,40.93) 40.27,41.17 40.19,41.24 39.81,41.24 39.59,41.46 39.59,42.13 40.42,42.96 40.42,44.59 41.02,45.19 41.02,46.06 41.22,46.26 42.76,46.26 42.87,46.37 42.87,46.69 42.76,46.8 41.22,46.8 41.02,47 41.02,47.92 41.26,48.16 42.73,48.16 42.99,48.41 42.99,49.96 42.81,50.14 42.15,50.14 41.93,49.91 41.93,49.24 41.69,49 41.23,49 40.97,49.26 40.97,49.71 40.7,49.98 40.7,52.02 40.41,52.31 40.41,52.44 39.97,52.88 39.72,52.88 v1(39.47,52.63) 39.17,52.93 38.98,52.93 38.74,53.17 38.74,53.68 40.36,55.3 40.36,57.82 40.68,58.14 40.68,70.99 40.19,71.47 40.19,74.15 39.98,74.36 39.77,74.36 v1(39.47,74.06) 39.14,74.39 38.93,74.39 38.72,74.6 38.72,75.13 40.4,76.8 40.4,79.32 40.65,79.57 40.65,83.59 40.4,83.85 40.4,88.37 40.83,88.8 40.83,89.12 40.71,89.24 40.55,89.24 v1(40.32,89.01)
  IN3 w0.089: v1(31.68,87.94) 31.91,88.16 32.03,88.16 32.32,87.87 32.32,87.62 33.08,86.85 36,86.85 37.02,87.87 38.42,87.87 39.78,89.24 40.1,89.24 v1(40.32,89.01) ; v2(80.02,64.65) 79.85,64.48 79.69,64.48 79.56,64.34 76.38,64.34 76.33,64.39 76.31,64.39
  IN3 w0.14: v1(40.27,40.93) 39.57,41.63 39.57,42.23 39.78,42.44 39.78,42.98 39.47,43.28 39.47,43.67 39.78,43.98 39.78,44.42 39.57,44.63 39.57,47.82 39.87,48.12 40.7,48.12 40.85,48.27 40.85,48.65 40.66,48.84 39.73,48.84 39.57,49 39.57,52.12 39.94,52.48 39.94,53.56 40.38,54.01 40.38,54.21 40.05,54.54 40.05,56.12 39.67,56.5 39.67,57.03 40.05,57.41 40.05,57.5 40.68,58.13 47.01,58.13 48.22,56.92 48.22,55.8 48.53,55.49 49.39,55.49 49.81,55.06 49.89,55.06 50.41,54.54 50.41,54.46 50.81,54.07 51.13,54.07 51.77,54.71 52.28,54.71 52.95,54.04 53.47,54.04 53.85,54.42 57.35,54.42 57.77,54 58.24,54 59,54.76 59,55.52 59.27,55.79 60.06,55.79 60.26,55.59 60.58,55.59 60.75,55.75 60.75,57.66 61.06,57.97 61.72,57.97 61.98,57.71 61.98,55.65 62.15,55.48 62.44,55.48 62.66,55.7 62.66,57.68 62.96,57.97 63.6,57.97 63.89,57.68 63.89,56.31 64.03,56.18 64.46,56.18 64.7,56.41 64.7,56.79 65.07,57.16 65.07,57.99 65.37,58.29 68.65,58.29 70.17,59.8 71.67,59.8 73.71,61.84 73.71,62.33 75.77,64.39 76.31,64.39
  BOTTOM w0.079: v2(80.02,64.65) 80.34,64.32 U1.AF28
M_B_CLKP0: length 164
  TOP w0.076: v1(40.32,89.65) 40.14,89.65 40.04,89.55 40.04,89.33 39.88,89.16 39.53,89.16 39.39,89.02 39.39,87.42 39.27,87.31 39.17,87.31 39.07,87.41 U6.K7 ; U4.K7 39.07,39.53 39.17,39.43 39.27,39.43 39.39,39.54 39.39,41.14 39.53,41.29 40.04,41.29 40.27,41.52 v1(40.27,41.77)
  TOP w0.102: v1(39.47,74.86) 39.32,75.01 39.09,75.01 38.94,74.86 38.94,74.59 U7.K7 ; U5.K7 38.94,53.16 38.94,53.43 39.09,53.58 39.32,53.58 v1(39.47,53.43) ; v1(31.68,88.57) 31.31,88.2 30.86,88.2 C310.2 30.38,88.1 29.99,88.1 R265.1
  IN1 w0.089: v1(40.32,89.65) 40.52,89.44 40.79,89.44 41.03,89.2 41.03,88.72 40.6,88.29 40.6,83.93 40.85,83.68 40.85,79.49 40.6,79.23 40.6,76.72 38.92,75.04 38.92,74.68 39.01,74.59 39.21,74.59 v1(39.47,74.86) 39.77,74.56 40.07,74.56 40.4,74.23 40.4,71.56 40.88,71.07 40.88,58.06 40.56,57.74 40.56,55.22 38.94,53.6 38.94,53.25 39.07,53.13 39.17,53.13 v1(39.47,53.43) 39.82,53.08 40.05,53.08 40.61,52.52 40.61,52.4 40.91,52.11 40.91,50.06 41.18,49.79 41.18,49.34 41.32,49.2 41.6,49.2 41.72,49.33 41.72,50 42.07,50.34 42.89,50.34 43.19,50.04 43.19,48.33 42.82,47.95 41.34,47.95 41.22,47.83 41.22,47.09 41.3,47.01 42.84,47.01 43.08,46.77 43.08,46.29 42.84,46.06 41.3,46.06 41.22,45.97 41.22,45.1 40.63,44.5 40.63,42.88 39.79,42.05 39.79,41.54 39.89,41.45 40.18,41.45 40.27,41.53 v1(40.27,41.77)
  IN3 w0.089: v2(80.03,63.92) 80.03,64.19 79.92,64.3 79.77,64.3 79.63,64.16 76.38,64.16 76.33,64.12 76.31,64.12 ; v1(31.68,88.57) 31.91,88.35 32.11,88.35 32.51,87.95 32.51,87.7 33.16,87.04 35.92,87.04 36.94,88.06 38.34,88.06 39.7,89.43 40.1,89.43 v1(40.32,89.65)
  IN3 w0.14: 76.31,64.12 75.88,64.12 73.98,62.22 73.98,61.73 71.78,59.54 70.28,59.54 68.76,58.02 65.48,58.02 65.34,57.88 65.34,57.05 64.96,56.68 64.96,56.3 64.57,55.91 63.92,55.91 63.63,56.2 63.63,57.57 63.49,57.71 63.07,57.71 62.93,57.57 62.93,55.59 62.55,55.21 62.04,55.21 61.71,55.54 61.71,57.6 61.61,57.71 61.17,57.71 61.01,57.55 61.01,55.64 60.69,55.32 60.15,55.32 59.95,55.52 59.38,55.52 59.27,55.41 59.27,54.65 58.35,53.73 57.66,53.73 57.24,54.15 53.96,54.15 53.58,53.77 52.84,53.77 52.17,54.44 51.88,54.44 51.24,53.8 50.7,53.8 50.15,54.35 50.15,54.43 49.78,54.8 49.7,54.8 49.28,55.22 48.42,55.22 47.95,55.69 47.95,56.81 46.9,57.86 40.79,57.86 40.32,57.39 40.32,57.3 39.94,56.92 39.94,56.61 40.32,56.23 40.32,54.65 40.65,54.32 40.65,53.9 40.21,53.45 40.21,52.37 39.84,52.01 39.84,49.11 39.84,49.11 40.77,49.11 41.11,48.76 41.11,48.16 40.81,47.85 39.98,47.85 39.84,47.71 39.84,44.74 40.05,44.53 40.05,43.87 39.74,43.56 39.74,43.39 40.05,43.09 40.05,42.33 39.84,42.12 39.84,41.77 40.02,41.59 40.09,41.59 v1(40.27,41.77)
  BOTTOM w0.079: U1.AF29 79.93,64.29 80.07,64.15 80.07,63.96 v2(80.03,63.92)
M_B_CS#0: length 158.9
  TOP w0.076: U5.L7 38.47,53.23 38.47,54.49 v1(38.03,54.93) ; U6.L7 38.44,87.93 38.44,89.06 v1(38.37,89.14) ; U7.L7 38.47,74.65 38.47,75.92 v1(38.03,76.35) ; v1(38.67,94.47) 40.22,96.02 R273.2 ; U4.L7 38.53,39.88 39.06,40.41 39.06,40.85 38.96,40.96 38.86,40.96 38.76,40.85 38.76,40.51 38.51,40.26 37.92,40.26 37.74,40.44 37.74,40.72 37.9,40.88 38.16,40.88 v1(38.29,40.75)
  IN1 w0.089: v1(38.29,40.75) 38.29,39.72 38.66,39.35 39.19,39.35 39.28,39.43 39.28,39.97 39.37,40.05 39.76,40.05 39.84,40.14 39.84,40.26 39.76,40.35 39.37,40.35 39.28,40.43 39.28,41.44 37.65,43.06 37.65,44.6 38.3,45.24 38.84,45.24 39.05,45.45 39.05,51.09 37.52,52.61 37.52,54.17 38.03,54.68 v1(38.03,54.93) 38.28,54.93 38.77,55.42 38.77,55.69 38.69,55.77 38.62,55.77 38.54,55.84 38.54,55.95 38.62,56.03 38.69,56.03 38.77,56.11 38.77,56.22 38.69,56.3 38.62,56.3 38.54,56.38 38.54,56.49 38.62,56.57 38.69,56.57 38.77,56.64 38.77,56.8 38.53,57.04 38.53,57.89 39.03,58.38 39.03,59.42 39.15,59.55 39.32,59.55 39.41,59.64 39.41,65.4 39.21,65.59 38.91,65.59 38.77,65.73 38.77,67.75 38.22,68.3 38.22,73.34 37.52,74.04 37.52,75.6 38.03,76.11 v1(38.03,76.35) 38.77,77.09 38.77,78.22 38.53,78.47 38.53,79.24 38.75,79.46 38.75,79.96 38.67,80.04 38.62,80.04 38.53,80.13 38.53,80.25 38.62,80.34 38.96,80.34 39.04,80.42 39.04,80.54 38.96,80.63 38.62,80.63 38.53,80.71 38.53,80.83 38.62,80.92 38.67,80.92 38.75,81.01 38.75,81.13 38.67,81.21 38.62,81.21 38.53,81.3 38.53,81.42 38.62,81.5 39.01,81.5 39.09,81.59 39.09,81.71 39.01,81.8 38.62,81.8 38.53,81.88 38.53,82 38.62,82.09 39.32,82.09 39.41,82.17 39.41,82.29 39.32,82.38 38.62,82.38 38.53,82.47 38.53,82.59 38.62,82.67 39.01,82.67 39.09,82.76 39.09,82.88 39.01,82.96 38.62,82.96 38.53,83.05 38.53,83.17 38.62,83.26 38.67,83.26 38.75,83.34 38.75,83.46 38.67,83.55 38.62,83.55 38.53,83.63 38.53,83.76 38.62,83.84 38.67,83.84 38.75,83.93 38.75,84.05 38.67,84.13 38.62,84.13 38.53,84.22 38.53,84.34 38.62,84.43 38.67,84.43 38.75,84.51 38.75,84.63 38.67,84.72 38.62,84.72 38.53,84.8 38.53,84.92 38.62,85.01 38.67,85.01 38.75,85.09 38.75,85.22 38.67,85.3 38.62,85.3 38.53,85.39 38.53,85.51 38.62,85.59 38.67,85.59 38.75,85.68 38.75,85.93 38.52,86.16 38.52,86.94 38.71,87.12 38.71,87.38 38.62,87.46 38.61,87.46 38.52,87.55 38.52,87.67 38.61,87.75 38.62,87.75 38.71,87.84 38.71,87.96 38.62,88.05 38.61,88.05 38.52,88.13 38.52,88.25 38.61,88.34 38.62,88.34 38.71,88.42 38.71,89.1 38.67,89.14 v1(38.37,89.14)
  IN3 w0.089: v1(38.67,94.47) 37.4,93.2 37.4,91.95 37.72,91.63 37.72,91.61 38.77,90.56 38.77,89.55 v1(38.37,89.14)
  IN3 w0.14: v2(68.81,61.53) 68.81,60.58 68.44,60.21 68.21,60.21 68.09,60.33 68.09,60.62 67.96,60.75 67.79,60.75 67.67,60.62 67.67,60.33 67.55,60.21 67.37,60.21 67.25,60.33 67.25,60.78 67.13,60.9 66.95,60.9 66.83,60.78 66.83,60.33 66.71,60.21 66.53,60.21 66.41,60.33 66.41,60.64 66.29,60.76 66.11,60.76 65.99,60.64 65.99,60.33 65.87,60.21 65.14,60.21 64.42,59.5 60.43,59.5 59.22,58.29 59.22,57.89 58.29,56.96 55.14,56.96 54.74,56.56 50.73,56.56 49.95,57.34 49.95,58.19 49.36,58.78 48.72,58.78 47.7,59.8 46.54,59.8 45.99,60.36 39.73,60.36 38,58.63 38,56.69 37.26,55.96 37.26,54.42 37.51,54.18 37.91,54.18 38.05,54.04 38.05,45.03 37.68,44.66 37.68,43.04 38.44,42.28 38.49,42.28 39.05,41.72 39.05,41.23 39.64,40.65 39.64,39.84 39.46,39.66 39.3,39.66 39.15,39.81 39.15,40.4 38.8,40.75 v1(38.29,40.75)
  BOTTOM w0.076: v2(68.81,61.53) 68.81,61.24 68.86,61.19 68.86,60.21 68.91,60.16 69.06,60.16 69.14,60.23 69.14,61.02 69.21,61.1 69.34,61.1 69.42,61.02 69.42,60.23 69.49,60.16 69.62,60.16 69.7,60.23 69.7,61.02 69.77,61.1 69.9,61.1 69.98,61.02 69.98,60.23 70.05,60.16 70.17,60.16 70.25,60.25 70.25,61.31 70.45,61.5 70.45,61.64 70.67,61.86 72.72,61.86 73.05,61.53 73.64,61.53 73.74,61.64 73.99,61.64 74.22,61.42 74.36,61.42 74.41,61.47 74.41,61.56 74.49,61.64 74.66,61.64 74.74,61.56 U1.AL37
M_B_DIM0_ODT0: length 156.5
  TOP w0.076: v1(39.47,59.02) 38.7,58.24 38.7,56.6 U5.K3 ; v1(39.47,80.44) 38.7,79.67 38.7,78.33 39.07,77.96 U7.K3 ; v1(38.66,42.67) 38.66,42.92 38.81,43.08 U4.K3 ; U6.K3 39.04,90.96 38.67,91.33 v1(38.67,91.35) ; v1(39.3,94.47) 40.11,95.27 40.96,95.27 41.18,95.5 R291.2
  IN1 w0.089: v1(38.67,91.35) 38.92,91.61 38.92,93.41 39.06,93.55 40.74,93.55 40.88,93.69 40.88,93.83 40.74,93.97 38.45,93.97 38.3,93.82 38.3,91.95 38.16,91.81 38.16,91.17 38.78,90.55 38.78,90.13 38.96,89.95 38.96,87.02 38.78,86.83 38.78,86.27 39.06,85.99 39.06,83.37 39.66,82.76 39.66,80.63 v1(39.47,80.44) 39.47,79.82 38.78,79.13 38.78,78.57 39.03,78.33 39.03,76.74 37.78,75.49 37.78,74.15 38.47,73.45 38.47,68.41 39.03,67.85 39.03,66.14 39.66,65.5 39.66,59.21 v1(39.47,59.02) 39.47,58.42 38.78,57.73 38.78,57.14 39.03,56.9 39.03,55.31 37.78,54.06 37.78,52.72 39.3,51.19 39.3,45.35 38.93,44.97 38.39,44.97 37.99,44.57 37.99,43.34 v1(38.66,42.67)
  IN3 w0.089: v1(39.3,94.47) 38.42,93.59 38.42,91.6 v1(38.67,91.35)
  IN3 w0.14: v2(70.81,61.5) 70.81,61.77 70.95,61.9 71.89,61.9 72.2,62.22 72.2,62.58 72.06,62.72 71.41,62.72 71.28,62.59 71.28,62.41 71.16,62.29 70.99,62.29 70.86,62.41 70.86,62.59 70.74,62.72 70.51,62.72 70.41,62.62 70.41,61.38 70.07,61.04 69.68,61.04 68.55,59.92 68.24,59.92 68.11,59.79 68.11,59.64 67.99,59.52 67.82,59.52 67.69,59.64 67.69,59.79 67.57,59.92 67.4,59.92 67.27,59.79 67.27,59.64 67.15,59.52 66.98,59.52 66.86,59.64 66.86,59.79 66.73,59.92 66.56,59.92 66.44,59.79 66.44,59.64 66.31,59.52 66.14,59.52 66.02,59.64 66.02,59.79 65.89,59.92 65.72,59.92 65.6,59.79 65.6,59.64 65.48,59.52 64.86,59.52 64.55,59.21 60.55,59.21 59.51,58.17 59.51,57.77 58.29,56.55 57.97,56.55 57.85,56.67 57.67,56.67 57.55,56.55 57.55,56.01 57.43,55.89 57.25,55.89 57.13,56.01 57.13,56.55 57.01,56.67 55.26,56.67 54.99,56.41 54.99,56.06 54.85,55.92 54.66,55.92 54.52,56.06 54.52,56.15 54.39,56.27 54.14,56.27 54.02,56.15 54.02,56.01 53.89,55.89 53.72,55.89 53.6,56.01 53.6,56.15 53.48,56.27 50.61,56.27 49.66,57.22 49.66,58.07 49.24,58.49 48.6,58.49 47.63,59.46 46.2,59.46 46,59.66 46,59.86 45.84,60.02 40.74,60.02 40.63,59.9 40.63,59.6 40.5,59.48 40.3,59.48 40.16,59.62 40.16,59.83 40.03,59.97 39.76,59.97 39.04,59.26 39.04,58.91 38.9,58.76 38.61,58.76 38.34,58.49 38.34,58.32 38.48,58.18 38.48,58.01 38.34,57.87 38.34,56.15 38.21,56.02 37.81,56.02 37.6,55.82 37.6,54.57 37.71,54.47 38.12,54.47 38.34,54.25 38.34,44.89 37.95,44.5 37.95,43.15 38.09,43.01 38.52,43.01 38.66,42.87 v1(38.66,42.67)
  BOTTOM w0.076: U1.AL36 75.24,61.23 75.14,61.23 74.83,61.13 74.22,61.13 73.99,61.37 73.58,61.37 73.52,61.3 73.52,61.14 73.46,61.09 73.3,61.09 73.24,61.15 73.24,61.3 73.17,61.37 73.03,61.37 72.96,61.29 72.96,60.88 72.88,60.8 72.75,60.8 72.68,60.88 72.68,61.62 72.6,61.7 72.48,61.7 72.4,61.62 72.4,60.88 72.32,60.8 72.2,60.8 72.12,60.88 72.12,61.62 72.04,61.7 71.92,61.7 71.84,61.62 71.84,60.88 71.76,60.8 71.64,60.8 71.56,60.88 71.56,61.05 71.47,61.14 71.35,61.14 71.28,61.07 71.28,60.61 71.22,60.55 71.07,60.55 71,60.62 71,61.05 70.94,61.11 70.79,61.11 70.72,61.05 70.72,60.36 70.66,60.3 70.51,60.3 70.44,60.36 70.44,61.24 70.71,61.5 v2(70.81,61.5)
M_B_DQ0: length 51.2
  TOP w0.102: U6.A3 46.65,90.58 46.65,89.53 v1(46.6,89.49)
  IN3 w0.089: v1(46.6,89.49) 46.76,89.33 47.18,89.33 47.5,89.01 49.2,89.01 50.09,88.12 50.09,87.93 51.77,86.24 61.84,86.24 61.92,86.16 61.92,85.95 62.01,85.86 62.19,85.86 62.28,85.95 62.28,86.16 62.37,86.24 62.55,86.24 62.64,86.16 62.64,85.95 62.72,85.86 62.9,85.86 62.99,85.95 62.99,86.16 63.08,86.24 63.26,86.24 63.35,86.16 63.35,85.95 63.44,85.86 66.18,85.86 68.55,83.49 74.26,83.49 74.83,82.92 75.14,82.92 75.45,82.61 78.06,82.61 78.7,81.97 78.7,81.11 79.78,80.02 80.27,80.02 80.84,79.45 83.04,79.45 84.59,77.89 84.59,75.33 v2(83.48,74.21)
  BOTTOM w0.079: v2(83.48,74.21) 83.48,74.24 U1.J22
M_B_DQ1: length 53.8
  TOP w0.102: U6.C8 v1(45.07,86.56)
  IN3 w0.089: v1(45.07,86.56) 45.47,86.16 45.47,85.4 45.38,85.31 44.22,85.31 44.13,85.22 44.13,85.07 44.25,84.95 45.38,84.95 45.47,84.86 45.47,84.68 45.38,84.6 44.22,84.6 44.13,84.51 44.13,84.35 44.25,84.24 44.49,84.24 44.58,84.15 44.58,83.95 44.66,83.86 44.84,83.86 44.93,83.95 44.93,84.15 45.02,84.24 45.3,84.24 45.59,83.94 49,83.94 49.71,83.24 50.11,83.24 50.2,83.15 50.2,82.75 50.31,82.63 50.46,82.63 50.55,82.72 50.55,83.15 50.64,83.24 50.82,83.24 50.91,83.15 50.91,82.75 51.02,82.63 51.17,82.63 51.26,82.72 51.26,83.15 51.35,83.24 52.94,83.24 53.03,83.15 53.03,82.73 53.12,82.63 53.29,82.63 53.38,82.72 53.38,83.15 53.47,83.24 53.65,83.24 53.74,83.15 53.74,82.73 53.83,82.63 54.01,82.63 54.09,82.72 54.09,83.15 54.18,83.24 57.07,83.24 57.68,82.63 58.67,82.63 59.49,81.81 66.68,81.81 67.7,80.79 73.52,80.79 73.88,80.43 75.3,80.43 76.13,79.59 76.44,79.59 77.13,78.9 78.19,78.9 79.08,78.01 79.84,78.01 80.19,77.67 80.19,76.94 81.14,75.98 81.14,75.37 81.42,75.1 v2(81.52,75.1)
  BOTTOM w0.079: U1.H25 81.84,75.42 v2(81.52,75.1)
M_B_DQ2: length 50.6
  TOP w0.102: U6.C3 44.67,89.65 v1(45.04,89.28)
  IN3 w0.089: v1(45.04,89.28) 45.48,88.85 46.98,88.85 47.3,88.52 49,88.52 49.6,87.92 49.6,87.73 51.57,85.76 60.72,85.76 60.81,85.67 60.81,85.45 60.9,85.36 61.08,85.36 61.16,85.45 61.16,85.67 61.25,85.76 61.43,85.76 61.52,85.67 61.52,85.45 61.61,85.36 65.86,85.36 68.22,83.01 74.06,83.01 74.81,82.26 77.91,82.26 78.34,81.82 78.34,80.96 79.64,79.67 80.12,79.67 80.71,79.08 82.73,79.08 84.11,77.69 84.11,75.86 83.64,75.39 v2(83.45,75.39)
  BOTTOM w0.079: U1.G22 84,75.94 v2(83.45,75.39)
M_B_DQ3: length 51.1
  TOP w0.102: v1(45.75,89.25) 45.07,89.93 45.07,91.36 U6.C2
  IN3 w0.089: v2(83.48,74.81) 83.48,74.81 84.35,75.69 84.35,77.79 82.89,79.26 80.78,79.26 80.2,79.84 79.71,79.84 78.52,81.03 78.52,81.9 77.98,82.43 74.98,82.43 74.16,83.25 68.32,83.25 65.97,85.61 61.93,85.61 61.53,86 51.67,86 49.85,87.83 49.85,88.02 49.1,88.77 47.4,88.77 47.08,89.09 45.91,89.09 v1(45.75,89.25)
  BOTTOM w0.079: U1.H22 84,75.35 83.48,74.83 v2(83.48,74.81)
M_B_DQ4: length 54
  TOP w0.102: U6.B8 v1(45.87,86.56)
  IN3 w0.089: v1(45.87,86.56) 46.27,86.16 46.27,85.05 46.18,84.96 45.85,84.96 45.76,84.87 45.76,84.69 45.85,84.6 46.18,84.6 46.27,84.51 46.27,84.27 46.36,84.18 46.6,84.18 46.69,84.27 46.69,84.4 46.78,84.49 46.96,84.49 47.05,84.4 47.05,84.27 47.13,84.18 47.31,84.18 47.4,84.27 47.4,84.4 47.49,84.49 47.67,84.49 47.76,84.4 47.76,84.27 47.85,84.18 48.02,84.18 48.11,84.27 48.11,84.4 48.2,84.49 48.38,84.49 48.47,84.4 48.47,84.27 48.56,84.18 49.18,84.18 49.88,83.48 50.3,83.48 50.39,83.57 50.39,84.07 50.48,84.16 50.63,84.16 50.75,84.05 50.75,83.57 50.84,83.48 57.86,83.48 57.95,83.39 57.95,82.98 58.06,82.87 58.22,82.87 58.3,82.96 58.3,83.39 58.39,83.48 58.57,83.48 58.66,83.39 58.66,82.98 58.77,82.87 58.93,82.87 59.02,82.96 59.02,83.39 59.1,83.48 59.35,83.48 59.53,83.3 59.53,82.2 59.67,82.05 59.83,82.05 59.92,82.14 59.92,82.32 60.01,82.41 60.19,82.41 60.28,82.32 60.28,82.14 60.36,82.05 60.54,82.05 60.63,82.14 60.63,83.39 60.72,83.48 60.9,83.48 60.99,83.39 60.99,82.14 61.08,82.05 61.25,82.05 61.34,82.14 61.34,83.37 61.43,83.46 61.61,83.46 61.7,83.37 61.7,82.14 61.79,82.05 66.78,82.05 67.8,81.03 73.66,81.03 74.09,80.61 75.37,80.61 76.21,79.77 76.51,79.77 77.2,79.08 78.27,79.08 79.03,78.32 79.79,78.32 80.55,77.55 80.55,77.05 81.28,76.32 v2(81.48,76.32)
  BOTTOM w0.102: v2(81.48,76.32) 81.51,76.32 81.9,76.72 U1.F25
