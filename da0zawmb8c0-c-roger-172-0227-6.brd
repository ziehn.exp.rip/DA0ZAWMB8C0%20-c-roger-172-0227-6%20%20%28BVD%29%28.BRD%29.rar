# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Nets (continued)
PCH_SPI_IO2: R110.2 R220.1 U1.CF34
PCH_SPI_IO3: R109.1 U1.CG34
PCH_SUSPWRDNACK: R39.2 U37.15
PCH_TYPEC_UPFB#: Q6505.1(S) R202.1 R25480.1 U1.CP7
PCIE_CLKREQ_LAN#: Q6531.3 R155.1 R25444.1 R25446.1 U1.CE30
PCIE_CLKREQ_SSD#: CN16.52 R159.1 U1.CE32
PCIE_CLKREQ_VGA#: Q9.3 R25487.1 R25493.1 U1.CF32
PCIE_CLKREQ_WLAN#: Q63.3 R154.1 U1.CF31
PCIE_RCOMP: R139.2 U1.CE6
PCIE_RCOMP_P: R139.1 U1.CE5
PCIE_REQ_LAN#_R: Q6531.1(S) R25445.1 R25446.2 U24.12
PCIE_RXN9_LAN: C637.2 U1.BP5
PCIE_RXN10_WLAN: CN17.43 U1.BN6
PCIE_RXN13_SSD: R2652.1 U1.BK6
PCIE_RXN13_SSD_C: CN16.5 R2652.2
PCIE_RXN14_SSD: R2654.1 U1.BJ6
PCIE_RXN14_SSD_C: CN16.17 R2654.2
PCIE_RXN15_SSD: R2656.1 U1.BG5
PCIE_RXN15_SSD_C: CN16.29 R2656.2
PCIE_RXN16_SSD: R646.1 U1.BE5
PCIE_RXN16_SSD_C: CN16.43 R646.2
PCIE_RXN_LAN_L: C637.1 U24.18
PCIE_RXP9_LAN: C640.2 U1.BP6
PCIE_RXP10_WLAN: CN17.41 U1.BN5
PCIE_RXP13_SSD: R2653.1 U1.BK5
PCIE_RXP13_SSD_C: CN16.7 R2653.2
PCIE_RXP14_SSD: R2655.1 U1.BJ5
PCIE_RXP14_SSD_C: CN16.19 R2655.2
PCIE_RXP15_SSD: R2657.1 U1.BG6
PCIE_RXP15_SSD_C: CN16.31 R2657.2
PCIE_RXP16_SSD: R647.1 U1.BE6
PCIE_RXP16_SSD_C: CN16.41 R647.2
PCIE_RXP_LAN_L: C640.1 U24.17
PCIE_TXN9_LAN: C200.2 U24.14
PCIE_TXN9_LAN_C: C200.1 U1.BR2
PCIE_TXN10_WLAN: C203.2 U1.BR4
PCIE_TXN10_WLAN_C: C203.1 CN17.37
PCIE_TXN13_SSD: C788.1 U1.BM4
PCIE_TXN13_SSD_C: C788.2 CN16.11
PCIE_TXN14_SSD: C790.1 U1.BL2
PCIE_TXN14_SSD_C: C790.2 CN16.23
PCIE_TXN15_SSD: C792.1 U1.BL4
PCIE_TXN15_SSD_C: C792.2 CN16.35
PCIE_TXN16_SSD: C794.1 U1.BJ4
PCIE_TXN16_SSD_C: C794.2 CN16.47
PCIE_TXP9_LAN: C201.2 U24.13
PCIE_TXP9_LAN_C: C201.1 U1.BR1
PCIE_TXP10_WLAN: C202.2 U1.BR3
PCIE_TXP10_WLAN_C: C202.1 CN17.35
PCIE_TXP13_SSD: C789.1 U1.BM3
PCIE_TXP13_SSD_C: C789.2 CN16.13
PCIE_TXP14_SSD: C791.1 U1.BL1
PCIE_TXP14_SSD_C: C791.2 CN16.25
PCIE_TXP15_SSD: C793.1 U1.BL3
PCIE_TXP15_SSD_C: C793.2 CN16.37
PCIE_TXP16_SSD: C795.1 U1.BJ3
PCIE_TXP16_SSD_C: C795.2 CN16.49
PCIE_WAKE#: EC13.1 Q33.3 R33.1 R513.1 U1.BU30
PCIE_WAKE#_R: R513.2 U24.21
PD#: C595.1 D12.2 D13.2 R478.1 R479.1 U20.47
PEDET: CN16.69 Q34.2 R649.2 R654.2
PEG_RXN5: C358.1 U1.BW9
PEG_RXN5_C: C358.2 U8.AB9
PEG_RXN6: C384.1 U1.BU6
PEG_RXN6_C: C384.2 U8.AC10
PEG_RXN7: C6554.1 U1.BT7
PEG_RXN7_C: C6554.2 U8.AC11
PEG_RXN8: C6557.1 U1.BU9
PEG_RXN8_C: C6557.2 U8.AB12
PEG_RXP5: C370.1 U1.BW8
PEG_RXP5_C: C370.2 U8.AC9
PEG_RXP6: C382.1 U1.BU5
PEG_RXP6_C: C382.2 U8.AB10
PEG_RXP7: C6556.1 U1.BT6
PEG_RXP7_C: C6556.2 U8.AD11
PEG_RXP8: C6555.1 U1.BU8
PEG_RXP8_C: C6555.2 U8.AC12
PEG_TXN5: C192.2 U8.AG7
PEG_TXN5_C: C192.1 U1.BW4
PEG_TXN6: C194.2 U8.AE7
PEG_TXN6_C: C194.1 U1.BU4
PEG_TXN7: C6551.2 U8.AF9
PEG_TXN7_C: C6551.1 U1.BU2
PEG_TXN8: C6550.2 U8.AG10
PEG_TXN8_C: C6550.1 U1.BT4
PEG_TXP5: C193.2 U8.AG6
PEG_TXP5_C: C193.1 U1.BW3
PEG_TXP6: C195.2 U8.AF7
PEG_TXP6_C: C195.1 U1.BU3
PEG_TXP7: C6553.2 U8.AE9
PEG_TXP7_C: C6553.1 U1.BU1
PEG_TXP8: C6552.2 U8.AG9
PEG_TXP8_C: C6552.1 U1.BT3
PEGX_RST#: R296.1 R305.1 R306.2 R384.2
PEGX_RST#_C: R305.2 U9.4
PEX_CLKREQ#: Q9.1(S) R297.1 R25487.2 U8.AC6
PEX_TERMP: R312.2 U8.AF25
PEX_TSTCLK: R307.2 U8.AF22
PEX_TSTCLK#: R307.1 U8.AE22
PHASE1_CORE: PC7105.1 PL7000.1 PQ7000.5 PQ7000.6 PQ7000.7 PR7072.2 PR7073.1 PU7002.2
PHASE2_CORE: PC7056.1 PL7001.1 PQ7001.5 PQ7001.6 PQ7001.7 PR7081.2 PR7082.1 PU7001.2
PHASE_GT: PC7101.1 PL7003.1 PQ7004.5 PQ7004.6 PQ7004.7 PR7095.2 PR7096.1 PU7003.2
PHASE_SA: PC7103.1 PL7002.1 PQ7002.1 PQ7002.2 PQ7002.3(S3) PQ7003.5 PR7087.2 PR7088.1 PU7004.2
PIRQA#: R179.1 R580.1 R593.1 U1.CC32
PLTRST#: R56.2 R601.1 R648.2 R894.1 R2665.2 U1.BJ35 U9.2 U24.19
PLTRST#_EC: C2374.1 R894.2 U37.22
PM_EXTTS#0: JDIM1.134 R224.2
PMON: PC18.2 PR23.1 PR25.1 PR7039.1
PP: R600.2 U33.4
PROC_POPIRCOMP: R16.1 U1.BP27
PROC_TRST#: R6.2 U1.AB6
PROCHOT#: R9.2 U1.Y4
PROCHOT_EC: C6610.2 Q6509.2 R25298.2 U37.17
PROCPWRGD: C6619.1 R34.2 U1.AR2
PS_FB_CLAMP: R313.1 U8.F3
PTP_PWR_EN#: TP9019.1 U37.125
PULSAR_38P4M_REFCLK: CN17.64 L1.1
PULSAR_38P4M_REFCLK_R: C204.2 L1.2 R148.2 U1.CM3
PWM1_CORE: PR7105.1 PU7000.17
PWM2_CORE: PR7077.1 PU7000.16
PWM-VID: PR9015.1 R370.1
PWM_GT: PR7109.1 PU7000.22
PWM_SA: PR7113.1 PU7000.36
PWR_DEBUG: R218.2 TP43.1
PWRLED#: CN35.22 U37.24
R_SPK+: R480.1 U20.45
R_SPK+_1: C601.1 CN36.1 R480.2
R_SPK-: R481.1 U20.44
R_SPK-_1: C602.1 CN36.2 R481.2
RAM_ID0: R25378.2 R25381.1 U1.CN22
RAM_ID1: R25379.2 R25382.1 U1.CR22
RAM_ID2: R25380.2 R25383.1 U1.CM22
RAM_ID3: R25384.1 R25385.2 U1.CP22
REGN6V: PC9.1 PR39.1 PU1.24
REQ_WLAN#: CN17.53 Q63.1(S) R652.1
RF_EN: CN17.56 R672.1 R25318.2 R25494.1
RF_OFF_PCH: R37.1 U1.BV36
RGND_CORE: PC7008.1 PC7009.1 PR7046.2 PU7000.48
RGND_GT: PC7014.1 PC7015.1 PR7053.2 PU7000.25
RGND_SA: PC7022.1 PC7024.1 PR7062.2 PU7000.44
RING2: C591.2 CN35.6 CN35.7 CN35.8 R471.2 U20.17
ROM_CS: TP67.1 U8.D12
ROM_SCLK: R342.1 R352.2 U8.C12
ROM_SI: R341.1 R350.2 U8.B12
ROM_SO: R343.1 R351.2 U8.A12
RSET: R508.2 U24.31
RSMRST#: EC1.2 R45.1 R47.2 U1.BR36 U37.112
RTC_RST#: C1217.1 J9007.1 Q22.3 R979.2 U1.BR34
RTC_X1: C206.2 R169.1 U1.BN31 Y1.1
RTC_X2: C209.2 R169.2 U1.BN32 Y1.2
S5_ON: PR566.2 PR6015.2 PR6027.1 R25309.1 U37.100
SATA_LED#: CN16.10 TP2092.1
SATA_RXN0_C: C6592.2 R25352.2
SATA_RXN0_CN: C6592.1 C6596.1 HD1.8
SATA_RXN0_HDD: C6588.2 R25352.1 U1.BN10
SATA_RXN0_IN: C6588.1 U42.4
SATA_RXN1A_C: C782.1 CN15.5
SATA_RXN1A_ODD: C782.2 U1.BL6
SATA_RXN_OUT: C6596.2 U42.12
SATA_RXP0_C: C6593.2 R25353.2
SATA_RXP0_CN: C6593.1 C6597.1 HD1.7
SATA_RXP0_HDD: C6589.2 R25353.1 U1.BN8
SATA_RXP0_IN: C6589.1 U42.5
SATA_RXP1A_C: C781.1 CN15.6
SATA_RXP1A_ODD: C781.2 U1.BL5
SATA_RXP_OUT: C6597.2 U42.11
SATA_TXN0_C: C6591.2 R25351.2
SATA_TXN0_CN: C6591.1 C6595.1 HD1.10
SATA_TXN0_HDD: C6587.2 R25351.1 U1.BN4
SATA_TXN0_IN: C6587.1 U42.2
SATA_TXN1A_C: C784.1 CN15.2
SATA_TXN1A_ODD: C784.2 U1.BN2
SATA_TXN_OUT: C6595.2 U42.14
SATA_TXP0_C: C6590.2 R25350.2
SATA_TXP0_CN: C6590.1 C6594.1 HD1.11
SATA_TXP0_HDD: C6586.2 R25350.1 U1.BN3
SATA_TXP0_IN: C6586.1 U42.1
SATA_TXP1A_C: C783.1 CN15.3
SATA_TXP1A_ODD: C783.2 U1.BN1
SATA_TXP_OUT: C6594.2 U42.15
SATAGP0: R25481.1 U1.CN8
SATAGP1: R25433.1 U1.CM10
SD_1P8_RCOPM: R209.1 U1.CK33 U1.CM34
SDVO_CLK: R494.2 R775.1 U1.CC8 U23.7
SDVO_DATA: R502.2 R777.1 U1.CC9 U23.6
SEL: R25276.1 R25277.2 R25280.2 U6502.6
SENSEA: R451.1 R452.1 R733.1 U20.13
SERIRQ: R94.1 R25520.1 U1.BV28 U37.5
SIO_EXT_SCI#: R25436.1 R25448.2 U37.23
SIO_EXT_SMI#: R98.1 U1.CG22
SIO_RCIN#: R100.1 U1.BV29 U37.4
SLEEVE: C590.2 CN35.9 CN35.10 CN35.11 R468.2 U20.18
SLP_A#: TP7.1 U1.BU37
SLP_LAN#: TP4.1 U1.BT31
SLP_S5#: TP3.1 U1.BT29
SLP_SUS#_EC: TP9027.1 U1.BU29
SM_RCOMP_0: R28.1 U1.BN28
SM_RCOMP_1: R29.2 U1.BN27
SM_RCOMP_2: R30.1 U1.BN29
SM_VREF: C266.1 R242.1 U1.F36
SMB_ME0_CLK: R99.1 U1.CH14
SMB_ME0_DAT: R101.1 U1.CF15
SMB_ME1_CLK: R103.2 R25449.2 U1.CN15
SMB_ME1_DAT: R104.2 R25450.2 U1.CM15
SMB_PCH_CLK: Q3.6 R95.1 U1.CK14
SMB_PCH_DAT: Q3.3 R97.1 U1.CH15
SMB_RUN_CLK: JDIM1.253 Q3.1(S) R115.2 R557.2 R591.1
SMB_RUN_DAT: JDIM1.254 Q3.4 R114.2 R561.2 R590.1
SMDDR_VREF_DQ1_M3: C299.1 R262.1 U1.E36
SML0ALERT#: R119.1 R121.1 U1.CJ15
SML1ALERT#: R123.1 R125.2 U1.CG15
SP_PLLVDD: C459.2 C460.2 C461.1 C462.1 L8.2 R329.2 U8.M6
SPI1_CLK: TP9.1 U1.CF20
SPI1_CS#: TP12.1 U1.CG20
SPI1_IO2: TP10.1 U1.CG23
SPI1_IO3: TP11.1 U1.CH23
SPI_TPM_CS#: R586.1 R599.1 U1.CH34
SRTC_RST#: C1211.1 Q6520.3 R971.2 U1.BR37
STRAP0: R344.1 R353.2 U8.D1
STRAP1: R345.1 R354.2 U8.D2
STRAP2: R346.1 R355.2 U8.E4
STRAP3: R347.1 R356.2 U8.E3
STRAP4: R348.1 R357.2 U8.D3
STRAP5: R349.1 R358.2 U8.C1
SUS_STAT#: C6626.1 U1.CA27
SUSACK#: R32.2 TP9018.1 U1.BY32
SUSB#: C5.1 U1.BU36 U37.119
SUSC#: C6.1 U1.BU27 U37.18
SUSCLK_32K: R670.2 U1.BT32
SUSCLK_32KHZ: CN17.50 R670.1
SUSD: PC152.1 PQ11.2 PQ25.3 PR191.2
SUSLED#: CN35.21 U37.28
SUSON: C247.2 PR266.2 PR9251.1 PR9258.2 R215.2 R25320.1 U3.3 U37.120
SUSPWRDNACK: R31.2 R39.1 U1.BV34
SYS_HWPG: D60.1(CATHODE) PR6004.2 PR6022.2 U37.124
SYS_PWROK: C7.1 R25359.1 R25362.1 TP5.1 U1.CR10 U6504.4
SYS_RESET#: R43.1 U1.CN10
SYS_SHDN#: PR3022.2 PR6002.2 PR6009.1 PR6020.2 Q86.3 U37.85
TEMP_MBAT#: PR8.1 PR14.2 PR18.1 U37.73
TESTMODE: R311.1 U8.AD9
THERM+: TP68.1 U8.F12(THERMDP)
THERM-: TP69.1 U8.E12
THERMTRIP#: Q86.1(EMITTER) R822.1 R25479.1
THERMTRIP#_CPU: R25479.2 U1.BJ1
TP_I2C_CLK: R558.1 R565.1 R25415.2 U1.CN11
TP_I2C_DATA: R560.1 R563.1 R25413.2 U1.CM11
TP_INTH#_L: CN33.7 Q29.1(S) R25471.2 R25472.1
TP_PWR_C: C6624.2 C6625.2 CN29.30 CN29.31 R25462.2 R25465.2
TP_SMB_CLK: C699.1 CN33.6 Q27.3 R559.1
TP_SMB_DATA: C698.1 CN33.5 Q27.6 R562.1
TPCLK: L23.1 R566.2 U37.89
TPCLK-1: C696.1 CN33.2 L23.2
TPD_EN: R572.2 R574.1 R895.2
TPD_INT#: R573.1 R25477.1 U1.CN14
TPD_INT#_EC: R25308.2 R25323.1 R25473.1
TPDAT-1: C697.1 CN33.3 L24.2
TPDATA: L24.1 R567.2 U37.90
TPM_LRESET#: R601.2 U33.17
TPM_PIRQ#: R102.1 U1.CF22
TRA_V_DAC: C645.1 U25.1 U25.4 U25.7 U25.10
TS_EN: R436.2 R956.1
TS_EN_C: C1210.1 R956.2 U37.81
TS_EN_R: CN29.28 R436.1
TYPEC_SBU1: CN10.A8 D19.2 TP77.1
TYPEC_SBU2: CN10.B8 D18.2 TP78.1
TYPEC_STRAP: R25499.2 R25500.1 U37.77
UART2_CTS#: R604.1 U1.CM12
UART2_RTS#: R607.1 U1.CN12
UART2_RXD: R606.1 U1.CR12
UART2_TXD: R605.1 U1.CP12
UGATE1_CORE: PQ7000.1 PR7106.2
UGATE2_CORE: PQ7001.1 PR7078.2
UGATE_GT: PQ7004.1 PR7110.2
UGATE_SA: PQ7002.4 PR7114.2
ULT_EDP_HPD: C6616.2 R1.2 R10880.1 R25467.1 U1.CM7
ULT_EDP_HPD_R: CN29.25 R25467.2
USB2_COMP: R136.1 U1.CC5
USB2_ID: R137.1 U1.CE8
USB2_VBUSSENSE: R138.1 U1.CC6
USB3_SS0RX+: C683.1 U6502.5
USB3_SS0RX-: C682.1 U6502.4
USB3_SS0TX+: C677.1 U6502.2
USB3_SS0TX-: C681.1 U6502.1
USB30_RX1+: C518.2 R422.2 U1.CB6
USB30_RX1+_C: CN2.6 R422.1 U16.10
USB30_RX1-: C513.2 R421.2 U1.CB5
USB30_RX1-_C: CN2.5 R421.1 U16.1
USB30_RX2+: C526.2 R428.2 U1.BY9
USB30_RX2+_C: CN3.6 R428.1 U17.10
USB30_RX2-: C523.2 R427.2 U1.BY8
USB30_RX2-_C: CN3.5 R427.1 U17.1
USB30_RX3+: C683.2 U1.BY6
USB30_RX3-: C682.2 U1.BY7
USB30_RX+_TYPEC1: CN10.B11 RV3.1 RV3.10(NC#4) U6502.7
USB30_RX+_TYPEC2: CN10.A11 RV2.1 RV2.10(NC#4) U6502.14
USB30_RX-_TYPEC1: CN10.B10 RV3.2 RV3.9 U6502.8
USB30_RX-_TYPEC2: CN10.A10 RV2.2 RV2.9 U6502.13
USB30_TX1+: C520.1 U1.CA3
USB30_TX1+_C: C520.2 R423.2
USB30_TX1+_C_R: C522.1 CN2.9 R423.1 U16.6
USB30_TX1-: C519.1 U1.CA4
USB30_TX1-_C: C519.2 R424.2
USB30_TX1-_C_R: C521.1 CN2.8 R424.1 U16.5
USB30_TX2+: C531.1 U1.CA1
USB30_TX2+_C: C531.2 R430.2
USB30_TX2+_C_R: C533.1 CN3.9 R430.1 U17.6
USB30_TX2-: C530.1 U1.CA2
USB30_TX2-_C: C530.2 R429.2
USB30_TX2-_C_R: C532.1 CN3.8 R429.1 U17.5
USB30_TX3+: C677.2 U1.BY3
USB30_TX3-: C681.2 U1.BY4
USB30_TX+_TYPEC1: C686.1 CN10.A2 RV2.5 RV2.6
USB30_TX+_TYPEC1_C: C686.2 U6502.10
USB30_TX+_TYPEC2: C684.1 CN10.B2 RV3.5 RV3.6
USB30_TX+_TYPEC2_C: C684.2 U6502.17
USB30_TX-_TYPEC1: C685.1 CN10.A3 RV2.4 RV2.7
USB30_TX-_TYPEC1_C: C685.2 U6502.11
USB30_TX-_TYPEC2: C680.1 CN10.B3 RV3.4 RV3.7
USB30_TX-_TYPEC2_C: C680.2 U6502.16
USB_BC_ON: U14.4 U37.97
USB_CHARGE_ON: R416.1 U14.5 U37.96
USB_CLT1: U14.6 U37.79
USB_OC0#: C6614.2 R60.1 U1.CK6 U14.13
USB_OC1#: C6613.2 R25439.1 U1.CK5 U15.3
USB_OC2#: C6612.2 R25438.1 U1.CK8 U18.3
USB_OC3#: R25437.1 TP9025.1 U1.CK9
USBON#: U15.4 U18.4 U37.99
USBP1+: R25512.1 R25514.1 U1.CE4
USBP1+_C: R25518.1 U14.10
USBP1+_C_R: R25514.2 R25516.1
USBP1+_C_R_N: CN2.3 R25516.2 R25518.2 U16.7
USBP1+_U14: R25512.2 U14.3
USBP1-: R25511.1 R25513.1 U1.CE3
USBP1-_C: R25517.1 U14.11
USBP1-_C_R: R25513.2 R25515.1
USBP1-_C_R_N: CN2.2 R25515.2 R25517.2 U16.4
USBP1-_U14: R25511.2 U14.2
USBP2+: R425.2 U1.CE2
USBP2+_C: CN3.3 R425.1 U17.7
USBP2-: R426.2 U1.CE1
USBP2-_C: CN3.2 R426.1 U17.4
USBP3+_TPC: R25292.2 U1.CG4
USBP3-_TPC: R25293.2 U1.CG3
USBP4+_DB: CN35.16 U1.CD4
USBP4-_DB: CN35.15 U1.CD3
USBP5+_CAM: R25289.2 U1.CG6
USBP5+_CAM_C: CN29.8 R25289.1
USBP5-_CAM: R25288.2 U1.CG5
USBP5-_CAM_C: CN29.7 R25288.1
USBP6+_CR: CN35.19 U1.CC2
USBP6-_CR: CN35.18 U1.CC1
USBP7+_FP: CN14.7 EC7.2 U1.CG9
USBP7-_FP: CN14.6 EC8.1 U1.CG8
USBP8+_TS: R25291.2 U1.CB9
USBP8-_TS: R25290.2 U1.CB8
USBP8_TS+_C: CN29.5 R25291.1
USBP8_TS-_C: CN29.4 R25290.1
USBP10+_BT: CN17.3 U1.CC4
USBP10-_BT: CN17.5 U1.CC3
USBP_TYPC+_C: CN10.A6 CN10.B6 R25292.1 RV1.1
USBP_TYPC-_C: CN10.A7 CN10.B7 R25293.1 RV1.2
USBPWRD2: C527.2 C528.2 C529.2 C664.2 C665.1 CN35.36 CN35.37 CN35.38 CN35.39 CN35.40 U18.1(OUT)
VA: PC1.1 PC5.1 PC13.1 PC14.1 PD2.1 PJ2.1 PQ1.5 PR16.2 PR31.1 PR235.1
VA2: PC2.1 PQ1.1 PQ1.2 PQ1.3(S3) PQ9054.1 PQ9054.2 PQ9054.3(S3) PR28.1
VADJ1: C558.1 CN29.27 R441.2 R442.1
VCORE_SENSE: PR7043.1 PR7044.1 U1.AN6
VCORESS_SENSE: PR7045.1 PR7046.1 U1.AN5
VGA_OVT#: Q15.1(S) R395.1 U8.A6
VGA_RST#: C364.1 R296.2 U8.AC7
VGA_VCCSENSE: PR9026.2 PR9028.2 U8.F2
VGA_VSSSENSE: PR9029.2 PR9031.2 U8.F1
VL: PR3020.1 PR6025.2
VMA_CLK0: R25488.2 U8.D24 VRAM1.J12
VMA_CLK0#: R25488.1 U8.D25 VRAM1.J11
VMA_CLK1: R25489.2 U8.N22 VRAM2.J12
VMA_CLK1#: R25489.1 U8.M22 VRAM2.J11
VMA_DQ0: U8.E18 VRAM1.E2
VMA_DQ1: U8.F18 VRAM1.F2
VMA_DQ2: U8.E16 VRAM1.A2
VMA_DQ3: U8.F17 VRAM1.B2
VMA_DQ4: U8.D20 VRAM1.F4
VMA_DQ5: U8.D21 VRAM1.B4
VMA_DQ6: U8.F20 VRAM1.E4
VMA_DQ7: U8.E21 VRAM1.A4
VMA_DQ8: U8.E15 VRAM1.B11
VMA_DQ9: U8.D15 VRAM1.E13
VMA_DQ10: U8.F15 VRAM1.A13
VMA_DQ11: U8.F13 VRAM1.A11
VMA_DQ12: U8.C13 VRAM1.E11
VMA_DQ13: U8.B13 VRAM1.F11
VMA_DQ14: U8.E13 VRAM1.B13
VMA_DQ15: U8.D13 VRAM1.F13
VMA_DQ16: U8.B15 VRAM1.N11
VMA_DQ17: U8.C16 VRAM1.U11
VMA_DQ18: U8.A13 VRAM1.M11
VMA_DQ19: U8.A15 VRAM1.T11
VMA_DQ20: U8.B18 VRAM1.U13
VMA_DQ21: U8.A18 VRAM1.T13
VMA_DQ22: U8.A19 VRAM1.N13
VMA_DQ23: U8.C19 VRAM1.M13
VMA_DQ24: U8.B24 VRAM1.N4
VMA_DQ25: U8.C23 VRAM1.U4
VMA_DQ26: U8.A25 VRAM1.M4
VMA_DQ27: U8.A24 VRAM1.T4
VMA_DQ28: U8.A21 VRAM1.T2
VMA_DQ29: U8.B21 VRAM1.U2
VMA_DQ30: U8.C20 VRAM1.M2
VMA_DQ31: U8.C21 VRAM1.N2
VMA_DQ32: U8.R22 VRAM2.U11
VMA_DQ33: U8.R24 VRAM2.N11
VMA_DQ34: U8.T22 VRAM2.U13
VMA_DQ35: U8.R23 VRAM2.M11
VMA_DQ36: U8.N25 VRAM2.N13
VMA_DQ37: U8.N26 VRAM2.M13
VMA_DQ38: U8.N23 VRAM2.T11
VMA_DQ39: U8.N24 VRAM2.T13
VMA_DQ40: U8.V23 VRAM2.M4
VMA_DQ41: U8.V22 VRAM2.N4
VMA_DQ42: U8.T23 VRAM2.U4
VMA_DQ43: U8.U22 VRAM2.T4
VMA_DQ44: U8.Y24 VRAM2.N2
VMA_DQ45: U8.AA24 VRAM2.T2
VMA_DQ46: U8.Y22 VRAM2.M2
VMA_DQ47: U8.AA23 VRAM2.U2
VMA_DQ48: U8.AD27 VRAM2.F2
VMA_DQ49: U8.AB25 VRAM2.B2
VMA_DQ50: U8.AD26 VRAM2.E2
VMA_DQ51: U8.AC25 VRAM2.A2
VMA_DQ52: U8.AA27 VRAM2.B4
VMA_DQ53: U8.AA26 VRAM2.A4
VMA_DQ54: U8.W26 VRAM2.E4
VMA_DQ55: U8.Y25 VRAM2.F4
VMA_DQ56: U8.R26 VRAM2.B13
VMA_DQ57: U8.T25 VRAM2.A13
VMA_DQ58: U8.N27 VRAM2.F13
VMA_DQ59: U8.R27 VRAM2.E13
VMA_DQ60: U8.V26 VRAM2.A11
VMA_DQ61: U8.V27 VRAM2.B11
VMA_DQ62: U8.W27 VRAM2.F11
VMA_DQ63: U8.W25 VRAM2.E11
VMA_WCK01: U8.D18 VRAM1.D4
VMA_WCK01#: U8.C18 VRAM1.D5
VMA_WCK23: U8.D17 VRAM1.P4
VMA_WCK23#: U8.D16 VRAM1.P5
VMA_WCK45: U8.T24 VRAM2.P4
VMA_WCK45#: U8.U24 VRAM2.P5
VMA_WCK67: U8.V24 VRAM2.D4
VMA_WCK67#: U8.V25 VRAM2.D5
VR_READY: PR7067.2 PU7000.38
VR_SVID_ALERT#_VCORE: PR7002.2 PR7020.2 R63.1 R64.2
VR_SVID_CLK_R: R66.1 U1.AA1
VRON: PR7025.2 R25311.1 U37.69
VSEN_CORE: PC7007.1 PC7008.2 PC7010.1 PR7044.2 PR7047.2 PU7000.47
VSEN_GT: PC7013.1 PC7014.2 PC7016.2 PR7051.2 PR7054.2 PU7000.27
VSEN_SA: PC7019.1 PC7020.2 PC7022.2 PR7058.2 PR7059.2
VSTBY_FSPI: R359.2 R25330.2 U37.106
WIGIG_LED: CN17.6 TP9029.1
WLAN_RST#: CN17.52 R2665.1
WLANPWR#: TP2090.1 U37.35
WRST#: C6571.1 D63.2 R25300.1 U37.14(WRST#)
XCLK_BIASREF: R145.1 U1.CJ1
XDP_BPM0: TP23.1 U1.U1
XDP_BPM1: TP25.1 U1.U2
XDP_PRDY#_CPU: TP24.1 U1.W2
XDP_PREQ#_CPU: TP22.1 U1.W1
XDP_TCK0: R7.2 R24.2 TP52.1 U1.T6
XDP_TDI_CPU: R3.2 R19.2 U1.U6
XDP_TDO_CPU: R4.2 R22.1 U1.Y5
XDP_TMS_CPU: R5.2 R15.2 U1.T5
XDP_TRST#_CPU: R6.1 R25.2 U1.Y6
XTAL1: R511.2 U24.28
XTAL2: R512.1 U24.29
XTAL24_IN: R166.1 U1.CK3
XTAL24_IN_C: C205.2 R166.2 R167.1 Y2.1
XTAL24_OUT: R168.1 U1.CK2
XTAL24_OUT_C: C208.2 R167.2 R168.2 Y2.3
XTAL_SSIN: R331.1 U8.A10
N06325: Q29.3 R573.2 R25471.1 R25473.2
N16824426: R323.2 R324.2 U11.2
N17002655: C572.2 U20.39
N17002661: C566.2 U20.37
N17002676: C567.1 U20.34
N17002678: C573.1 U20.19
N17002722: R453.2 R454.2 U20.48
N17002952: C578.1 U20.7
N17002968: R738.1 R739.1 R741.1 U20.11
N17002995: C846.1 R740.1 R742.1 U20.12
N17003129: C566.1 U20.35
N17003186: R450.1 U20.20
N17004316: D12.1(CATHODE) Q21.3
N17046941: PJ1.3 PR13.1
N17047007: PQ9054.5 PR1.1 PR3.1
N17047009: PR5.1 PU1.20
N17047028: PR6.1 PU1.19
N17047083: PJ1.5 PR14.1
N17047087: PC17.1 PL5.2 PQ2.1 PQ2.2 PQ2.3(S3) PR7.1 PR209.1 PR210.2
N17047112: PC1.2 PC2.2 PQ1.4 PQ9054.4 PR29.1
N17047335: PC19.1 PR33.2
N17047399: PC15.2 PR11.2
N17047425: PJ1.4 PR12.1
N17047601: PC17.2 PQ2.4 PR4.1
N17398787: PR30.2 PU1.5
N17424918: PR19.2 PU1.11
N17424920: PR17.2 PU1.12
N17424921: PR32.2 PU1.7
N17424925: PR25.2 PU1.9
N17424950: PR8.2 PR205.2 PU1.15
N17661815: PR26.2 PU1.8
N18867651: PC6020.1 PC6021.1 PR9245.1 PU6001.8 PU6001.9
N18867812: PC6042.1 PC6043.1 PR9249.1 PU6002.8 PU6002.9
N18922914: C425.2 C429.2 C431.2 R299.1 U8.AA8 U8.AA9
N19138106: R321.2 U8.F22
N19138109: R322.2 U8.J22
N19521323: PQ6000.3 PR6006.1
N19521733: PQ6000.2 PR6012.1 PR9268.1 PR9269.1
N19549602: PQ6001.2 PR6024.1 PR9270.1 PR9271.1
N20380930: R44.2 U1.BT27
N20513971: R220.2 TP54.1
N20681162: R25494.2 U1.BY31
N20858957: C266.2 R244.2
N20946170: R245.1 U4.E9
N20946459: R247.1 U7.E9
N20946794: R246.1 U5.E9
N20947128: R248.1 U6.E9
N21263014: TP65.1 U8.E10
N21263017: TP66.1 U8.F10
N22413276: PQ7.3 PQ10.2 PQ25.2 PR79.2 PR80.1
N22413302: PQ10.3 PR105.2
N22415444: PC219.1 PC220.1 PC222.1 PC224.1 PC227.1 PC230.1 PC231.1 PC233.1 PJ3005.2 PL12.2 PR9259.2
N22415644: PC225.2 PR269.1 PR9259.1
N22415652: PC82.1 PR99.2
N22415672: PC235.2 PR277.1
N22767382: R84.2 U1.BP36
N24359231: PC7056.2 PU7001.4
N24359390: PR7078.1 PU7001.3
N24444747: PR7017.2 PR7018.1 PR7021.2 PR7031.1
N24444757: PC7023.1 PR7063.2
N24445360: PC7005.1 PR7025.1 PU7000.37
N24445593: PR7066.2 PR7069.2 PU7000.8
N24445614: PR7016.2 PR7026.1 PR7030.1 PR7032.2
N24446268: PR7037.2 PR7038.1
N24459302: PR7073.2 PR7076.1
N24492000: PC7012.1 PR7049.1
N24507636: PC229.1 PC6230.1 PC6231.1 PJ3008.1 PL14.2 PR6414.2
N24507642: PC9097.1 PR283.1 PR6418.2 PU3003.6
N24507664: PC9097.2 PR6414.1 PR6418.1
N24507676: PC6229.2 PR6417.1 PU3003.1
N24507691: PR284.2 PU3003.5
N24515156: PC7018.1 PR7056.1
N24602110: PR7007.2 PR7013.2 PR7014.1
N24622727: PR7099.2 PR7100.1 PR7101.1
N24679794: C243.2 L3.1 R212.1 R213.1
N24742093: PC9067.1 PC9068.1 PC9069.1 PJ9003.1 PQ9008.1 PQ9008.2 PQ9008.3(S3) PR9073.1
N24742096: PD9001.2 PQ9011.3 PR9075.2
N24742104: PQ9009.2 PQ9010.3 PQ9011.2 PR9074.2 PR9077.1
N24742107: PC9055.1 PC9056.1 PR9067.2 PU9002.13 PU9002.14(VOUT1#2)
N24742118: PR9078.1 PU9003.3
N24742123: PQ9009.3 PR9073.2
N24742126: PC9073.1 PQ9010.2 PR9079.1 PU9003.4
N24742146: PC9071.1 PR9080.2
N24742173: PC9059.1 PR9069.2 PU9002.4
N24742207: PC9063.1 PU9002.10
N24742208: PC9062.1 PU9002.12
N24742222: PC9060.1 PR9070.1 PU9002.5
N24742230: PC9064.1 PR9072.2 PU9002.3
N24995566: PC6228.1 PR3020.2 PU3002.5(VCC)
N24995570: PR3021.1 PU3002.1
N24995581: PR3022.1 PU3002.3
N25365001: PQ9084.3 PR9103.2
N25369936: Q27.1(S) R560.2 R561.1
N25369945: Q27.4 R557.1 R558.2
N25430953: PQ14.3 PR111.2
N25430988: PQ12.3 PR106.2
N25430994: PQ19.3 PR126.2
N25431520: PQ9050.3 PR9227.2
N25804343: PR9027.2 PR9030.2
N25817818: PQ9085.3 PR9099.2
N25817820: PQ9085.2 PQ9086.3 PR9100.2 PR9101.1
N25821251: PC9088.1 PR9092.2
N27752748: R450.2 R736.1 R737.1
N28053888: PR7006.1 PR7007.1
N28054550: PR7077.2 PU7001.5
N28087213: C646.2 R516.1 R517.1 R518.1 R519.1
N28088374: PC7004.1 PR7008.2
N28089786: PR7035.1 PR7040.1
N28089833: PR7036.2 PR7041.2
N28092561: R83.2 U1.W4
N28100067: CN33.8 R572.1
N28107941: PC7096.2 PR7095.1
N28108994: PR7096.2 PR7098.1
N28123718: PR7030.2 PR7033.1
N28123995: PR7031.2 PR7034.1
N28124269: PR7010.2 PR7017.1
N28124298: PR7009.2 PR7016.1
N28127437: PC7001.1 PR7001.1 PR7002.1 PR7003.1 PR7102.1
N28129355: PR7022.1 PR7027.1
N28129385: PR7023.1 PR7028.1
N28129414: PR7024.1 PR7029.1
N28159674: PR7091.1 PR7092.1 PR7093.1
N28160119: PC7078.2 PR7087.1
N28160139: PR7088.2 PR7090.2
N28379472: PC9025.1 PR9021.2 PR9023.1 PR9024.1
N28379477: PC9024.1 PR9019.1
N28380796: PR9017.1 TP9000.1
N28380828: PC9004.1 PR9000.2 PR9002.2
N28414264: PR9033.1 PR9274.1 PU9000.13
N28607521: PR9034.1 PU9000.22
N29093947: Q14.2 Q16.3 R386.1
N30319022: PC9080.1 PC9081.1 PC9082.1 PC9083.1 PC9084.1 PC9085.1 PC9086.1 PC9087.1 PJ9002.2 PL9002.2 PR9263.1
N30319317: PC9089.2 PR9094.1 PR9263.2
N30319351: PC9079.2 PR9089.1
N30442035: PC6040.1 PC6041.1 PR9248.2 PU6002.13 PU6002.14(VOUT1#2)
N30442060: PC6051.1 PR6023.1 PU6002.4
N30442062: PC6056.1 PU6002.12
N30442063: PC6057.1 PU6002.10
N30442080: PC6053.1 PR6028.2 PU6002.5
N30442084: PC6052.1 PR6027.2 PU6002.3
N30568314: PC6024.2 PR6010.1 PR6014.2 PU6000.12
N30568326: PC6024.1 PR6011.1
N30568424: PC6059.2 PR6030.1 PR6031.2 PU6003.9
N30568429: PC6059.1 PR6029.1
N30568472: PC6054.1 PR6025.1 PU6003.12
N30568498: PQ6001.3 PR6021.1
N30568535: PR6003.2 PR6004.1 PR6005.2 PR6007.1
N31069510: PC6018.1 PC6019.1 PR9244.2 PU6001.13 PU6001.14(VOUT1#2)
N31161958: PC6025.1 PR6013.2 PU6001.4
N31161974: PC6028.1 PU6001.12
N31161976: PC6029.1 PU6001.10
N31162017: PC6027.1 PR6016.2 PU6001.5
N31162025: PC6026.1 PR6015.1 PU6001.3
N31297467: PC9093.1 PR184.1 PR9251.2 PR9252.2 PU14.2
N31297491: PC9094.1 PC9095.1 PC9096.1 PR222.2 PR9254.1 PU14.6
N31297495: PR222.1 PR224.1 PU14.7
N31297650: PC185.1 PR9253.2 PU14.4(VPP)
N31353058: PC561.1 PC562.1 PC563.1 PC9098.1 PJ9005.1 PL551.2 PR569.2
N31353100: PC551.2 PR551.2
N31375926: PQ7.2 PR9258.1 PR9272.1
N33618596: Q34.3 R653.2
N33652665: EC12.1 R655.2
N33712295: R85.2 U1.E1
N33761123: CN16.38 R645.1 R2660.1
N33761125: CN16.50 R648.1
N33761127: CN16.68(SUSCLK) TP81.1
N33764822: R216.2 TP26.1
N33764826: R217.2 TP32.1
N34044006: PR7109.2 PU7003.5
N34044116: PC7101.2 PU7003.4
N34044137: PR7110.1 PU7003.3
N34045443: PR7113.2 PU7004.5
N34045547: PC7103.2 PU7004.4
N34045574: PR7114.1 PU7004.3
N34047546: PR7105.2 PU7002.5
N34047656: PC7105.2 PU7002.4
N34047677: PR7106.1 PU7002.3
N36446693: C639.1 R512.2 Y4.3
N36953746: C750.2 Q32.2 R609.2
N36954805: R589.2 U32.7
N36977514: Q30.2 Q31.3 R579.2
N37139396: D22.2 R600.1
N37139525: R598.2 U33.24
N37139527: R597.2 U33.21
N37139529: R596.2 U33.19
N37139539: R593.2 U33.18
N37139543: R599.2 U33.20
N37139545: R592.2 U33.29
N37162665: L28.1 R448.2 R449.2
N37162929: R454.1 TP9023.1
N37164012: C843.1 U20.16
N37164724: R735.2 R25371.2
N37190310: C842.1 D13092.2 HE1.2(VCC) R25519.2
N37349239: PC7046.2 PR7072.1
N37349425: PC7064.2 PR7081.1
N37352433: PC9012.1 PR9004.1
N37598035: R507.1 U23.4
N37994586: C6559.2 R265.2 R266.2
N38517581: D6542.1 R25338.2 R25339.1
N38517589: Q6518.2 R25338.1
N38517597: Q6516.4 Q6518.3(E) R25340.2 R25341.2
N38517605: Q6519.3 R25341.1
N38517627: Q6515.3 R25342.2
N38517632: C6584.2 Q6519.5 Q6519.6 R6603.1
N38517638: C6583.2 Q6515.2 R25337.2
N38521997: CN18.1 D33.1 R720.1
N38673982: Q85.1(S) R821.2 R825.2
N38674074: Q86.2 R821.1
N38674948: PR7082.2 PR7084.1
N38680042: D11.1(CATHODE) D6543.1(CATHODE) R735.1
N38680880: Q6523.2 R576.1
N38756671: C6568.2 R25318.1 U37.66
N38756738: C1208.2 R960.1 U37.82
N38756749: TP9037.1 U37.87
N38756787: C6580.2 R895.1 U37.98
N38756834: Q81.3 R25321.1 SW2.3 SW2.4
N38756945: TP9035.1 U37.83
N38757016: TP9038.1 U37.20
N38757336: C6563.1 R25308.1 U37.128
N38757406: C1044.1 Q81.2 R25310.2 SW3.3 SW3.4
N38758998: C6562.2 R402.1
N38759178: C1190.1 U37.12
N38763467: R25448.1 U1.CP6
N39168858: Q6533.3 R706.2 R707.2 R708.2 R709.2 R710.2 R711.2 R712.2 R713.2
N39687060: PR262.1 PU26.23
N39687062: PC301.1 PR262.2
N39687064: PC301.2 PL30.1 PR261.1 PR9264.2 PU26.9 PU26.10 PU26.11 PU26.12 PU26.32
N39687102: PC293.1 PC294.1 PC295.1 PC296.1 PC297.1 PC305.1 PC306.1 PJ7001.1 PL30.2 PR9266.1 PU26.30
N39687293: PC300.2 PR9264.1
N39687315: PC267.2 PR263.2 PR9266.2
N39687335: PC283.1 PR265.1 PU26.4
N39687341: PR261.2 PU26.8
N39687373: PC276.1 PR266.1 PR9273.1 PU26.5
N39687445: PC267.1 PR253.2 PR263.1 PU26.1
N39687482: PC304.1 PR9267.2 PU26.2
N39687516: PC298.1 PR254.1 PU26.29
N39688806: PR267.1 PU26.6
N39782161: TP9044.1 U1.BW35
N39782179: TP9042.1 U1.BW34
N39782191: TP9043.1 U1.CA37
N39785725: HD1.1 R25483.1 R25485.1
N40437801: TP9033.1 U8.V7
N40437812: TP9032.1 U8.W7
N40437815: TP9031.1 U8.W6
N40437818: TP9030.1 U8.Y6
N40911013: R405.2 VRAM1.J13(ZQ)
N40911015: R406.2 VRAM2.J13(ZQ)
N41141585: TP9041.1 U37.16
N43700942: CN29.24 R25521.2
N43737419: CN29.29 R25522.2
N47271970: R363.2 R364.2 R366.2 R367.2 R368.2
N48434117: C375.2 C380.2 C386.2 L4.2 U8.F11
N48587681: R329.1 U8.N6
N48650493: Q15.2 R382.1 R384.1
N49263752: R339.1 R341.2 R342.2 R343.2
N60242660: C299.2 R267.1
N414891010: TP9039.1 U37.31
N4148946975: TP9040.1 U37.48

Pads without a net: CN1 3 4; CN13 3; CN14 1 2 3 4; CN16 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; CN17 8 12 16 20 38 40 42 44 46 48; CN29 38; CN35 25 26 28 33 34 35; CN37 13 14; HOLE23 1; HOLE24 1; JDIM1 162 165; NOREF 1; NOREF#2 1; NOREF#4 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; PQ7000 2; PQ7001 2; PQ7004 2; PQ9000 2; PQ9001 2; PU14 5; PU16 7; PU3004 5; PU7000 14 15 19 20 21; PU9004 7; U1 A34 A35 AA24 AA26 AB25 AC1 AC2 AC3 AC4 AC6 AC7 AC24 AC25 AC26 AD3 AD4 AD24 AD26 AE1 AE2 AE3 AE4 AE28 AE29 AG6 AG7 AH26 AJ27 AL1 AL2 AL3 AL4 AL34 AL35 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC3 BC24 BC28 BD3 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BP34 BP35 BR18 BT8 BT9 BU34 BV24 BV25 BW1 BW2 BW5 BW6 BW36 BW37 C34 CA32 CA34 CA35 CA36 CB35 CB36 CC27 CC35 CC36 CE9 CF12 CF27 CF29 CG1 CG2 CG12 CG14 CG17 CG25 CG35 CH3 CH4 CH5 CH6 CH7 CH8 CH9 CH12 CH17 CH20 CH22 CH25 CH27 CH28 CH30 CH32 CJ12 CJ17 CJ22 CJ25 CJ27 CJ29 CJ30 CJ31 CK12 CK19 CK22 CK23 CK25 CM6 CM14 CM16 CM18 CM19 CM20 CM23 CM24 CM27 CM28 CN3 CN4 CN7 CN16 CN18 CN19 CN20 CN23 CN26 CN28 CN36 CP3 CP4 CP16 CP18 CP20 CP26 CP28 CP36 CR3 CR4 CR16 CR18 CR20 CR24 CR26 CR28 CR35 D34 D35 D37 F34 F37 G1 G2 G3 G4 H3 H4 K12 K14 K15 K17 K18 K20 L25 M24 M26 P24 P26 R24 R25 R26 T25 T29 U3 U4 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; U4 T7; U5 T7; U6 T7; U7 T7; U8 A3 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AA14 AA15 AB1 AB2 AB3 AB4 AB5 AB6 AB8 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B4 B6 B19 C2 C3 C7 C14 D4 D10 D11 D23 E6 E7 E9 F4 F5 F6 F7 F19 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 P25 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T27 U3 U4 U6 V1 V2 V3 V4 V5 V6 W1 W2 W3 W4 W5 W22 Y3 Y4; U14 9; U20 14 15 23 24; U23 3 23 24; U32 2 3; U33 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 30 31 32; VRAM1 A5 A10 U5 U10; VRAM2 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4003 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 2671 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 135 vias
v4: diameter 0.305, hole 0.152, TOP to BOTTOM, 10 vias
v5: diameter 0.406, hole 0.203, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_S:
  vias: v1(24.8,98.41)
1V8_MAIN_EN: length 194
  TOP w0.102: PQ9083.2 124.54,122.15 124.87,121.81 PR9105.1 v1(126.77,121.81) ; v1(20.61,88.56) 20.66,88.51 21.14,88.51 21.7,87.94 21.7,87.72 21.94,87.48 PR9072.1 ; v2(88.31,99.74) 87.15,99.74 86.9,99.5 86.9,98.27 86.5,97.86 86.5,97.45 86.07,97.01 R403.1 86.02,96.79 86.88,96.79 87.11,97.01 R374.1
  TOP w0.203: PR9012.2 75.64,116.61 75.86,116.39 77.33,116.39 v1(77.71,116.78) 77.79,116.69 PD9000.1 77.26,115.12 76.41,115.12 v1(76.39,115.1)
  IN1 w0.089: v2(88.31,99.74) 88.28,99.78 88.28,102.35 88.43,102.51 88.43,107.8 88.23,108.01 88.23,109 89.04,109.82 89.04,115.44 91.33,117.73 92.73,117.73 92.96,117.96 92.96,119.2 95.54,121.78 95.79,121.78 v2(95.92,121.91) 96.39,121.91 96.77,122.29 96.77,122.79 97.45,123.47 101.38,123.47 101.64,123.72 104.54,123.72 107.25,121.02 121.22,121.02 121.73,121.53 126.48,121.53 v1(126.77,121.81)
  IN2 w0.089: v1(76.39,115.1) 76.03,115.45 76.03,116.93 72.91,120.05 72.91,125.06 73.75,125.89 76.21,125.89 78.34,123.76 85.23,123.76 87.08,121.91 87.08,121.07 88.33,119.82 92.7,119.82 94.65,121.78 95.79,121.78 v2(95.92,121.91)
  IN3 w0.089: v1(76.39,115.1) 74.31,113.02 72.78,113.02 70.88,111.11 67.8,111.11 65.77,113.14 55.05,113.14 53.45,111.54 53.45,110.27 52.2,109.02 47.25,109.02 46.54,108.32 41.46,108.32 38.11,104.96 26.76,104.96 26.25,104.46 26.25,102.63 25.74,102.12 22.39,102.12 21.02,100.75 21.02,93.08 22.16,91.93 22.16,90.92 20.61,89.37 v1(20.61,88.56)
1V8_MAIN_EN_N17: length 17.3
  TOP w0.102: R374.2 88.7,97.01 88.9,97.22 90.37,97.22 93.54,100.39 93.91,100.39 96.05,98.26 96.05,97.69 96.85,96.89 97.44,96.89 97.75,97.2 97.75,97.73 97.95,97.93 98.61,97.93 99.71,96.84 v2(99.71,96.66)
  BOTTOM w0.102: U8.F9 100.5,96.66 v2(99.71,96.66)
5V_HSMBCK: length 7.6
  TOP w0.102: v1(20.94,73.76) 20.78,73.93 R490.1 ; v1(21.26,72.88) 21.26,72.64 22.79,71.11 22.79,70.22 23.05,69.96 24.45,69.96 24.59,70.11 D14.1
  BOTTOM w0.102: v1(20.94,73.76) 21.26,73.44 v1(21.26,72.88)
5V_HSMBDT: length 3.2
  TOP w0.102: D14.2 23.29,71.32 v1(22.36,72.25) 22.24,72.38 R491.1
8813VID: length 3.2
  TOP w0.254: PU9000.5 73.23,113.69 73.15,113.77 72.66,113.77 v1(72.55,113.88) 72.24,114.18 71.89,114.18 PR9017.2 PR9015.2
8813VOUT1: length 3.4
  TOP w0.254: PR9028.1 69.43,109.78 PC9027.1 69.71,110.06 PC9028.1 70.85,110.06 70.88,110.03 PU9000.11
8813VREF: length 4.1
  TOP w0.254: v1(70.65,112.2) 70.88,112.2 71.55,111.53 PU9000.8
  BOTTOM w0.254: v1(70.65,112.2) 71.27,112.2 PR9021.1 PC9023.1 71.3,110.98 71.21,110.89 PR9033.2
+1.2VSUS: length 210.7
  TOP w0.178: v1(39.14,42.25) 39.48,42.59 39.48,43.49 U4.J2 U4.J1
  TOP w0.254: U7.T9 32.67,72.86 32.31,72.5 31.3,72.5 30.92,72.88 30.92,73.15 C313.1 ; v1(46.82,92.77) 46.61,92.56 U6.A1 ; U4.L9 38.16,38.17 38.16,37.56 38.65,37.07 v1(38.67,37.07) ; v1(44.56,93.25) 44.67,93.15 U6.C1 ; v1(33.11,86.09) 33.46,86.09 33.53,86.16 U6.T9 ; U5.T9 34.1,51.43 34.09,51.42 32.1,51.42 31.68,51.01 31.16,51.01
  TOP w0.305: U6.R1 34.68,92.16 v1(34.67,92.16) ; U6.J9 39.85,86.16 v1(39.46,86.55) 39.86,86.96 U6.J8 ; v1(39.99,84.47) 39.33,84.47 38.52,85.28 38.52,85.94 38.3,86.16 U6.L9 ; v1(40.27,37.88) U4.J9
  TOP w0.33: U5.G9 v1(41.87,51.03)
  TOP w0.356: U4.E2 v1(43.47,44.28) ; v1(40.32,45.88) 38.78,45.88 38.27,45.38 U4.L1 ; U6.B3 45.47,90.39 v1(46.04,89.83) ; v1(39.41,71.72) U7.L9 ; v1(41.08,71.74) 40.7,71.74 40.07,72.38 40.07,72.66 U7.J9 ; U6.J1 v1(39.47,92.16) U6.J2 ; U6.D1 v1(44.27,92.16) ; U7.L1 38.27,80.1 39.18,81.01 v1(39.18,81.11) ; v1(42.67,56.6) 42.27,57 U5.F2 ; U5.D1 v1(44.27,57.43) ; U6.E2 v1(42.67,92.16) ; U5.G7 v1(41.87,53.43) ; 39.37,60.3 38.27,59.2 U5.L1 ; U4.A9 v1(45.87,37.88) ; U6.G9 v1(41.87,85.76) ; U5.F8 v1(41.87,51.83) ; U4.G1 v1(41.87,44.28) ; U7.F2 42.27,78.45 v1(41.87,78.05) ; U4.D1 v1(44.27,45.08) ; U4.G9 v1(41.87,37.88) ; v1(41.36,80.38) 40.99,80.38 U7.J1 40.07,79.06 40.07,78.65 U7.J2 ; v1(41.87,43.45) 41.87,43.48 U4.F2 ; U5.J8 v1(40.27,51.83) ; U4.T9 34.22,38.23 32.59,38.23 v1(32.07,37.71) 31.54,38.23 30.66,38.23 C298.1 ; U4.D9 43.44,37.86 v1(43.44,37.85) ; U5.D9 v1(44.27,51.03) ; U4.E7 v1(42.67,40.28) ; v1(42.18,59.22) 42.18,59.02 41.49,58.33 40.37,58.33 U5.J1 39.88,57.83 40.13,57.58 40.13,57.29 U5.J2 ; U5.G1 v1(41.87,57.43) ; U7.D9 v1(44.27,72.46) ; U7.B3 v1(45.87,77.26) ; v1(44.26,54.72) 44.13,54.72 43.07,53.66 U5.E7 ; U4.F8 v1(41.87,38.68) ; U6.G1 v1(41.87,92.96) ; U5.L9 39.08,50.62 39.08,48.73 39.44,48.36 C319.1 ; U5.B9 v1(45.87,51.03) ; v1(30.41,60.95) 30.58,60.78 C307.1 30.8,59.6 30.82,59.6 31.91,58.51 34.39,58.51 U5.R1 ; U4.B9 45.07,37.88 v1(45.07,37.88) ; v1(30.54,46.01) 30.8,46.01 32.12,44.69 33.16,44.69 33.67,45.2 34.55,45.2 U4.R1 ; U6.E7 v1(42.67,88.16) ; U5.C1 v1(45.07,57.43) ; U7.R1 34.39,79.94 33.11,79.94 33.08,79.91 31.39,79.91 31.04,80.26 C315.1 ; U7.G7 v1(41.87,74.06) ; U4.G7 v1(41.87,39.48) ; U7.J8 v1(39.47,73.26) ; U6.D9 v1(44.27,85.76) ; U7.F8 v1(41.87,73.26) ; U7.A9 v1(46.67,72.46) ; v1(40.27,51.03) U5.J9 ; U5.B3 v1(45.87,55.83) ; U7.G1 v1(41.87,79.66) ; U6.F2 41.87,91.36 v1(41.87,91.35) ; U4.A1 v1(46.67,44.28) ; v1(37.88,92.17) U6.L1 ; U7.B9 v1(45.87,72.46) ; U7.E2 v1(43.47,78.86) ; v1(45.47,41.26) U4.B3 ; U6.B9 v1(45.87,85.76) ; U5.A9 v1(46.67,51.03) ; U5.A1 v1(45.87,57.43) ; U6.A9 v1(46.67,85.76) ; U7.D1 v1(44.27,78.86) ; U7.A1 v1(46.67,78.86) ; U4.C1 v1(45.07,45.08) ; U7.E7 v1(42.67,74.86) ; U5.E2 v1(43.47,57.43) ; U7.C1 v1(45.07,78.86) ; U6.F8 v1(41.87,86.56) ; U7.G9 v1(41.87,72.46) ; U4.J8 v1(40.27,38.68)
  TOP w0.381: U6.G7 v1(41.87,87.36) ; v1(32.35,83.53) 31.93,83.11 R271.2
  TOP w0.406: R26.2 50.73,34.5 50.53,34.71 49.55,34.71 v1(48.83,35.43)
  TOP w0.508: C328.2 48.98,93.33 v1(48.86,93.45) ; v1(29.91,79.87) 30.3,80.26 C315.1 ; v1(29.81,74.41) 30.29,74.41 30.54,74.15 30.54,73.67 30.55,73.66 C313.1 ; C319.1 39.81,48.49 39.81,49.14 v1(40.32,49.64) ; v1(34.12,63.21) 34.23,63.21 v1(34.74,62.7) C305.1 ; v1(44.89,48.88) 44.89,48.24 C289.1 ; v1(53.78,35.72) 53.78,36.31 53.53,36.56 51.24,36.56 50.11,35.43 v1(48.83,35.43) ; v1(43.76,35.92) C309.1 ; C292.1 40.9,82.87 40.9,83.68 41.4,84.19 v1(41.72,84.19) ; C258.1 49.48,40.11 v1(48.86,39.48) ; C311.1 v1(31.43,37.2) ; v1(38.55,35.92) 38.55,35.55 38.3,35.3 C308.1 ; v1(48.83,94.58) 49.31,94.58 C343.2 ; C339.2 44.76,35.54 44.77,35.55 v1(44.77,35.92) ; C304.1 v1(46.43,70.34) ; v1(29.63,52.16) 30.04,52.16 30.55,51.65 C306.1 30.74,51.42 31.16,51.01 ; C340.2 v1(45.77,48.88)
  BOTTOM w0.102: U1.AH36 74.41,63.29 ; v2(74.03,55.7) 74.2,55.7 74.25,55.75 75.16,55.75 U1.AY36 ; v2(74.01,68.53) 74.03,68.53 74.24,68.33 U1.Y36 ; U1.AD36 73.71,65.81 73.57,65.95 v2(73.57,66)
  BOTTOM w0.191: 74.41,63.29 72.28,63.29 v2(72.2,63.21)
  BOTTOM w0.203: v2(73.84,60.99) 73.97,60.86 75.08,60.86 U1.AM36 ; v1(59.87,88.21) 59.83,88.16 59.83,87.54 60.19,87.18 EC5.2 ; U1.BH36 75.07,50.61 74.36,50.61 74.31,50.56 74.28,50.56 v2(74.23,50.51)
  BOTTOM w0.254: v1(48.94,57.77) 49.26,57.46 JDIM1.148 ; JDIM1.123 59.51,65.7 59.6,65.62 v1(59.75,65.62) ; v1(53.78,35.72) 53.78,35.29 54.87,34.2 JDIM1.241 ; v1(59.78,55.08) 59.4,54.7 JDIM1.159 ; v1(48.93,55.95) JDIM1.154 ; JDIM1.130 49.12,63.95 48.32,64.76 48.32,65.39 v1(47.97,65.75) ; U1.AN32 78.07,60.06 v2(78.07,60.11) ; JDIM1.220 48.88,39.45 v1(48.86,39.48) ; v1(47.46,66.13) 48.29,66.95 JDIM1.118 ; v1(57.03,67.14) 57.04,67.14 57.06,67.14 57.12,67.2 JDIM1.117 ; v1(46.8,68.69) 46.8,68.31 47.18,67.93 48.58,67.93 49.1,68.46 JDIM1.112 ; JDIM1.147 59.7,57.7 59.96,57.45 59.96,56.33 v1(59.85,56.23) 59.83,56.2 JDIM1.153 ; 48.83,82.54 49.25,82.95 JDIM1.54 ; JDIM1.136 48.99,62.46 v1(48.83,62.29) ; JDIM1.124 49.27,65.46 v1(48.96,65.77) ; U1.BE32 77.74,52.57 v2(78.07,52.9) ; JDIM1.160 49.05,54.46 v1(48.79,54.71) ; U1.R32 78.09,71.93 v2(78.09,72.06) ; v1(48.19,62.29) 48.19,61.7 48.94,60.95 JDIM1.142 ; v2(78.12,56.52) 77.74,56.14 U1.AW32 ; v1(60.39,65.62) 60.39,64.48 60.12,64.2 JDIM1.129 ; 54.57,45.05 54.91,44.71 JDIM1.199 ; v1(59.93,77.2) 59.43,77.7 JDIM1.75 ; v1(57.09,53.7) JDIM1.163 ; v1(61.58,61.45) 61.58,61.63 60.51,62.7 JDIM1.135 ; v1(60.93,61.49) 60.65,61.2 JDIM1.141 ; JDIM1.12 v1(48.86,93.45) ; v1(59.85,68.95) 59.7,68.95 59.46,68.7 JDIM1.111 ; v1(59.87,88.21) JDIM1.33 ; v1(52.18,50.6) 52.18,50.32 51.82,49.95 JDIM1.178 ; U1.AH32 77.74,63.46 v2(78.07,63.79) ; v1(48.96,72.46) JDIM1.96
  BOTTOM w0.508: v1(53.53,46.47) 53.53,45.96 54.44,45.05 54.57,45.05
  vias: v1(22.54,100.32) v1(22.54,99.17) v1(22.92,99.68) v1(23.05,100.82) v1(23.05,98.79) v1(23.3,100.19) v1(23.43,99.3) v1(23.68,100.7) v1(23.81,99.81) v1(24.06,101.21) v1(24.19,100.32) v1(24.57,100.82) v1(37.02,70.73) v1(39.43,70.73) v1(40.19,70.73) v1(41.36,60.79) v1(45.53,95.36) v1(46.16,95.36) v1(46.8,95.36) v1(47.43,95.36) v1(48.63,115.33) v1(48.65,114.69) v1(48.83,88.12) v1(48.83,85.97) v1(48.98,114.13) v1(48.96,90.54) v1(49.29,115.33) v1(49.29,114.69) v1(49.62,114.13) v1(49.92,115.35) v1(49.92,114.72) v1(50.25,114.16) v1(50.89,114.29) v1(61.78,68.95) v1(62.42,68.95) v1(62.67,75.17) v1(63.05,68.95) v1(63.43,75.17) v1(63.74,90.02) v1(63.69,68.95) v1(64.2,75.17) v1(64.37,90.02) v1(65.01,90.01) v1(65.64,90.02) v1(66.86,94.88) v1(67.02,117.44) v1(67.24,118.6)
+1.5V: length 81
  TOP w0.381: v2(202.14,20.56) 202.2,20.51 204.53,20.51 205.14,21.12 205.14,21.38 206.46,22.7 207.32,22.7 ; v2(209.31,19.14) 208.9,19.14 208.6,19.44 208.6,20.36 208.14,20.81 208.14,22.03 207.47,22.7 207.32,22.7 ; 207.32,22.7 v1(207.32,23.51) 207.32,24.14 206.97,24.48 206.13,24.48 205.14,25.47 203.33,25.47 202.63,26.17 R462.2
  IN1 w0.508: v2(200.04,19.04) 199.55,19.04 199.09,18.57 197.46,18.57 196.81,19.23 v2(196.81,19.24)
  IN2 w0.381: v2(209.31,19.14) 209.94,19.77 212.79,19.77 213.43,20.42 213.43,23.36 215.96,25.89 215.96,30.34 215.23,31.08 215.23,31.71 214.41,32.52 214.41,33.26 211.64,36.03 v1(211.64,37.2)
  IN2 w0.508: v2(200.04,19.04) 200.95,19.95 201.53,19.95 v2(202.14,20.56)
  IN3 w0.508: v2(171.64,23.75) 171.66,23.77 171.75,23.77 172.16,24.18 178.1,24.18 178.7,24.77 179.34,24.77 179.56,24.55 179.56,23.81 179.87,23.5 182.09,23.5 182.21,23.38 185.1,23.38 185.69,23.96 188.2,23.96 188.53,23.63 188.53,23.25 188.81,22.97 192.57,22.97 193.66,21.88 193.66,21.38 195.08,19.95 195.08,19.43 195.38,19.14 196.71,19.14 v2(196.81,19.24)
  BOTTOM w0.381: R449.1 211.72,37.12 v1(211.64,37.2)
  BOTTOM w0.508: v2(200.04,19.04) 199.96,19.04 199.51,19.48 Q21.2
+1.05V_DEEP_SUS: length 74.2
  TOP w0.254: R1267.2 100.65,28.43 101,28.08 101.92,28.08 102.17,27.82 102.17,27.44 102.37,27.24 102.75,27.24 103.06,27.55
  TOP w0.305: 103.06,27.55 103.57,27.55 104.35,28.33 v2(104.35,28.43)
  IN1 w0.254: v1(107.12,73.7) 106.95,73.7 105.22,75.42 105.22,78.65 104.61,79.26 103.21,79.26 101.36,77.41 101.36,75.04 101.95,74.45 101.95,71.87 101.65,71.56 101.65,67.91 101.95,67.61 101.95,66.54 102.5,65.99 102.5,60.42 103.6,59.32 103.6,57.22 103.92,56.9 103.92,55.9 104.49,55.33 108.37,55.33 111.06,58.03 113.2,58.03 113.43,57.8 v2(113.45,57.8)
  IN3 w0.254: v2(113.45,57.8) 114.11,57.8 115.02,56.88 115.02,55.27 112.08,52.32 112.08,49.69 111.19,48.8 111.19,46.34 110.73,45.88 110.73,44.59 110.12,43.98 110.12,43.24 109.84,42.96 v1(109.84,41.01)
  BOTTOM w0.254: R1277.1 105.44,28.69 105.18,28.43 v2(104.35,28.43) ; U1.CB14 89.15,41.69 v2(88.97,41.69) 88.96,41.69 U1.CB15 ; v1(107.12,73.7) 106.79,73.37 106.29,73.37 ; U1.CB12 90.18,42.15 90.14,42.15 v2(89.95,42.34) 90.28,42.66 U1.CA12
  vias: v1(104.84,36.21) v1(104.84,35.57) v1(104.86,34.94) v1(105.57,36.08) v1(105.57,35.44) v1(105.6,34.81) v1(108.65,42.05) v2(84.89,44.94) v2(84.89,44.28) v2(84.89,43.65) v2(85.64,44.94) v2(85.64,44.28) v2(85.64,42.34) v2(86.59,44.94) v2(86.59,42.34) v2(87.34,44.94) v2(87.36,42.99) v2(87.41,42.35)
+1.05V_LAN: length 3.5
  TOP w0.203: U24.30 44.04,108.44
  TOP w0.508: v1(43.5,110.73) 43.76,110.47 C636.1 C634.1 44.04,108.8 44.04,108.44
  vias: v1(38.78,102.57) v1(39.74,115.53) v1(40.04,114.67) v1(40.45,113.65) v1(40.85,114.87) v1(40.96,114.03) v1(48.91,107.96)
+1.05V_LAN_REGOUT:
  vias: v1(43.5,114.49) v1(43.7,115.1) v1(44.18,114.49) v1(47.43,108.62)
+1.8V: length 295.8
  TOP w0.254: v2(201.38,28.64) 200.62,29.4 R733.2
  TOP w0.508: v2(107.83,28.41) 107.83,27.63 105.29,25.09 105.29,24.71 102.46,21.88 98.82,21.88 98.16,21.22 93.44,21.22 92.47,22.19 91.5,22.19 89.62,24.07 82.82,24.07 77.15,18.4 77.15,17.26 76.52,16.62 75.63,16.62 74.86,15.86 74.86,15.35 73.8,14.29 56.12,14.29 55,15.4 v1(55,17) ; v2(207.4,19.67) 207.4,20.43 206.89,20.94 205.93,20.94 204.74,19.75 v1(204.16,19.75) 203.18,18.77 201.85,18.77 201.51,18.43 v2(201.18,18.43) ; v2(24.93,21.2) 24.22,21.2 23.02,20 22.3,20 21.01,21.3 15.1,21.3 v1(14.08,20.28) ; PQ9.1 26.63,30.96 v1(26.63,31.96) ; R448.1 213.51,31.36 212.89,30.75 v2(212.36,30.75)
  IN1 w0.508: v2(212.36,30.75) 212.18,30.57 211.39,30.57 211.03,30.21 211.03,26.24 210.53,25.74 209.86,25.74 209,26.6 209,28.33 208.39,28.94 208.39,29.2 207.86,29.73 203.86,29.73 202.6,28.48 201.54,28.48 v2(201.38,28.64)
  IN2 w0.508: v2(158.18,16.83) 158.32,16.69 172.87,16.69 173.91,17.73 182.34,17.73 183.86,16.22 185.04,16.22 185.29,15.96 185.31,15.96 185.88,15.39 190.47,15.39 190.88,14.98 191.95,14.98 192.07,14.87 196.53,14.87 196.96,15.3 196.96,15.66 197.29,15.99 199.43,15.99 201.18,17.74 v2(201.18,18.43) ; v1(55,17) 54.98,16.98 46.01,16.98 39.64,23.35 31.25,23.35 28.59,26.02 27.85,26.02 26.88,26.99 26.88,31.71 v1(26.63,31.96) ; v2(212.36,30.75) 213.75,29.35 213.75,25.51 212.86,24.62 212.86,20.76 212.48,20.38 209.64,20.38 208.29,19.04 207.68,19.04 207.4,19.32 v2(207.4,19.67)
  IN3 w0.508: v2(158.18,16.83) 158.18,16.54 158.13,16.49 157.62,15.98 144.81,15.98 142.41,18.38 137.58,18.38 136.84,17.64 131.25,17.64 129.93,18.96 128.03,18.96 126.83,17.77 124.67,17.77 124.27,17.36 ; v2(107.83,28.41) 107.91,28.33 107.91,22.65 110.51,20.05 113.47,20.05 115.33,18.19 118.94,18.19 119.7,17.44 119.9,17.44 120.53,16.8 122.74,16.8 122.85,16.9 ; v2(24.93,21.2) 24.93,24.03 25.61,24.71 25.61,29.54 26.1,30.02 26.1,31.43 v1(26.63,31.96)
  BOTTOM w0.102: R25332.1 v1(13.18,18.61)
  BOTTOM w0.254: v2(24.93,21.2) 24.3,20.57 R9042.1
  BOTTOM w0.508: R25332.1 13.4,19.59 v1(14.08,20.28) ; PR9227.1 22.81,36.43 23.2,36.82 24.01,36.82 24.45,36.38 24.45,35.42 25.08,34.78 25.59,34.78 25.72,34.91 26.86,34.91 27.11,34.66 27.11,32.63 26.63,32.14 v1(26.63,31.96)
+1.8V_DEEP_SUS: length 146.3
  TOP w0.254: 146.11,24.37 146.11,24.6 145.39,25.32 145.39,26.04 144.82,26.61 144.82,27.01 145.82,28.01 U35.5 ; v2(195.9,22.64) 195.79,22.64 v2(194.83,23.61) ; R662.1 R663.1
  TOP w0.381: R663.1 105.22,31.14 105.98,30.38 105.98,29.32 106.21,29.09 106.21,27.72 104.61,26.12 103.24,26.12 103.03,25.92 103.03,25.56 101.99,24.52 v2(101.97,24.52)
  TOP w0.508: 98.23,24.29 98.79,23.74 101.51,23.74 101.97,24.19 v2(101.97,24.52)
  IN3 w0.254: v2(146.18,24.24) 146.18,24.27 147.33,25.42 153.32,25.42 153.86,24.88 158.33,24.88 159.15,24.07 164.58,24.07 165.24,23.4 166.28,23.4 167.2,24.33 168.26,24.33 168.74,24.81 177.66,24.81 178.44,25.59 182.99,25.59 183.17,25.77 185.51,25.77 186.32,24.95 187.64,24.95 187.74,25.06 188.45,25.06 188.89,24.62 189.7,24.62 190.7,23.62 192.96,23.62 193.96,22.62 195.87,22.62 195.89,22.64 v2(195.9,22.64)
  IN3 w0.508: v2(101.97,24.52) 101.97,23.91 101.36,23.3 100.09,23.3 96.42,19.63 96.42,15.9 v2(96.18,15.66)
  BOTTOM w0.254: R180.1 v2(194.83,23.61)
  BOTTOM w0.508: v2(96.18,15.66) 96.18,14.29 96.68,13.78 113.78,13.78 114.41,14.41 118.12,14.41 118.76,13.78 125.28,13.78 125.88,14.37 125.88,15.51 126.1,15.73 127.2,15.73 127.51,15.43 137.43,15.43 137.73,15.73 139.1,15.73 139.43,15.4 147,15.4 147.8,16.2 v2(147.8,18.66)
  vias: v1(97.55,27.98) v1(98.18,27.98) v1(146.26,23.61)
+1.8V_S5: length 10.5
  IN3 w0.254: 27.62,28.94 27.11,28.43 27.11,26.02 26.86,25.77 26.86,24.12 25.72,22.97 25.72,20.31 v2(25.84,20.18)
  BOTTOM w0.254: v2(25.84,20.18) 25.45,20.57 R9041.1
  vias: v1(19.75,90.66) v1(20.25,91.43) v1(20.41,90.79) v1(20.89,91.3) v1(21.52,91.3) v1(23.23,26.58) v1(24.65,91.93) v1(24.65,91.3) v1(28.38,30.21) v1(28.38,29.58) v1(28.38,28.94) v1(28.54,31.79) v1(29.02,31.1) v1(29.02,30.47) v1(29.02,29.83) v1(29.02,29.2) v1(100.65,24.52) v1(101.28,24.52)
+1.8V_SW: length 35.5
  IN2 w0.508: 12.59,20.28 12.61,20.3 12.61,20.86 13.08,21.32 16.9,21.32 17.16,21.07 18.17,21.07 18.6,20.64 v1(18.6,18.78) ; 12.59,20.28 v2(12.59,20.25) ; 12.59,20.28 11.93,20.28 11.01,21.2 11.01,22.69 11.96,23.65 13.41,23.65 14.64,24.88 v2(14.9,24.88)
  BOTTOM w0.203: 18.6,18.66 18.6,17.92 18.35,17.66 17.33,17.66 16.73,18.27 R25273.2 ; 18.6,18.66 19.08,18.18 R25276.2 ; 18.6,18.66 v1(18.6,18.78) ; U6502.12 15.94,22.34 15.68,22.08
  BOTTOM w0.508: R9048.2 20.65,25.45 20.27,25.82 ; 19.34,26.53 18.93,26.53 18.5,26.96 16.32,26.96 15.66,26.3 ; 15.68,22.08 14.63,21.03 C6546.1 C6545.1 C6544.1 11.24,21.03 EC6500.1 11.24,20.34 R25332.2 11.98,19.62 12.59,20.23 v2(12.59,20.25)
  vias: v1(15.23,26.15)
+1.35V_GFX: length 40.8
  TOP w0.356: C496.2 131.28,86.34 v2(131.41,86.21) ; v2(128.2,87.16) 128.16,87.12 C483.2 ; C480.2 131.68,113.66 v2(131.41,113.4) ; v2(138.61,86.21) 138.48,86.33 C478.2
  TOP w0.381: v2(107.35,98.21) 107.35,98.49 C450.2 ; C479.2 132.04,91.63 v2(132.21,91.81) ; C494.2 131.38,92.58 v2(131.41,92.61) ; C449.2 108.81,97.58 v2(108.75,97.52) ; v2(128.22,90.22) 128.2,90.24 C502.1
  TOP w0.457: C495.2 129.97,109.45 v2(129.98,109.46) ; C440.2 122.5,93.2 v1(122.49,93.2) 122.48,93.2 C438.2 121.23,93.2 v1(121.22,93.2) 121.09,93.08 R318.1
  IN3 w0.381: 129.98,108.44 v2(129.98,109.46)
  BOTTOM w0.254: v2(116.14,99.25) 116.14,99.17 115.71,98.74 114.96,98.74 U8.H26 ; U8.H24 v2(113.73,98.37) ; U8.E26 v2(114.52,96.7) ; v2(112.1,96.73) 112.1,96.66 U8.E23
  BOTTOM w0.305: v2(116.14,100.87) 116.14,101.08 115.81,101.41 115.09,101.41 U8.L26 ; v2(114.51,93.41) 114.89,93.83 U8.B26 ; v2(112.94,100.86) U8.L24
  BOTTOM w0.33: v2(128.2,85.38) 127.82,85 VRAM1.T3 ; VRAM2.H12 VRAM2.G13 ; VRAM1.T1 127.81,83.4 v2(127.41,83.01) ; v2(131.41,105.41) 131.4,105.41 VRAM2.F14 ; VRAM2.C10 128.99,108.62 v2(129.01,108.62) 129.01,108.61 129.41,108.21 VRAM2.D11 129.41,108.2 v2(129.01,107.81) 129.01,107.8 VRAM2.D12 ; VRAM1.P1 129.41,83.4 v2(129.01,83.01) ; v2(129.81,85.38) 129.42,85 VRAM1.P3 ; VRAM1.R5 128.61,86.61 128.2,87.01 v2(128.2,87.16) ; VRAM1.M1 131.02,83.4 v2(131.41,83.01) ; VRAM2.B14 127.81,105.8 v2(127.41,105.41) ; VRAM1.B3 139.02,85 v2(139.41,84.61) ; VRAM1.L4 131.42,85.41 v2(131.41,85.41) 131.01,85 VRAM1.M3 ; VRAM1.N5 130.21,87.01 v2(130.01,87.21) ; VRAM1.H12 134.21,92.21 v2(134.61,92.61) ; VRAM2.L14 135.02,105.8 v2(135.41,105.41) 135.81,105.8 ; v2(131.41,83.81) 131.81,84.2 VRAM1.L2 ; VRAM2.L13 VRAM2.M12 ; VRAM2.B12 127.81,107.41 v2(127.41,107.81) ; VRAM2.D14 129.41,105.8 v2(129.01,105.41)
  BOTTOM w0.356: VRAM2.K12 134.21,107.41 v2(134.61,107.81) ; v2(129.98,109.46) 130.21,109.23 VRAM2.E10 ; VRAM2.G13 VRAM2.F12 131.01,107.4 v2(131.41,107.81) 131.81,108.2 VRAM2.G11
  BOTTOM w0.381: v2(114.52,95.01) 114.14,94.63 U8.C25
  BOTTOM w0.457: 125.91,93.2 122.5,93.2 v1(122.49,93.2) v1(121.22,93.2)
  vias: v1(129.04,104.68) v1(129.98,101.33) v1(130.62,101.33) v1(131.25,101.33) v1(131.89,101.33) v1(140.55,82.46) v1(140.55,81.8) v1(140.52,81.16) v1(141.21,84.77) v1(141.21,84.06) v1(141.21,83.43) v1(141.24,82.76) v1(141.24,82.05) v1(141.24,81.42) v1(141.51,99.86) v1(141.9,83.91) v1(141.9,83.22) v1(141.9,82.59) v1(141.92,81.9) v1(141.92,81.22) v2(104.65,97.46) v2(104.65,96.64) v2(109.49,97.47) v2(110.35,99.05) v2(111.31,107.43) v2(111.28,105.83) v2(111.28,105.03) v2(111.29,104.24) v2(111.29,100.83) v2(111.29,100.01) v2(111.29,99.19) v2(111.36,101.66) v2(127.41,114.99) v2(128.21,116.61) v2(128.21,93.41) v2(128.21,91.81) v2(129.01,116.61) v2(129.01,94.21) v2(129.81,114.21) v2(129.81,91.81) v2(130.61,114.99) v2(130.63,112.62) v2(130.61,90.22) v2(131.41,115.81) v2(131.41,114.99) v2(131.41,106.16) v2(131.41,94.21) v2(131.41,93.41) v2(131.41,91.01) v2(132.21,114.99) v2(132.21,83.01) v2(133.01,83.81) v2(133.01,83.01) v2(133.81,87.01) v2(134.61,115.81) v2(134.61,91.81) v2(134.61,86.21) v2(134.61,85.41) v2(134.61,83.81) v2(134.61,83.01) v2(135.41,115.81) v2(135.41,114.21) v2(135.41,94.21) v2(135.41,91.01) v2(135.41,83.01) v2(136.21,112.61) v2(136.21,109.41) v2(136.21,107.8) v2(136.21,92.61) v2(136.21,91.01) v2(136.21,87.01) v2(137.01,116.61) v2(137.01,106.16) v2(137.01,94.21) v2(137.01,92.61) v2(137.01,85.41) v2(137.01,83.01) v2(137.81,114.21) v2(137.81,113.41) v2(137.81,108.61) v2(137.81,107.81) v2(137.81,91.01) v2(137.81,90.21) v2(138.61,116.61) v2(138.61,108.61) v2(138.61,106.21) v2(138.61,105.41) v2(138.61,92.61) v2(138.61,91.81) v2(138.61,91.01) v2(138.61,83.81) v2(138.61,83.01) v2(139.41,114.21) v2(139.41,107.01) v2(139.41,94.21) v2(139.41,91.81) v2(139.41,90.21) v2(140.21,86.21)
+1V8_AON: length 291.5
  TOP w0.203: 173.42,31.61 173.54,31.74 Q13.5 ; 173.42,31.61 173.42,31.05 172.89,30.52 R365.2 172.89,30.06 172.71,29.88 172.71,29.7 v2(172.58,29.58) ; 173.42,31.61 173.29,31.74 Q13.2 171.63,31.74 171.31,31.41 171.31,30.92 171.58,30.65 R362.2
  TOP w0.254: v2(71.05,114.77) 71.31,115.02 PR9018.1
  TOP w0.381: R382.2 101.54,123.43 103.19,123.43 103.31,123.55 104.9,123.55 v1(105.42,124.07) ; R25490.2 R397.2 87.44,98.03 v1(86.93,97.52)
  TOP w0.508: R25322.2 200.86,11.98 Q6512.2 201.65,11.71 v2(201.74,11.8) ; R403.2 84.75,97.01 v1(84.39,96.66)
  IN1 w0.254: v2(71.05,114.77) 71.03,114.77 70.88,114.62 70.22,114.62 69.19,113.59 69.19,110.74 68.49,110.04 68.49,107.99 69.17,107.31 71.55,107.31 72.34,106.53 72.85,106.53 74.26,105.12 74.26,103.93 75.54,102.65 78.01,102.65 78.14,102.77 82.81,102.77 86.93,98.64 v1(86.93,97.52)
  IN1 w0.381: v1(99.73,120.64) 99.73,119.04 101.29,117.47 101.29,109.6 99.12,107.43 99.12,106.56 99.43,106.26 99.43,105.45 99.12,105.14 99.12,99.91 100.01,99.02 100.34,99.02
  IN1 w0.508: v2(201.74,11.8) 200.39,11.8 198.82,13.37 v2(198.82,15.28)
  IN1 w1.016: 63.59,99.4 65.75,99.4 66.74,98.41 69.02,98.41 70.29,99.68 76.52,99.68 v1(76.77,99.43) 77.18,99.02 80.61,99.02 82.48,97.14 ; 50.51,99 50.18,98.67 45.53,98.67 44.44,97.57 32.09,97.57 31.25,98.41 28.26,98.41 26.6,96.76
  IN2 w0.381: v1(98,122.26) 98.03,122.24 99.33,122.24 100.39,123.3 104.66,123.3 v1(105.42,124.07)
  IN3 w0.254: v2(198.82,15.28) 198.36,15.73 198.36,22.71 198.09,22.97 197.13,22.97 196.25,23.85 195.43,23.85 194.96,24.32 193.47,24.32 192.65,25.13 191.26,25.13 190.1,26.28 190.1,27.34 189.85,27.6 188.91,27.6 188.58,27.27 187.08,27.27 186.4,27.95 186.4,28.74 185.46,29.67 173.71,29.67 173.17,30.21 172.86,30.21 172.58,29.93 v2(172.58,29.58) 172.17,29.98 168.67,29.98 168.09,30.57 151.75,30.57 151.23,31.09 147.16,31.09 147.09,31.02 143.16,31.02 142.31,31.86 142.31,32.33 139.91,34.73 139.91,35.17 139.56,35.52 137.69,35.52 136.92,36.28 136.92,38.44 136.64,38.72 136.64,40.37 134.72,42.29
  IN3 w0.508: v2(108.04,87.54) 109.41,86.17 109.41,85.41 111.54,83.27 111.54,81.8 109.27,79.53 109.27,78.08 111.54,75.81 113.07,75.81 113.71,75.16 113.71,73.7 114.78,72.63 114.78,66.47 116.17,65.09 121.42,65.09 125.28,61.23 125.28,53.43 124.9,53.05 124.9,46.29 125.3,45.9 126.08,45.9 128.01,43.97 131.59,43.97 132.14,43.42 133.69,43.42 134.72,42.39 134.72,42.29
  BOTTOM w0.203: PR9076.2 77.19,101.83 77.19,101.68 77.4,101.46 77.4,99.55 77.26,99.41 76.79,99.41 v1(76.77,99.43)
  BOTTOM w0.356: v2(102.22,97.75) 102.4,97.75 102.68,98.03 103.23,98.03 U8.G12 ; U8.G10 v2(101.32,97.48)
  BOTTOM w0.381: v2(108.04,87.54) 108.67,87.54 109.37,88.23 R339.2
  vias: v1(26.14,95.92) v1(26.4,98.41) v1(26.78,95.92) v1(83.83,96.33) v1(86.17,96.71) v1(98.31,86.73) v1(98.31,86.09) v2(102.17,98.41)
