# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PLTRST#_EC: length 4.6
  TOP w0.102: U37.22 182.18,19.78 182.16,19.8 C2374.1 181.66,19.45 180.86,18.65 180.32,18.65 v1(180.11,18.44) 179.94,18.27 R894.2
PM_EXTTS#0: length 5.7
  TOP w0.102: v1(47.56,62.29) 47.56,62.47 47.95,62.86 49.38,62.86 49.54,62.7 R224.2
  BOTTOM w0.102: JDIM1.134 48.17,62.95 47.56,62.34 v1(47.56,62.29)
PMON: length 33.3
  TOP w0.102: v2(142.43,50.89) 141.86,51.46 141.84,51.46 141.7,51.6 PR7039.1
  TOP w0.203: v2(138.44,32.88) 138.44,32.55 v1(137.86,31.96) 137.58,31.69 PR23.1 PC18.2
  IN2 w0.089: v2(133.21,41.46) 133.47,41.46 134.02,42.02 134.02,42.35 135.34,43.67 135.34,45.2 136.92,46.77 138.54,46.77 139.89,48.12 139.89,48.68 141.39,50.18 141.72,50.18 v2(142.43,50.89)
  IN3 w0.089: v2(133.21,41.46) 134.25,40.42 134.25,37.32 133.44,36.51 133.44,35.54 134.94,34.04 135.32,34.04 135.86,33.49 136.98,33.49 137.19,33.29 138.03,33.29 v2(138.44,32.88)
  BOTTOM w0.203: PR25.1 137.8,32.11 138.44,32.75 v2(138.44,32.88)
PP: length 2
  TOP w0.102: U33.4 129,20.21 129.35,20.56 v1(129.45,20.56) R600.2
PROC_POPIRCOMP: length 4.3
  TOP w0.079: R16.1 78.32,46.85 ; v2(81.21,46.54) 80.77,46.1 80.24,46.1 80.2,46.06
  TOP w0.102: 80.2,46.06 79.84,46.06 79.34,46.57 79.28,46.57 78.83,47.03 78.5,47.03 78.32,46.85
  BOTTOM w0.089: v2(81.21,46.54) 81.21,46.6 80.99,46.82 U1.BP27
PROC_TRST#: length 11.4
  TOP w0.102: v2(93.84,66.69) 94.33,67.18 97.1,67.18 97.45,67.52 101.59,67.52 103.09,69.03 R6.2
  BOTTOM w0.102: v2(93.84,66.69) 94.03,66.87 U1.AB6
PROCHOT#: length 10.2
  BOTTOM w0.079: U1.Y4 95.95,67.98 96.25,67.68 96.58,67.68 96.75,67.85 99.41,67.85 100.84,69.27 100.84,69.61 101.02,69.8 101.02,70.52 101.16,70.66 101.44,70.66 101.84,71.06 101.84,71.21 102.22,71.59 102.23,71.59
  BOTTOM w0.102: R9.2 103.06,72.25 102.4,71.59 102.23,71.59
PROCHOT_EC: length 18.8
  TOP w0.102: Q6509.2 171.97,18.46 172.4,18.03 172.4,17.13 173.24,16.29 175.04,16.29 175.25,16.5 175.25,17.46 176.53,18.75 v1(176.57,18.75) R25298.2 177.48,18.84 176.92,19.4 176.92,20.58 177.14,20.79 177.66,20.79 177.73,20.86 178.83,20.86 178.95,20.99 C6610.2 180.09,21.82 180.43,22.16 181.54,22.16 181.64,22.06 182.05,22.06 182.33,21.78 U37.17
PROCPWRGD: length 7.3
  BOTTOM w0.079: U1.AR2 97.04,59.09 97.54,59.09 97.71,58.93 98.12,58.93 98.51,59.32
  BOTTOM w0.102: 98.51,59.32 98.89,59.32 99.62,60.04 101.01,60.04 101.13,60.16 C6619.1 101.65,60.44 R34.2 102.5,60.78 v1(102.5,61)
PS_FB_CLAMP: length 5.9
  BOTTOM w0.102: R313.1 91.25,98.16 92.75,96.66 95.46,96.66 U8.F3
PTP_PWR_EN#: length 3.4
  TOP w0.102: TP9019.1 186.8,31.36 186.39,31.76 185.83,31.76 185.76,31.69 185.76,30.84 186.05,30.55 U37.125
PULSAR_38P4M_REFCLK: length 105.6
  TOP w0.102: L1.1 100.02,33.23 102.2,31.05 102.2,30.44 103.41,29.22 104.78,29.22 105.29,28.71 105.29,28.08 104.28,27.06 v2(104.28,26.91)
  IN1 w0.089: v2(104.28,26.91) 104.28,26.56 104.76,26.08 118.61,26.08 118.97,26.44 125.12,26.44 126.41,25.15 132.21,25.15 132.38,25.32 137.03,25.32 137.69,24.66 144.73,24.66 144.95,24.88 152.67,24.88 153.64,23.91 158.86,23.91 159.42,23.35 164.3,23.35 165.44,22.22 170.57,22.22 171.15,21.63 172.9,21.63 173.37,22.1 173.76,22.1 174.78,23.13 176.05,23.13 176.61,22.58 177.2,22.58 177.66,23.04 178.13,23.04 178.36,22.81 184.92,22.81 187.53,20.2 188.12,20.2 189.19,19.14 189.19,17.23 v2(189.6,16.82)
  BOTTOM w0.102: v2(189.6,16.82) 189.6,15.68 189.9,15.38 CN17.64
PULSAR_38P4M_REFCLK_R: length 7.6
  TOP w0.102: L1.2 99.24,34.07 98.54,34.78 C204.2 R148.2 97.22,34.71 v2(97.78,34.15)
  BOTTOM w0.079: U1.CM3 96.39,35 96.58,34.81 96.58,34.56 96.94,34.2 97.72,34.2 v2(97.78,34.15)
PWM1_CORE: length 32.8
  TOP w0.254: PR7105.1 118.57,67.77 118.75,67.59 119.45,67.59 119.62,67.42 arc(119.62,67.42) 119.62,67.42 v1(119.62,66.97)
  IN1 w0.203: v2(130.67,57.69) 130.85,57.52 130.85,54.9 131.79,53.96 v1(134.61,53.96)
  IN3 w0.203: v1(119.62,66.97) 119.62,68.87 120.08,69.33 122.88,69.33 124.4,67.8 127.42,67.8 arc(127.42,67.8) 127.42,67.8 130.41,64.81 arc(130.41,64.81) 130.41,64.81 130.41,60.13 129.7,59.42 arc(129.7,59.42) 129.7,59.42 129.7,58.61 130.52,57.8 130.57,57.8 v2(130.67,57.69)
  BOTTOM w0.203: v1(134.61,53.96) 134.68,53.96 134.77,53.87 PU7000.17
PWM2_CORE: length 4
  BOTTOM w0.203: PU7000.16 134.19,53.47 134.02,53.3 134.02,51.78 133.5,51.25 PR7077.1
PWM-VID: length 41.5
  TOP w0.102: v1(70.72,112.84) 71.33,113.45 PR9015.1
  IN1 w0.089: v1(89.11,89.06) 89.6,89.55 89.6,90.61 88.45,91.76 88.45,96.17 88.08,96.55 88.08,99.12 83.41,103.79 76.93,103.79 76.58,104.14 75.49,104.14 75.15,104.48 75.15,105.49 73.51,107.14 73.51,107.72 73.05,108.18 72.58,108.18 72.55,108.21 70.41,108.21 70.15,108.46 70.15,112.57 70.42,112.84 v1(70.72,112.84)
  BOTTOM w0.102: R370.1 89.84,89.92 89.11,89.2 v1(89.11,89.06) ; v1(70.72,112.84) 70.52,112.84 70.12,112.43 v1(70.01,112.43)
PWM_GT: length 34.2
  IN2 w0.203: v1(124.98,79.99) 125.28,79.69 126.71,79.69 126.74,79.68 128.05,78.37 128.05,76.95 127.67,76.57 127.67,75.27 126.5,74.1 126.5,72.6 130.29,68.82 132.45,68.82 133.21,68.06 133.21,63.46 133.82,62.85 134.66,62.85 135.06,62.44 135.06,56.5 v1(134.48,55.92)
  BOTTOM w0.203: v1(134.48,55.92) 134.53,55.87 PU7000.22
  BOTTOM w0.254: v1(124.98,79.99) 125.43,79.54 PR7109.1
PWM_SA: length 22.8
  IN2 w0.254: v1(141.24,58.61) 141.31,58.61 144.84,55.08 144.84,52.56 146.75,50.66 146.75,48.88 143.04,45.17 140.47,45.17 140.02,44.72 v1(139.96,44.72)
  BOTTOM w0.203: PU7000.36 140.95,58.17 141.24,58.46 v1(141.24,58.61)
  BOTTOM w0.254: PR7113.1 139.91,43.95 139.96,44 v1(139.96,44.72)
PWR_DEBUG: length 1
  TOP w0.102: R218.2 105.48,67.21 TP43.1
PWRLED#: length 50.3
  TOP w0.102: U37.24 184.53,18.98 184.96,19.42 185.16,19.42 187.6,21.86 190.51,21.86 191.32,22.67 192.11,22.67 192.52,22.26 v2(192.52,22.13)
  IN1 w0.089: v2(206.21,26.05) 206.26,26.05 207.07,25.23 208.4,25.23 209.28,24.35 211.87,24.35 213.88,26.36 213.88,28.64 215.61,30.36 215.61,31.76 216.09,32.24 216.09,33.46 212.32,37.22 v2(212.32,37.22)
  IN2 w0.089: v2(192.52,22.13) 192.67,22.29 193.74,22.29 194.05,22.6 195.32,22.6 195.74,23.02 196.23,23.02 196.27,22.98 199.42,22.98 199.49,23.06 200.84,23.06 203.12,25.33 205.49,25.33 v2(206.21,26.05)
  BOTTOM w0.102: CN35.22 212.49,37.4 v2(212.32,37.22)
R_SPK+: length 90.3
  TOP w1.016: 119.19,15.91 119.75,15.35 181.44,15.35 182.15,14.65 v1(183.58,14.65)
  IN3 w1.016: 205.42,19.47 205.42,18.23 204.47,17.28 204.47,16.12 202.64,14.29 198.89,14.29 198.58,13.98 191.91,13.98 190.13,15.76 186.91,15.76 185.76,14.62 184.97,14.62
  vias: v1(209.23,31.08) v1(209.87,31.08) v2(184.39,15.63) v2(184.97,15.47)
R_SPK+_1:
  vias: v1(119.11,19.59) v1(119.29,20.26)
R_SPK-: length 93.1
  TOP w1.016: 117.69,15.15 118.81,14.03 180.87,14.03 181.65,13.24 182.48,13.24 183.68,12.05 185.1,12.05
  IN3 w1.016: 186.35,13.33 187.45,14.44 189.58,14.44 191.37,12.65 199.29,12.65 199.6,12.97 203.21,12.97 204.4,14.16 205.83,14.16 206.96,15.29 206.96,16.83
  vias: v1(186.14,11.72) v1(209,31.68) v1(209.69,31.71) v2(185.84,12.33) v2(186.42,12.33)
R_SPK-_1:
  vias: v1(118.22,20.26) v1(118.22,19.59)
RAM_ID0: length 10.4
  BOTTOM w0.079: U1.CN22 84.1,35.97 84.52,35.56 84.52,35.04 84.77,34.6 84.77,33.69 85.36,33.11 85.36,32.09 85.46,31.99
  BOTTOM w0.102: 85.46,31.99 85.68,31.77 85.68,31.14 R25378.2 85.28,30.69 85.28,29.5 v1(84.82,29.04) 84.64,28.87 84.64,27.71 84.18,27.24 R25381.1
RAM_ID1: length 6.1
  BOTTOM w0.079: U1.CR22 84.19,34.52 84.4,34.31 84.4,31.79 84.16,31.56 84.16,31.48
  BOTTOM w0.102: R25382.1 83.88,29.42 83.68,29.63 83.68,30.78 R25379.2 84.16,31.48
RAM_ID2: length 16.8
  BOTTOM w0.079: U1.CM22 84.28,36.63 84.62,36.97 85.84,36.97 86.37,36.44 86.37,36.21 86.32,36.16 86.32,35.85 86.37,35.8 86.37,34.17 85.53,33.34 85.53,32.24 85.72,32.05
  BOTTOM w0.102: 85.72,32.05 85.91,31.86 v1(85.91,29.75) 85.91,29.04 85.91,29.03 85.91,28.7 85.53,28.32 85.53,26.35 84.28,25.1 R25383.1 83.86,24.63 83.77,24.55 R25380.2
RAM_ID3: length 15.3
  BOTTOM w0.079: U1.CP22 84.19,35.28 84.56,34.62 84.56,31.82 84.63,31.75 84.63,31.6
  BOTTOM w0.102: R25384.1 80.82,25.33 80.11,26.04 R25385.2 80.11,26.49 80.28,26.66 80.91,26.66 v1(82.08,25.49) 82.55,25.49 83.63,26.57 83.63,27.07 84.31,27.74 84.31,29.51 84.52,29.71 84.52,30.04 84.63,30.15 84.63,31.6
REGN6V: length 12.9
  TOP w0.254: v1(130.36,28.79) 131.3,29.73 PC9.1 131.6,29.92 132.04,30.36 132.04,32.5 131.13,33.41 131.13,34.28 131.38,34.53 133.16,34.53 133.38,34.75 134.21,34.75 PR39.1
  BOTTOM w0.198: PU1.24 131.38,29.51
  BOTTOM w0.203: 131.38,29.51 131.23,29.51 130.52,28.79 v1(130.36,28.79)
REQ_WLAN#: length 11.7
  TOP w0.102: v2(175.53,21.47) 175.45,21.54 Q63.1
  IN3 w0.089: v2(175.53,21.47) 175.77,21.47 176.18,21.87 177.07,21.87 177.28,21.67 180.71,21.67 180.73,21.69 180.76,21.69 v2(180.83,21.75)
  BOTTOM w0.102: v2(180.83,21.75) 180.83,21.13 181.06,20.89 181.06,20.18 181.16,20.07 R652.1 181.73,20.07 182.21,19.59 182.21,18.32 182.4,18.13 CN17.53
RF_EN: length 181.6
  TOP w0.102: R25318.2 v1(197.3,12.64) 197.3,12.79 197.55,13.04 197.55,14.93 197.14,15.34 197.14,16.17 197.42,16.45 197.42,17.35 197.22,17.55 196.83,17.55 196.6,17.33 195.48,17.33 195.19,17.61 193.72,17.61 193.01,18.32 v2(192.78,18.32) 192.25,18.85 192.25,19.93 193.38,21.06 193.38,22.49 192.52,23.35 190.13,23.35 v2(189.65,23.84) ; v2(64.73,27.62) 64.53,27.82 64.53,28.64 64.22,28.94 63.08,28.94 62.98,29.04 62.98,29.91 62.88,30.01 62.88,30.72 62.95,30.8 62.95,31.25 62.67,31.53 62.67,40.96 64.48,42.76 R25494.1
  IN2 w0.089: v2(189.65,23.84) 189.65,24.47 190.3,25.12 190.3,26.78 189.55,27.53 189.09,27.53 188.4,26.83 188.01,26.83 187.38,26.2 185.81,26.2 185.06,26.95 183.81,26.95 183.12,27.65 180.6,27.65 179.46,28.78 177.77,28.78 177.39,29.16 172.29,29.16 171.54,29.91 164.45,29.91 163.85,30.51 161.59,30.51 161.06,31.04 156.06,31.04 155.56,31.55 147.1,31.55 146.26,32.39 144.98,32.39 144.35,33.01 143.68,33.01 143.11,33.58 140.89,33.58 140.75,33.72 136.44,33.72 136.33,33.83 133.55,33.83 132.96,34.42 129.07,34.42 128.85,34.2 128.85,33.77 128.66,33.58 127.76,33.58 127.23,33.04 124.89,33.04 122.98,31.12 118.33,31.12 118.13,30.93 110.02,30.93 109.39,30.29 105.25,30.29 104.47,29.51 102.68,29.51 101.68,30.51 97.65,30.51 97.46,30.69 94.54,30.69 94.07,31.17 93.44,31.17 92.83,31.79 88.35,31.79 88.15,31.58 84.77,31.58 84.44,31.25 78.78,31.25 78.12,31.91 72.96,31.91 72.73,32.14 70.45,32.14 70.17,31.86 68.77,31.86 68.13,31.23 67.37,31.23 66.1,29.96 66.1,27.82 65.75,27.47 64.88,27.47 v2(64.73,27.62)
  BOTTOM w0.102: CN17.56 191.47,17.38 191.97,17.88 192.34,17.88 v2(192.78,18.32) 192.95,18.15 R672.1
RF_OFF_PCH: length 12.7
  BOTTOM w0.079: 71.31,41.52 71.31,41.65 74.07,44.42 U1.BV36
  BOTTOM w0.102: 71.31,41.52 71.31,41.39 68.99,39.07 68.99,38.79 68.24,38.04 66.43,38.04 66.38,37.98 R37.1
RGND_CORE: length 34.8
  TOP w0.102: PR7046.2 119.11,51.22 119.29,51.4 119.56,51.4 119.75,51.21 119.75,50.43 120,50.18 v2(120.18,50.18) ; v1(142.76,51.42) 142.81,51.42 143.16,51.77 144.25,51.77 PC7009.1 144.72,51.6 144.93,51.8 145.34,51.8 PC7008.1
  IN1 w0.089: v1(142.76,51.42) 142.73,51.42 142.38,51.78 139.79,51.78 136.97,48.96 132.22,48.96 131.04,47.78 121.18,47.78 120.65,48.31 120.65,49.96 120.43,50.18 v2(120.18,50.18)
  BOTTOM w0.102: v1(142.76,51.42) 142.43,51.42 141.85,52 PU7000.48
RGND_GT: length 55.2
  TOP w0.102: PC7015.1 136.04,58.03 v1(135.82,57.82) 135.5,58.14 PC7014.1 ; PR7053.2 103.4,78.22 v2(104,78.22)
  IN1 w0.089: v2(104,78.22) 103.54,77.76 103.54,74.97 103.82,74.69 103.82,72.05 102.87,71.1 102.87,68.6 104.07,67.4 104.07,64.63 105.04,63.66 108.7,63.66 111.64,60.72 114.35,60.72 115.9,59.17 118.13,59.17 118.61,58.69 133.74,58.69 133.89,58.84 133.89,59.12 v2(133.23,59.78)
  IN3 w0.089: v2(133.23,59.78) 133.23,59.38 134.49,58.13 135.29,58.13 135.6,57.82 v1(135.82,57.82)
  BOTTOM w0.102: PU7000.25 136.08,57.57 v1(135.82,57.82)
RGND_SA: length 50
  TOP w0.102: PR7062.2 117.9,45.48 v1(118.76,45.48)
  IN1 w0.089: v1(118.76,45.48) 117.87,45.48 117.66,45.27 117.66,44.66 117.82,44.51 118.63,44.51 120.04,45.92 122.43,45.92 122.67,46.16 122.67,46.54 122.87,46.75 123.28,46.75 123.48,46.54 123.48,46.14 123.7,45.92 128.24,45.92 128.33,46.01 128.33,46.68 128.42,46.77 128.78,46.77 128.87,46.68 128.87,46.01 128.95,45.92 129.31,45.92 129.4,46.01 129.4,46.68 129.49,46.77 129.84,46.77 129.93,46.68 129.93,46.01 130.02,45.92 130.56,45.92 131.59,46.95 132.75,46.95 133.97,48.17 137.4,48.17 138.67,49.44 140.14,49.44 140.66,49.96 142.19,49.96 143.85,48.3 144.21,48.3 145.1,49.19 145.1,49.89 144.89,50.09 144.59,50.09 144.38,50.29 144.38,50.7 144.59,50.9 144.89,50.9 145.1,51.1 145.1,51.51 144.89,51.71 143.89,51.71 143.69,51.92 143.69,52.32 143.89,52.53 144.89,52.53 145.1,52.73 145.1,53.2 145.36,53.46 v1(145.73,53.46)
  BOTTOM w0.102: PU7000.44 143.27,53.87 PC7024.1 143.97,53.76 144.55,53.76 144.84,53.46 PC7022.1 v1(145.73,53.46)
RING2: length 24.7
  IN3 w1.016: 199.02,34.38 199.02,35.8 201.08,37.86 202.35,37.86 203.62,39.12 203.62,39.64 207.45,43.47 207.96,43.47 210.38,45.88 214.36,45.88 214.9,45.35
  BOTTOM w0.203: U20.17 199.77,32.03 v1(199.1,32.7)
  vias: v1(214.6,44.61) v1(214.92,44.08) v1(215.24,44.63)
ROM_CS: length 1.8
  TOP w0.152: TP67.1 103.69,95.73 v2(103,95.04)
  BOTTOM w0.102: v2(103,95.04) U8.D12
ROM_SCLK: length 7.2
  TOP w0.102: v2(102.67,92.63) 102.61,92.63 102.17,93.08 102.17,93.41 v2(102.97,94.21)
  BOTTOM w0.102: v2(102.97,94.21) 102.97,94.23 103.37,94.63 U8.C12 ; R342.1 R352.2 104.08,90.02 102.8,91.3 102.8,92.49 v2(102.67,92.63)
ROM_SI: length 6.3
  BOTTOM w0.102: R341.1 R350.2 104.84,89.78 104.33,90.28 104.14,90.28 103.05,91.38 103.05,93.49 U8.B12
ROM_SO: length 7.4
  BOTTOM w0.102: R343.1 106.86,89 R351.2 107.64,90.15 107,90.79 105.09,90.79 103.39,92.49 U8.A12
RSET: length 5.4
  TOP w0.203: U24.31 43.64,108.17
  TOP w0.254: 43.64,108.17 43.24,108.57 42.73,108.57 42.51,108.79 42.51,110.9 v1(42.28,111.14) 42.18,111.24 R508.2
RSMRST#: length 199.5
  TOP w0.102: v2(61.71,28.71) 61.71,28.74 61.81,28.84 61.81,29.35 62.04,29.58 62.04,30.16 61.99,30.21 61.99,41.64 v1(62.47,42.12) 62.29,42.3 62.29,43.56 R47.2 ; U37.112 191.25,29.09 190.63,28.47 190.54,28.47 189.82,27.75 189.15,27.75 188.05,26.65 v2(188.05,24.55)
  IN1 w0.089: v2(188.05,24.55) 186.92,23.42 186.92,23.06 186.51,22.66 186.51,21.92 187.05,21.39 187.82,21.39 190.36,18.85 190.36,16.45 189.23,15.31 185.94,15.31 185.09,16.16 183.24,16.16 181.66,17.74 176.76,17.74 176.16,17.14 176.16,16.42 175.75,16.02 119.74,16.02 119.12,16.64 108.43,16.64 107.83,16.04 102.47,16.04 101.78,16.74 99.19,16.74 98.57,17.36 94.23,17.36 89.1,22.49 83.3,22.49 78.32,17.51 74.61,17.51 73.64,16.53 63.3,16.53 58.97,20.86 58.97,25.11 59.73,25.87 59.73,26.43 61.19,27.89 61.19,28.19 v2(61.71,28.71)
  BOTTOM w0.079: U1.BR36 75.17,46.51 74.91,46.51 74.73,46.6 74.27,46.6 73.62,45.95 73.62,45.88 71.23,43.5
  BOTTOM w0.102: 71.23,43.5 69.86,43.5 68.82,42.45 66.91,42.45 EC1.2 R45.1 64.26,42.73 63.08,42.73 v1(62.47,42.12)
RTC_RST#: length 48.6
  TOP w0.102: v2(51.09,25.67) 51.09,24.85 51.31,24.63 Q22.3 50.87,24.27 C1217.1 50.07,24.78 49.85,25.01 R979.2 49.18,24.88 49.64,24.42 v1(49.64,24.17) 49.96,23.85 J9007.1
  BOTTOM w0.079: 70.88,42.63 73.95,45.71 73.95,45.81 74.19,46.05 74.56,46.05 74.61,46 76.18,46 76.46,46.28 U1.BR34
  BOTTOM w0.102: v2(51.09,25.67) 51.09,25.41 51.85,24.65 54.11,24.65 54.94,25.49 58.05,25.49 59.57,27.01 60.08,27.01 60.52,27.45 61.72,27.45 62.91,28.64 62.91,40.58 63.18,40.85 68.48,40.85 70.26,42.63 70.88,42.63
RTC_X1: length 25.7
  IN1 w0.089: v2(78.76,47.5) 78.74,47.5 78.24,47.99 77.91,47.99 77.63,47.71 77.63,47.28 77.4,47.05 76.61,47.05 75.65,46.09 75.65,41.44 75.13,40.91 75.13,38.08 74.27,37.22 74.27,35.67 73.98,35.38 v2(73.98,33.97)
  BOTTOM w0.079: v2(78.76,47.5) 78.74,47.5 78.39,47.84 U1.BN31
  BOTTOM w0.102: Y1.1 76.9,29.83 v1(76.72,30.01) 76.52,30.2 C206.2 76.65,30.97 77.14,30.97 R169.1 77.35,31.53 76.66,31.53 76.29,31.9 75.85,31.9 74,33.75 74,33.95 v2(73.98,33.97)
RTC_X2: length 24.6
  IN1 w0.089: v2(78.21,47.44) 78.21,47.75 78.14,47.81 77.99,47.81 77.81,47.63 77.81,47.17 77.48,46.84 76.66,46.84 75.91,46.09 75.91,41.16 75.72,40.98 75.72,37.83 74.86,36.97 74.86,35.29 74.61,35.04 v2(74.61,34.38)
  BOTTOM w0.079: v2(78.21,47.44) 77.76,47.89 U1.BN32
  BOTTOM w0.102: v2(74.61,34.38) 74.61,34 76.1,32.51 76.55,32.51 76.89,32.17 77.61,32.17 78.3,31.47 R169.2 78.52,31.36 78.55,31.33 C209.2 79.28,31.01 80.23,30.05 Y1.2
S5_ON: length 217.7
  TOP w0.102: U37.100 196.05,30.72 195.87,30.9 R25309.1 195.87,32.78 195.29,33.36 v2(195.21,33.36) ; PR6027.1 28.33,26.63 28.71,27.02 v1(28.71,27.06) ; v2(148.4,18.78) 148.4,20.59 147.79,21.2 147.58,21.2 147.46,21.32 147.46,22.16 148.89,23.59 148.89,24.64 148.65,24.88 148.65,26.81 148.22,27.24 v2(148.22,29.07) 148.22,30.29 147.71,30.8 147.71,34.11 v2(147.66,34.16) ; PR566.2 37.81,27.36 37.84,27.33 37.84,27.28 38.18,26.94 v1(38.22,26.94)
  IN2 w0.089: v1(28.71,27.06) 28.71,27.93 29.03,28.24 34.85,28.24 36.18,26.91 37,26.91 37.37,26.54 37.72,26.54 37.75,26.56 37.84,26.56 v1(38.22,26.94) 38.29,26.94 40.66,24.56 40.66,24.03 41.8,22.88 45.85,22.88 46.54,22.19 46.54,21.92 46.82,21.65 46.82,19.95 47.13,19.64 49.03,19.64 49.58,19.09 51.02,19.09 51.83,18.28 61.42,18.28 63.33,16.37 71.5,16.37 72.41,17.28 79.12,17.28 83.97,22.12 88.89,22.12 93.91,17.11 97.67,17.11 97.95,16.83 101.22,16.83 102.37,15.68 107.32,15.68 108.57,16.93 112.82,16.93 114.17,18.29 118.55,18.29 118.86,18.59 119.51,18.59 120.41,19.49 123.99,19.49 124.43,19.05 128.06,19.05 128.31,19.3 129.6,19.3 130.57,18.32 132.29,18.32 133.15,19.18 144.35,19.18 144.49,19.04 148.14,19.04 v2(148.4,18.78)
  IN3 w0.089: v2(147.66,34.16) 148.66,35.16 149.23,35.16 149.33,35.25 152.93,35.25 153.31,34.88 155.96,34.88 156.28,35.2 162.18,35.2 164.63,32.75 168.27,32.75 168.28,32.76 174.41,32.76 174.94,32.23 180.62,32.23 181.77,33.38 185.02,33.38 185.34,33.7 186.16,33.7 186.25,33.8 187.8,33.8 188.19,34.19 189.31,34.19 189.5,34.38 193.39,34.38 194.5,33.27 195.12,33.27 v2(195.21,33.36)
  BOTTOM w0.102: v2(148.22,29.07) 148.22,28.99 148.8,28.41 153.43,28.41 154.11,29.09 PR6015.2
SATA_LED#: length 2.3
  TOP w0.102: TP2092.1 37.53,3.34 v1(37.6,3.26)
  BOTTOM w0.102: v1(37.6,3.26) CN16.10
SATA_RXN0_C: length 12
  TOP w0.102: C6592.2 210.81,11.81 v1(210.81,11.39) ; R25352.2 210.3,20.68 v1(210.3,21.09)
  IN1 w0.089: v1(210.81,11.39) 210.48,11.39 210.39,11.48 210.39,14.48 209.43,15.44 209.43,17.3 209.99,17.86 209.99,19.86 209.82,20.03 209.82,20.61 v1(210.3,21.09)
SATA_RXN0_CN: length 8.8
  TOP w0.102: v1(210.5,10.27) 210.35,10.42 210.35,12.02 210.23,12.14 210.23,12.26 210.31,12.33 C6596.1
  BOTTOM w0.102: HD1.8 213.57,12.82 213.33,13.05 213.22,13.05 212.89,12.72 212.57,12.72 212.06,12.22 210.67,12.22 210.34,11.89 210.34,10.95 210.21,10.82 210.21,10.54 210.48,10.27 v1(210.5,10.27)
SATA_RXN0_HDD: length 147.6
  TOP w0.102: C6588.2 210.15,20.15 209.85,20.45 209.85,21.89 210.31,22.35 v1(210.42,22.35)
  IN1 w0.089: v2(92.39,47.31) 92,46.92 91.41,46.92 91.1,46.6 91.1,45.46 90.21,44.58 90.21,43.39 90.58,43.02 91.18,43.02 91.37,43.22 92.48,43.22 92.91,42.79 92.91,42.71 93.45,42.18 95.24,42.18 95.64,41.77 100.09,41.77 103.69,38.16 104.35,38.16 104.73,37.78 105.85,37.78 108.2,35.43 110.68,35.43 111.53,34.58 116.62,34.58 117.19,35.15 117.19,35.45 117.86,36.12 120.51,36.12 121.16,36.78 124.78,36.78 125.96,37.96 135.45,37.96 136.32,38.83 139.13,38.83 139.71,39.41 141.38,39.41 144.07,36.72 144.07,36.61 144.51,36.17 144.51,35.54 145.06,34.99 145.74,34.99 146.61,34.11 146.89,34.11 147.76,33.25 156.55,33.25 156.86,33.56 158.75,33.56 159.21,33.11 160.07,33.11 160.59,32.59 160.59,32.21 160.93,31.87 162.95,31.87 163.56,31.26 164.35,31.26 164.55,31.06 169.35,31.06 169.44,30.97 172.01,30.97 172.21,31.16 175.68,31.16 175.99,31.48 183.99,31.48 184.16,31.65 186.82,31.65 188.22,33.06 191.02,33.06 191.63,33.67 194.03,33.67 195.8,31.9 195.8,30.98 196.03,30.75 196.03,29.36 196.63,28.76 196.63,28.31 197.14,27.81 197.14,27.44 197.42,27.16 197.8,27.16 198.08,26.88 200.58,26.88 200.79,26.67 200.86,26.67 200.89,26.66 204.24,26.66 204.72,26.18 204.72,25.77 206.04,24.45 206.43,24.45 206.66,24.23 207.29,24.23 209.51,22.01 209.84,22.01 210.19,22.35 v1(210.42,22.35)
  BOTTOM w0.079: U1.BN10 91.94,47.76 v2(92.39,47.31)
SATA_RXN0_IN: length 2
  TOP w0.102: C6588.1 210.02,19.7 209.92,19.6 209.92,19.44 210.1,19.26 210.1,19.04 210.38,18.76 U42.4
SATA_RXN1A_C: length 3.7
  BOTTOM w0.102: C782.1 134.23,20.43 134.23,19.67 134.71,19.19 134.71,18.26 134.85,18.12 CN15.5
SATA_RXN1A_ODD: length 121.9
  IN1 w0.089: v2(158.15,32.96) 157.95,32.75 157.95,32.54 157.7,32.29 156.47,32.29 156.31,32.45 147.42,32.45 146.73,33.14 145.95,33.14 145.79,33.29 145.14,33.29 144.54,33.89 144.54,34.33 143.7,35.17 143.7,35.62 142.68,36.64 142.68,36.97 141.72,37.93 136.79,37.93 136,37.15 127.12,37.15 125.86,35.89 124.79,35.89 124.7,35.98 121.49,35.98 120.84,35.32 118.88,35.32 117.33,33.77 111.21,33.77 110.42,34.56 107.68,34.56 105.6,36.64 104.47,36.64 104.02,37.1 103.41,37.1 101.03,39.48 99.52,39.48 98.5,40.5 95.74,40.5 95.03,41.21 93.68,41.21 92.74,42.15 90.68,42.15 90.01,42.82 89.75,42.82 89.24,43.34 89.24,44.62 89.37,44.76 89.37,46.05 89.6,46.27 89.78,46.27 90.22,46.71 90.22,47.85 90.55,48.18 91.06,48.18 91.34,47.9 94.43,47.9 94.52,47.99 94.52,48.13 v2(94.36,48.3)
  BOTTOM w0.079: U1.BL6 94.03,48.63 v2(94.36,48.3)
  BOTTOM w0.102: C782.2 134.38,21.81 134.38,22.19 134.61,22.41 136.1,22.41 136.97,23.28 144.41,23.28 144.71,22.97 153.3,22.97 154.24,23.91 154.24,24.9 154.82,25.49 156.5,25.49 157.48,26.47 157.48,28.12 157.41,28.18 157.41,31.74 157.99,32.31 157.99,32.79 v2(158.15,32.96)
SATA_RXN_OUT: length 2.2
  TOP w0.102: U42.12 210.38,13.84 210.32,13.78 210.32,12.9 210.44,12.78 C6596.2
SATA_RXP0_C: length 12.1
  TOP w0.102: R25353.2 209.17,20.66 v1(209.17,21.09) ; C6593.2 209.69,11.81 v1(209.69,11.39)
  IN1 w0.089: v1(209.17,21.09) 209.19,21.09 209.61,20.66 209.61,19.95 209.79,19.77 209.79,17.94 209.23,17.39 209.23,15.35 210.18,14.4 210.18,11.48 210.09,11.39 v1(209.69,11.39)
SATA_RXP0_CN: length 8.8
  TOP w0.102: v1(209.87,10.27) 210.14,10.55 210.14,11.93 210.02,12.05 210.02,12.25 209.94,12.33 C6597.1
  BOTTOM w0.102: HD1.7 213.52,13.32 213.47,13.27 213.13,13.27 212.8,12.94 212.48,12.94 211.97,12.43 210.58,12.43 210.12,11.98 210.12,11.04 209.99,10.91 209.99,10.4 v1(209.87,10.27)
SATA_RXP0_HDD: length 147.6
  TOP w0.102: v1(209.82,22.57) 209.94,22.44 209.94,22.29 209.63,21.98 209.63,20.25 209.53,20.15 C6589.2
  IN1 w0.089: v2(93.08,47.31) 92.85,47.31 92.76,47.21 92.76,47.03 92.67,46.94 92.27,46.94 92.07,46.74 91.49,46.74 91.3,46.55 91.3,45.38 90.42,44.49 90.42,43.47 90.67,43.22 91.09,43.22 91.29,43.42 92.57,43.42 93.11,42.87 93.11,42.8 93.53,42.38 95.32,42.38 95.73,41.97 100.17,41.97 103.78,38.37 104.43,38.37 104.81,37.98 105.94,37.98 108.29,35.63 110.76,35.63 111.62,34.78 116.54,34.78 116.98,35.23 116.98,35.54 117.78,36.33 120.42,36.33 121.08,36.98 124.69,36.98 125.87,38.16 135.37,38.16 136.24,39.03 139.05,39.03 139.63,39.61 141.47,39.61 144.27,36.8 144.27,36.7 144.71,36.25 144.71,35.62 145.15,35.19 145.82,35.19 146.7,34.31 146.98,34.31 147.84,33.45 156.46,33.45 156.78,33.77 158.84,33.77 159.29,33.31 160.16,33.31 160.79,32.68 160.79,32.29 161.01,32.08 163.03,32.08 163.65,31.46 164.43,31.46 164.64,31.26 169.44,31.26 169.53,31.17 171.93,31.17 172.13,31.37 175.59,31.37 175.9,31.68 183.9,31.68 184.08,31.86 186.73,31.86 188.13,33.26 190.94,33.26 191.55,33.87 194.12,33.87 196,31.98 196,31.06 196.23,30.83 196.23,29.44 196.84,28.84 196.84,28.4 197.34,27.89 197.34,27.53 197.51,27.36 197.88,27.36 198.16,27.08 200.67,27.08 200.87,26.87 200.9,26.87 200.93,26.86 204.33,26.86 204.93,26.26 204.93,25.85 206.12,24.66 206.52,24.66 206.74,24.43 207.37,24.43 209.59,22.21 209.76,22.21 209.87,22.32 209.87,22.52 v1(209.82,22.57)
  BOTTOM w0.079: v2(93.08,47.31) 92.87,47.31 92.73,47.45 U1.BN8
SATA_RXP0_IN: length 2
  TOP w0.102: C6589.1 209.58,19.7 209.71,19.57 209.71,19.35 209.88,19.17 U42.5
SATA_RXP1A_C: length 3.7
  BOTTOM w0.102: C781.1 134.02,20.43 134.02,19.58 134.49,19.1 134.49,18.26 134.35,18.12 CN15.6
SATA_RXP1A_ODD: length 121.9
  IN1 w0.089: v2(157.57,32.96) 157.75,32.78 157.75,32.63 157.61,32.49 156.56,32.49 156.4,32.65 147.51,32.65 146.82,33.34 146.03,33.34 145.88,33.49 145.22,33.49 144.74,33.97 144.74,34.41 143.9,35.25 143.9,35.71 142.89,36.72 142.89,37.05 141.8,38.14 136.71,38.14 135.92,37.35 127.04,37.35 125.78,36.09 124.87,36.09 124.78,36.18 121.41,36.18 120.76,35.53 118.8,35.53 117.25,33.97 111.29,33.97 110.51,34.76 107.77,34.76 105.68,36.84 104.56,36.84 104.1,37.3 103.49,37.3 101.11,39.68 99.61,39.68 98.58,40.7 95.83,40.7 95.12,41.41 93.76,41.41 92.82,42.35 90.77,42.35 90.09,43.03 89.84,43.03 89.44,43.42 89.44,44.54 89.58,44.67 89.58,45.96 89.69,46.07 89.87,46.07 90.42,46.62 90.42,47.77 90.63,47.98 90.98,47.98 91.26,47.69 94.52,47.69 94.73,47.9 94.73,48.19 94.8,48.27 v2(94.96,48.27)
  BOTTOM w0.079: U1.BL5 94.92,48.69 95.03,48.58 95.03,48.34 v2(94.96,48.27)
  BOTTOM w0.102: C781.2 134.06,21.58 134.16,21.69 134.16,22.28 134.52,22.63 136.01,22.63 136.88,23.49 144.5,23.49 144.8,23.19 153.21,23.19 154.02,24 154.02,24.99 154.73,25.7 156.41,25.7 157.26,26.56 157.26,28.03 157.2,28.09 157.2,31.83 157.77,32.4 157.77,32.75 v2(157.57,32.96)
SATA_RXP_OUT: length 2.2
  TOP w0.102: U42.11 209.88,13.81 210.11,13.59 210.11,12.91 209.98,12.78 C6597.2
SATA_TXN0_C: length 11.9
  TOP w0.102: v1(211.64,11.39) 211.64,11.42 211.77,11.54 C6591.2 ; R25351.2 211.14,21.02 v1(211.06,21.09)
  IN1 w0.089: v1(211.64,11.39) 212.08,11.39 212.16,11.48 212.16,13.44 211.9,13.7 211.9,15.1 212.13,15.33 212.13,18.17 211.52,18.78 211.52,20.64 v1(211.06,21.09)
SATA_TXN0_CN: length 6.3
  TOP w0.102: v1(211.9,10.2) 212.19,10.49 212.19,12.18 212.04,12.33 C6595.1
  BOTTOM w0.102: HD1.10 213.57,11.82 213.55,11.8 213.42,11.8 213.17,12.05 212.53,12.05 212.17,11.69 212.17,10.47 v1(211.9,10.2)
SATA_TXN0_HDD: length 163
  TOP w0.102: R25351.1 211.44,20.15 211.54,20.25 211.54,22.06 v1(211.26,22.34)
  IN3 w0.089: v1(211.26,22.34) 211.48,22.12 211.48,18.3 212.11,17.67 212.11,15.42 211.46,14.77 209.35,14.77 208.32,13.73 207.48,13.73 205.85,12.1 204.48,12.1 203.69,11.31 192.13,11.31 191.85,11.59 190.62,11.59 189.98,12.23 189.98,12.51 189.11,13.37 187.89,13.37 187.03,12.51 187.03,11.92 186.65,11.54 185.64,11.54 184.98,12.2 184.98,12.32 182.13,15.17 119.38,15.17 117.98,16.57 114.22,16.57 113.15,17.64 110.64,17.64 106.28,21.99 106.28,27.72 106.16,27.85 106.16,29.27 102.87,32.56 102.87,35.59 102.59,35.87 102.59,37.74 101.71,38.62 101.71,39.23 101.48,39.46 101.48,42.76 103.52,44.79 103.52,48.36 v2(103.68,48.53)
  BOTTOM w0.079: 101.28,48.42 101.26,48.42 101.23,48.44 100.23,48.44 99.07,47.28 97.95,47.28 97.77,47.46 97.27,47.46 97.18,47.5 96.92,47.5 96.89,47.48 96.67,47.44 96.54,47.48 96.46,47.52 95.79,47.64 U1.BN4
  BOTTOM w0.102: 101.28,48.42 102,48.42 102.58,47.84 103.24,47.84 103.53,48.13 103.53,48.37 v2(103.68,48.53)
SATA_TXN0_IN: length 2.1
  TOP w0.102: U42.2 211.38,18.77 211.52,18.92 211.52,19.19 211.72,19.38 211.72,19.59 211.62,19.7 C6587.1
SATA_TXN1A_C: length 4
  BOTTOM w0.102: C784.1 136.73,20.56 136.73,20.22 136.93,20.01 136.93,19.22 136.21,18.5 136.21,18.26 136.35,18.12 CN15.2
SATA_TXN1A_ODD: length 89.7
  IN3 w0.089: v2(140.68,16.82) 140.86,16.63 140.86,16.5 140.35,15.99 119.69,15.99 118.3,17.39 114.97,17.39 113.9,18.45 113.12,18.45 112.43,19.14 110.28,19.14 107.09,22.33 107.09,28.06 106.97,28.18 106.97,29.6 103.82,32.75 103.82,35.77 103.39,36.21 103.39,38.07 102.55,38.91 102.55,39.61 102.3,39.86 102.3,42.01 104.18,43.89 104.18,44.04 104.33,44.2 104.33,48.45 105.01,49.14 105.01,49.63 104.72,49.92 104.51,49.92 v2(104.25,50.18)
  BOTTOM w0.079: 100.73,49.55 100.71,49.55 100.68,49.52 100.62,49.52 98.86,47.77 98.18,47.77 97.78,48.17 96.86,48.17 96.72,48.03 U1.BN2
  BOTTOM w0.102: C784.2 136.73,21.71 136.64,21.8 136.64,21.96 137.3,22.62 140.88,22.62 142.58,20.91 142.58,19.24 140.83,17.49 140.83,16.97 v2(140.68,16.82) ; 100.73,49.55 101.66,49.55 102.05,49.95 104.02,49.95 v2(104.25,50.18)
SATA_TXN_OUT: length 2.6
  TOP w0.102: U42.14 211.38,13.96 211.55,13.8 211.55,13.59 211.77,13.36 212.06,13.36 212.28,13.14 212.28,12.94 212.12,12.78 C6595.2
SATA_TXP0_C: length 12
  TOP w0.102: R25350.2 212.51,20.71 212.2,21.02 v1(212.2,21.07) ; v1(212.89,11.39) 212.91,11.42 212.91,11.76 C6590.2
  IN1 w0.089: v1(212.89,11.39) 212.46,11.39 212.37,11.48 212.37,13.52 212.1,13.79 212.1,15.01 212.33,15.24 212.33,18.26 211.72,18.87 211.72,20.59 v1(212.2,21.07)
SATA_TXP0_CN: length 6.3
  TOP w0.102: v1(212.66,10.17) 212.41,10.43 212.41,12.18 212.56,12.33 C6594.1
  BOTTOM w0.102: HD1.11 213.64,11.32 213.42,11.54 213.37,11.54 213.08,11.84 212.62,11.84 212.39,11.6 212.39,10.45 v1(212.66,10.17)
SATA_TXP0_HDD: length 163
  TOP w0.102: v1(211.9,22.34) 211.76,22.2 211.76,20.31 211.92,20.15 C6586.2
  IN3 w0.089: v1(211.9,22.34) 211.85,22.34 211.68,22.17 211.68,18.39 212.31,17.76 212.31,15.34 211.54,14.57 209.44,14.57 208.4,13.53 207.56,13.53 205.93,11.9 204.57,11.9 203.78,11.11 192.04,11.11 191.76,11.39 190.53,11.39 189.77,12.15 189.77,12.42 189.03,13.17 187.97,13.17 187.23,12.43 187.23,11.83 186.73,11.34 185.56,11.34 184.78,12.12 184.78,12.23 182.04,14.97 119.3,14.97 117.89,16.37 114.14,16.37 113.07,17.44 110.55,17.44 106.08,21.91 106.08,27.64 105.95,27.77 105.95,29.19 102.67,32.48 102.67,35.51 102.39,35.79 102.39,37.66 101.51,38.53 101.51,39.14 101.28,39.37 101.28,42.84 103.31,44.87 103.31,48.31 v2(103.1,48.53)
  BOTTOM w0.079: 101.28,48.63 101.26,48.63 101.23,48.6 100.17,48.6 99,47.44 98.02,47.44 97.84,47.62 97.53,47.62 97.52,47.63 97.3,47.63 97.21,47.66 96.89,47.66 96.83,47.64 96.68,47.61 96.61,47.64 U1.BN3
  BOTTOM w0.102: v2(103.1,48.53) 103.13,48.53 103.31,48.35 103.31,48.22 103.15,48.06 102.67,48.06 102.09,48.63 101.28,48.63
SATA_TXP0_IN: length 2.1
  TOP w0.102: U42.1 211.88,18.8 211.74,18.94 211.74,19.1 211.94,19.29 211.94,19.57 212.06,19.7 C6586.1
SATA_TXP1A_C: length 4
  BOTTOM w0.102: CN15.3 135.85,18.12 135.99,18.26 135.99,18.58 136.71,19.31 136.71,19.93 136.51,20.13 136.51,20.55 C783.1
SATA_TXP1A_ODD: length 89.8
  IN3 w0.089: v2(141.29,16.82) 141.07,16.6 141.07,16.42 140.43,15.78 119.61,15.78 118.21,17.18 114.89,17.18 113.82,18.25 113.03,18.25 112.35,18.93 110.2,18.93 106.89,22.25 106.89,27.98 106.77,28.1 106.77,29.52 103.62,32.67 103.62,35.69 103.19,36.12 103.19,37.99 102.35,38.83 102.35,39.53 102.09,39.78 102.09,42.1 103.97,43.98 103.97,44.13 104.13,44.28 104.13,48.53 104.81,49.22 104.81,49.54 104.63,49.72 104.41,49.72 v2(104.26,49.57)
  BOTTOM w0.079: U1.BN1 97.49,48.01 97.71,48.01 98.11,47.61 98.93,47.61 100.68,49.37 100.69,49.37 100.71,49.34 100.73,49.34
  BOTTOM w0.102: v2(104.26,49.57) 104.1,49.73 102.14,49.73 101.75,49.34 100.73,49.34 ; v2(141.29,16.82) 141.04,17.06 141.04,17.4 142.8,19.15 142.8,21 140.97,22.83 137.21,22.83 136.42,22.05 136.42,21.87 136.27,21.71 C783.2
SATA_TXP_OUT: length 2.6
  TOP w0.102: U42.15 211.88,13.94 211.76,13.82 211.76,13.68 211.86,13.58 212.15,13.58 212.49,13.23 212.49,12.98 212.69,12.78 C6594.2
SATAGP0: length 3.6
  TOP w0.102: R25481.1 93.42,33.29 v2(93.58,33.13)
  BOTTOM w0.079: v2(93.58,33.13) 93.38,33.33 93.38,34.44 93.18,34.92 93.18,35.12 93.23,35.24 93.23,35.43 93.06,35.84 U1.CN8
SATAGP1: length 4.6
  TOP w0.102: R25433.1 92.03,33.67 v2(92.47,33.23)
  BOTTOM w0.079: v2(92.47,33.23) 92.47,33.34 92.04,33.78 92.04,34.14 92.18,34.28 92.18,34.87 92.1,35.03 92.1,35.6 91.95,35.75 91.95,36.25 91.67,36.52 U1.CM10
SD_1P8_RCOPM: length 9.1
  TOP w0.102: v2(72.2,34.02) 72.35,34.17 72.35,34.48 73.21,35.34 73.86,35.34 74.23,35.71 76.17,35.71 76.64,36.18 76.64,36.89 76.51,37.02 v2(76.51,37.19)
  BOTTOM w0.102: U1.CK33 76.81,37.5 v2(76.51,37.19) 76.51,36.79 U1.CM34 ; R209.1 71.61,33.34 71.61,33.62 72.02,34.02 v2(72.2,34.02)
SDVO_CLK: length 189.6
  TOP w0.102: R494.2 18.73,83.2 19.24,82.69 v1(19.37,82.69) 19.37,82.36 20.02,81.7 U23.7 ; v1(24.67,67.7) 24.67,67.68 24.68,67.68 24.68,67.57 24.8,67.45 26.01,67.45 27.19,66.27 27.19,64.51 26.73,64.05 26.73,63.99 25.97,63.23 R775.1
  IN1 w0.089: v1(24.67,67.7) 24.67,67.72 24.68,67.73 24.68,71.9 23.31,73.27 23.31,74.49 22.9,74.9 22.9,79.91 21.17,81.63 20.4,81.63 19.37,82.66 v1(19.37,82.69) 19.79,83.11 19.79,86.38 22.12,88.71 25.74,88.71 26.41,89.37 26.41,92.8 26.86,93.25 26.86,94.21 v1(27.73,95.08)
  IN3 w0.089: v2(92.47,40.88) 92.59,40.88 93.23,41.52 93.23,43.17 93.48,43.42 94.42,43.42 94.68,43.67 95.69,43.67 96.67,44.65 96.67,45.1 97.33,45.76 98.9,45.76 100.65,47.5 100.65,49.7 101.21,50.27 101.21,50.84 102.17,51.8 102.17,53.96 101.98,54.15 101.98,55.83 101.84,55.97 101.84,61.48 102.21,61.86 102.21,63.01 103.97,64.77 103.97,65.08 105.08,66.18 105.08,67.66 105.45,68.03 105.45,74.13 104.06,75.52 104.06,75.63 103.38,76.3 103.38,77.31 101.1,79.59 101.1,83.08 100.14,84.05 98.48,84.05 97.83,84.7 97.83,87.33 96.96,88.2 96.96,89.2 92.58,93.58 92.58,94.25 91.9,94.93 91.9,95.28 91.02,96.17 91.02,96.69 90.27,97.44 90.27,97.98 89.66,98.59 88.82,98.59 86.93,100.48 85.71,100.48 85.34,100.85 83.87,100.85 82.45,102.27 76.47,102.27 74.87,103.87 73.54,103.87 73.32,103.65 69.78,103.65 68.26,105.17 67.35,105.17 66.46,106.06 64.49,106.06 63.5,105.07 47.15,105.07 45.87,103.79 44.33,103.79 42.78,102.24 42.78,100.85 41.02,99.09 31.73,99.09 v1(27.73,95.08)
  BOTTOM w0.079: U1.CC8 92.73,41.14 v2(92.47,40.88)
SDVO_DATA: length 187
  TOP w0.102: U23.6 20.52,82.01 20,82.53 v1(20,82.66) 19.75,82.92 R502.2 ; v1(24.69,67.03) 24.7,67.04 25.84,67.04 26.78,66.1 26.78,64.68 26.22,64.11 R777.1
  IN1 w0.089: v1(27.73,94.45) 27.37,94.08 27.37,93.2 26.8,92.63 26.8,89.21 25.89,88.3 22.27,88.3 20.19,86.22 20.19,82.85 v1(20,82.66) 20,82.59 20.56,82.03 21.33,82.03 23.29,80.07 23.29,75.06 23.7,74.65 23.7,73.43 25.07,72.06 25.07,67.42 v1(24.69,67.03)
  IN3 w0.089: v1(27.73,94.45) 31.98,98.69 41.19,98.69 43.2,100.71 43.2,102.1 44.5,103.4 46.04,103.4 47.3,104.66 63.65,104.66 64.66,105.66 66.23,105.66 67.13,104.76 68.11,104.76 69.61,103.26 73.49,103.26 73.62,103.39 74.51,103.39 76.02,101.88 82.28,101.88 83.7,100.46 85.18,100.46 85.54,100.09 86.76,100.09 88.66,98.2 89.5,98.2 89.88,97.81 89.88,97.27 90.62,96.53 90.62,96 91.51,95.12 91.51,94.77 92.19,94.09 92.19,93.42 96.56,89.05 96.56,88.05 97.44,87.17 97.44,84.54 98.32,83.65 99.98,83.65 100.71,82.92 100.71,79.43 102.99,77.15 102.99,76.14 103.66,75.47 103.66,75.36 105.05,73.97 105.05,68.3 104.68,67.93 104.68,66.34 103.58,65.24 103.58,64.93 101.82,63.17 101.82,62.02 101.45,61.65 101.45,55.81 101.59,55.66 101.59,53.98 101.78,53.8 101.78,51.96 100.82,51 100.82,50.43 100.24,49.85 100.24,47.65 98.75,46.16 97.18,46.16 96.28,45.26 96.28,44.61 95.73,44.07 94.51,44.07 94.26,43.81 93.32,43.81 92.84,43.33 92.84,41.68 92.54,41.39 92.21,41.39 91.83,41 v2(91.83,40.87)
  BOTTOM w0.079: U1.CC9 92.08,41.15 92,41.07 92,40.95 91.92,40.87 v2(91.83,40.87)
SEL: length 4.3
  BOTTOM w0.102: R25277.2 R25276.1 19.32,19.24 19.36,19.28 R25280.2 19.36,20.12 19.47,20.23 v1(19.47,20.66) 18.81,20.66 18.7,20.77 U6502.6
SENSEA: length 4.8
  TOP w0.381: v1(200.21,30.03) 199.77,29.59 R733.1 199.02,29.4 v1(198.97,29.35)
  BOTTOM w0.203: v1(200.21,30.03) 200.6,30.43 U20.13
  BOTTOM w0.381: R452.1 200.59,29.65 v1(200.21,30.03) 200.01,30.24 200.01,30.53 R451.1
SERIRQ: length 139.8
  TOP w0.079: v2(80.02,43.7) 80.31,43.41 81.08,43.41 81.32,43.17 81.32,41.79 81.86,41.24 81.86,37.75 82.06,37.55 82.06,36.22 82.6,35.67
  TOP w0.102: 82.6,35.67 82.66,35.61 82.66,35.01 83.17,34.5 83.17,33.21 83.29,33.09 83.29,31.52 83.58,31.23 83.58,29.4 v1(83.5,29.32) 83.45,29.27 v2(82.69,29.27) 82.61,29.2 R94.1 R25520.1 ; v2(186.14,23) 185.99,23.15 185.99,25.89 186.47,26.38 186.47,26.96 186.24,27.19 185.46,27.19 184.85,26.58 U37.5
  IN2 w0.089: v2(186.14,23) 185.84,22.7 182.82,22.7 181.95,23.57 178.96,23.57 178.32,24.21 173.9,24.21 173.73,24.03 173.03,24.03 172.29,23.29 165.25,23.29 164.96,23 147.38,23 146.65,22.27 138.24,22.27 137.65,22.87 134.36,22.87 133.9,22.41 128.24,22.41 126.58,24.07 124.04,24.07 123.43,24.68 120.65,24.68 118.93,22.96 112.9,22.96 112.72,22.78 110.43,22.78 108.44,20.79 104.6,20.79 103.83,20.02 102.17,20.02 96.81,25.38 95.8,25.38 95.39,25.79 93.94,25.79 93.28,26.45 93.28,27.08 92.95,27.41 89.33,27.41 88.12,28.62 87.28,28.62 86.55,29.35 82.76,29.35 v2(82.69,29.27)
  BOTTOM w0.079: U1.BV28 80.32,44.24 80.01,43.93 80.01,43.71 v2(80.02,43.7)
SIO_EXT_SCI#: length 103.1
  TOP w0.102: v2(186.6,25.44) 186.61,25.42 186.61,23.34 187.31,22.64 187.31,21.89 185.07,19.65 184.87,19.65 184.6,19.38 U37.23
  IN2 w0.089: v2(186.6,25.44) 185.48,25.44 185.17,25.75 182.71,25.75 182.59,25.87 180.49,25.87 180.07,25.45 177.52,25.45 176.89,26.08 176.59,26.08 176.17,26.5 173.56,26.5 173.11,26.06 168.55,26.06 168.48,26.13 166.65,26.13 166.23,25.71 165.35,25.71 165.22,25.57 164.09,25.57 163.85,25.34 160.22,25.34 160.14,25.42 153.95,25.42 153.31,26.06 149.69,26.06 149.33,25.7 146.66,25.7 146.35,26.01 145.56,26.01 144.81,26.76 144.42,26.76 144.21,26.97 143.51,26.97 143.32,27.16 141.9,27.16 141.69,27.37 138.39,27.37 136.93,28.82 135.76,28.82 135.34,28.4 133.19,28.4 132.48,27.69 128.78,27.69 127.46,29.02 124.87,29.02 124.33,28.48 119.12,28.48 118.84,28.19 111.83,28.19 111.09,27.45 107.88,27.45 106.37,25.94 103.26,25.94 102.68,25.36 101.38,25.36 101.18,25.56 v2(100.54,25.56)
  BOTTOM w0.102: v2(100.54,25.56) 101.2,25.56 101.28,25.48 R25436.1 R25448.2
SIO_EXT_SMI#: length 13.4
  BOTTOM w0.079: 83.65,31.48 83.65,31.53 83.78,31.66 84.01,31.66 84.23,31.88 84.23,34.24 83.93,34.54 83.93,34.78 83.97,34.88 83.97,34.91 83.97,35.14 83.92,35.28 83.92,35.47 83.92,35.47 83.92,35.72 83.81,35.92 83.81,36.1 83.88,36.17 83.88,36.44 83.72,36.6 83.72,38.75 U1.CG22
  BOTTOM w0.102: v1(82.56,27.09) 82.96,27.49 R98.1 83.42,28.39 83.42,31.26 83.65,31.48
SIO_RCIN#: length 137.2
  TOP w0.079: 82.05,35.67 82.05,35.8 81.89,35.96 81.89,37.48 81.69,37.68 81.69,41.15 81.14,41.7 81.14,43.11 81.01,43.24 79.9,43.24 79.46,43.67 v2(79.46,43.78)
  TOP w0.102: v2(182.05,26.53) 182.05,26.61 182.43,26.98 U37.4 ; R100.1 81.09,27.78 82.08,28.77 v1(82.08,29.37) 81.95,29.5 81.95,31.12 81.55,31.53 81.55,32.97 82.05,33.48 82.05,35.67
  IN1 w0.089: v2(182.05,26.53) 182.05,26.5 181.7,26.15 181.28,26.15 181.2,26.24 180.26,26.24 180.18,26.16 177.41,26.16 177.26,26.31 170.84,26.31 170.51,26.64 168.29,26.64 167.37,27.56 161.39,27.56 161.06,27.89 160.09,27.89 158.02,29.96 155.51,29.96 155.35,30.12 146.46,30.12 145.77,30.82 144.98,30.82 144.83,30.97 142.97,30.97 140.54,33.4 136.66,33.4 136.34,33.72 133.88,33.72 133.29,33.14 132.77,33.14 132.43,33.48 127.9,33.48 127.32,32.9 125.22,32.9 123.15,30.84 118.68,30.84 118.12,30.28 110.71,30.28 110.03,30.96 108.13,30.96 107.62,31.47 105.77,31.47 105.24,32 104.32,32 103.47,32.85 100.85,32.85 98.74,34.95 97.27,34.95 95.89,36.33 95.26,36.33 95.06,36.54 92.75,36.54 92.12,35.91 88.41,35.91 87.98,36.34 87.41,36.34 86.42,37.33 85.53,37.33 85.28,37.58 85.28,37.81 84.79,38.3 84.42,38.3 84.09,38.62 84.09,39.92 81.91,42.1 81.91,43.97 81.52,44.36 79.92,44.36 79.46,43.9 v2(79.46,43.78)
  BOTTOM w0.079: U1.BV29 79.69,44.12 79.46,43.89 79.46,43.78 v2(79.46,43.78)
SLEEVE: length 22.5
  IN3 w1.016: 214.29,43.52 213.88,43.12 210.32,43.12 209.84,42.63 209.84,42.05 209.34,41.54 207.68,41.54 205.29,39.16 205.29,37.15 204.91,36.77 204.91,36.21 204.48,35.77 202.37,35.77 201.36,34.76 201.36,33.87 v1(200.14,32.65)
  BOTTOM w0.203: v1(200.14,32.65) 200.36,32.43 U20.18
  vias: v1(214.69,42.81) v1(215.1,43.32)
SLP_A#: length 10.9
  BOTTOM w0.079: 70.55,41.9 70.72,42.07 70.81,42.07 73.8,45.07 U1.BU37
  BOTTOM w0.102: TP7.1 66.91,39.36 67.88,39.36 68.64,40.12 68.77,40.12 70.55,41.9
SLP_LAN#: length 4.2
  TOP w0.102: TP4.1 75.88,47.61 77.07,46.42 78.57,46.42 v2(78.73,46.57)
  BOTTOM w0.079: U1.BT31 78.39,46.23 v2(78.73,46.57)
SLP_S5#: length 6.9
  TOP w0.079: v2(79.94,45.58) 79.5,46.02 78.43,46.02 78.29,46.16 76.95,46.16
  TOP w0.102: 76.95,46.16 76.13,46.98 75.12,46.98 TP3.1
  BOTTOM w0.089: U1.BT29 79.69,45.94 79.94,45.68 v2(79.94,45.58)
SLP_SUS#_EC: length 4.9
  TOP w0.079: TP9027.1 75.46,44.34 78.24,44.34 78.37,44.21 78.83,44.21 79.24,44.62 79.26,44.62 v2(79.28,44.64)
  BOTTOM w0.102: v2(79.28,44.64) 79.28,44.72 79.69,45.13 U1.BU29
SM_RCOMP_0: length 1.4
  TOP w0.381: v2(80.81,48.35) 81.21,48.35 R28.1
  BOTTOM w0.305: U1.BN28 80.34,48.01 80.68,48.35 v2(80.81,48.35)
SM_RCOMP_1: length 1.2
  TOP w0.381: v2(81.29,47.43) 81.74,47.43 R29.2
  BOTTOM w0.254: U1.BN27 80.99,47.73 v2(81.29,47.43)
SM_RCOMP_2: length 1.8
  TOP w0.381: v2(79.35,48.41) 79.32,48.41 79.3,48.44 79.25,48.44 79.06,48.63 R30.1
  BOTTOM w0.254: U1.BN29 79.67,47.89 79.35,48.2 v2(79.35,48.41)
SM_VREF: length 63
  TOP w0.508: R242.1 50.1,47.61 50.62,47.09 C266.1 v1(51.73,44.94) 53.4,44.94 54.8,46.34 54.8,47.1 55.94,48.25 57.11,48.25 57.72,48.86 57.72,51.17 60.02,53.47 v1(60.85,53.47)
  BOTTOM w0.203: U1.F36 75.17,76.46 74.85,76.78 74.52,76.78 73.44,77.85
  BOTTOM w0.508: v1(60.85,53.47) 62.04,54.66 62.04,55.1 64.2,57.26 64.2,58.91 65.85,60.57 65.85,62.98 65.09,63.74 65.09,67.42 66.13,68.46 66.13,79.77 69.15,82.79 71.61,82.79 72.63,81.77 72.63,80.23 73.14,79.73 73.14,78.16 73.44,77.85
SMB_ME0_CLK: length 15.1
  TOP w0.102: v2(88.87,38.96) 88.87,38.94 88.04,38.11 87.59,38.11 87.31,37.83 87.31,36.66 88.12,35.85 88.85,35.85 90.38,34.32 90.38,33.31 92.19,31.51 92.19,29.35 v1(92.56,28.98) 93.03,28.51 R99.1
  BOTTOM w0.079: v2(88.87,38.96) 88.92,38.96 89.3,38.59 U1.CH14
SMB_ME0_DAT: length 15.6
  TOP w0.102: R101.1 92.06,28.79 91.83,29.02 91.83,31.23 v1(91.54,31.52) 90.99,32.07 90.99,32.42 90.18,33.23 90.18,34.25 89.06,35.37 88.3,35.37 87.08,36.58 87.08,37.91 87.49,38.31 87.97,38.31 88.23,38.58 88.23,39.09 v2(88.86,39.71)
  BOTTOM w0.079: U1.CF15 88.35,39.84 88.45,39.74 88.8,39.74 88.82,39.71 v2(88.86,39.71)
SMB_ME1_CLK: length 6.2
  BOTTOM w0.079: U1.CN15 88.58,35.48 88.4,35.3 88.31,35.1 88.31,34.91 88.36,34.82 88.36,34.46 88.02,34.12 88.02,33.25 89.27,32 89.3,32
  BOTTOM w0.102: R25449.2 89.32,30.59 89.32,31.26 89.5,31.44 R103.2 89.5,31.81 89.3,32
SMB_ME1_DAT: length 6.9
  BOTTOM w0.079: U1.CM15 88.29,36.02 88.29,35.47 88.15,35.14 88.15,34.88 88.19,34.78 88.19,34.53 87.84,34.18 87.84,33.2 88.71,32.33 88.71,32.22
  BOTTOM w0.102: 88.71,32.22 88.71,32.12 88.93,31.89 R104.2 88.93,31.38 89.11,31.2 89.11,30.84 R25450.2
SMB_PCH_CLK: length 53.7
  TOP w0.102: Q3.6 68.78,18.16 69.81,19.19 69.81,19.81 v2(70.1,20.1) ; v2(95.34,22.95) 95.64,23.25 96.66,23.25 97.27,23.86 97.27,24.9 97.19,24.97 97.19,26.63 96.84,26.99 96.84,28.57 R95.1 95.67,30.23 95.67,31.29 94.91,32.05 94.91,32.26 94.37,32.8 94.37,33.52 92.93,34.97 90.27,34.97 88.96,36.28 88.96,36.89 v2(88.81,37.04)
  IN1 w0.089: v2(95.34,22.95) 94.99,22.95 93.91,24.03 92.42,24.03 90.63,25.82 88.96,25.82 88.81,25.96 84.49,25.96 83.9,25.37 82.11,25.37 81.15,24.42 79.72,24.42 77.95,22.66 75.67,22.66 75.46,22.45 75.46,21.81 75.13,21.49 71.2,21.49 70.1,20.39 v2(70.1,20.1)
  BOTTOM w0.079: U1.CK14 89.1,37.29 88.86,37.04 v2(88.81,37.04)
SMB_PCH_DAT: length 61.1
  TOP w0.102: v2(88.81,38.21) 88.81,38.19 88.43,37.81 88.43,36.84 88.71,36.56 88.71,36.26 90.26,34.71 92.69,34.71 94.02,33.38 94.02,32.65 94.55,32.12 94.55,31.91 95.31,31.14 95.31,30.08 96.05,29.34 R97.1 96.08,28.82 96.23,28.82 96.45,28.59 96.45,26.86 96.84,26.48 96.84,24.83 96.91,24.75 96.91,24.14 96.48,23.71 v1(96.43,23.71) 95.4,23.71 95.17,23.48 v2(95.07,23.48) ; v2(66.1,20.36) 66.1,19.32 65.54,18.76 65.54,17.44 66.12,16.86 Q3.3
  IN1 w0.089: v2(66.1,20.36) 66.1,20.13 66.79,19.44 69.45,19.44 69.71,19.7 69.71,20.48 71.05,21.83 74.99,21.83 75.12,21.96 75.12,22.59 75.53,23 77.81,23 79.58,24.76 81.01,24.76 81.96,25.72 83.76,25.72 84.35,26.31 88.95,26.31 89.1,26.16 90.77,26.16 92.56,24.37 94.05,24.37 94.94,23.48 v2(95.07,23.48)
  BOTTOM w0.079: v2(88.81,38.21) 88.44,38.59 U1.CH15
SMB_RUN_CLK: length 54.7
  TOP w0.102: v2(67.88,20.08) 67.88,19.8 67.47,19.39 R115.2 67.47,19.17 67.63,19 67.63,18.41 67.39,18.16 Q3.1 ; R591.1 60.87,17.16 v2(60.95,17.08) ; v2(76.54,18.27) 76.3,18.03 R557.2
  IN2 w0.089: v2(67.88,20.08) 67.74,19.94 65.91,19.94 65.28,20.57 60.62,20.57 56.52,24.67 52.98,24.67 52.58,25.07 52.58,26.49 51.38,27.69 v2(51.38,27.86)
  BOTTOM w0.102: v2(76.54,18.27) 72.58,18.27 71.56,17.26 69.51,17.26 68.26,18.51 68.26,19.7 v2(67.88,20.08) 67.75,20.08 67.12,19.44 66.05,19.44 65.92,19.32 61.3,19.32 60.95,18.96 v2(60.95,17.08) ; v2(51.38,27.86) 51.62,28.1 51.62,28.41 51.78,28.56 51.78,29.86 52,30.09 52.53,30.09 52.92,30.48 52.92,31 53.12,31.2 JDIM1.253
SMB_RUN_DAT: length 42.3
  TOP w0.102: R561.2 70.67,18.06 70.67,17.84 v2(70.65,17.82) 70.65,17.81 70.65,17.79 70.29,17.44 70.29,16.75 70.03,16.49 R114.2 69.36,16.22 v1(68.87,16.22) 68.21,16.22 67.91,16.52 67.91,16.7 68.07,16.86 Q3.4 ; R590.1 63.53,19.49 63.63,19.39 64.19,19.39 v2(64.58,19.77)
  IN2 w0.089: v2(50.76,27.88) 50.76,27.82 52.23,26.35 52.23,24.93 52.84,24.33 56.38,24.33 60.48,20.22 65.14,20.22 65.77,19.59 68.01,19.59 v2(68.51,20.1)
  BOTTOM w0.102: v2(50.76,27.88) 50.94,28.05 50.94,28.33 51.42,28.82 51.42,30.42 51.3,30.53 51.3,30.79 51.14,30.95 JDIM1.254 ; v2(64.58,19.77) 64.6,19.8 66.97,19.8 67.31,20.14 67.31,20.24 67.63,20.56 68.06,20.56 v2(68.51,20.1) 68.62,20 68.62,18.66 69.66,17.61 70.45,17.61 v2(70.65,17.82)
SMDDR_VREF_DQ1_M3: length 48
  TOP w0.508: C299.1 52.89,99.17 52.61,98.89 R262.1 51.97,99.21 52.69,99.94 v1(52.77,99.94)
  BOTTOM w0.254: 73.95,78.19 74.29,77.85 74.29,77.47 74.67,77.1 75.04,77.1 U1.E36
  BOTTOM w0.508: 73.95,78.19 73.75,78.4 73.75,79.97 73.26,80.45 73.26,82.79 72.12,83.93 68.68,83.93 v1(65.87,81.12) 63.83,81.12 62.29,82.66 62.29,91.48 61.78,91.99 61.78,97.64 61.02,98.4 56.77,98.4 55.48,99.68 53.63,99.68 53.38,99.94 v1(52.77,99.94)
SML0ALERT#: length 14.1
  BOTTOM w0.079: 88.23,32.04 88.23,32.57 87.64,33.16 87.64,35.32 87.51,35.44 87.22,35.44 86.93,35.73 86.93,37.98 87.21,38.26 88.02,38.26 U1.CJ15
  BOTTOM w0.102: 88.23,32.04 88.05,31.86 88.05,30.59 88.25,30.39 88.25,29.81 88.1,29.65 88.1,29.22 88.45,28.87 R121.1 88.61,28.56 89.04,28.13 R119.1 88.18,27.87 v1(88.17,27.88)
SML1ALERT#: length 13.9
  TOP w0.102: v2(87.83,38.71) 87.53,38.71 86.85,38.04 86.85,36.49 88.68,34.66 R125.2 88.89,34.78 89.27,34.78 89.79,34.26 v1(89.79,33.92) 89.98,33.73 89.98,33.16 90.74,32.4 90.74,31.58 90.82,31.51 90.82,28.37 R123.1
  BOTTOM w0.079: v2(87.83,38.71) U1.CG15
SP_PLLVDD: length 23.3
  TOP w0.254: C459.2 C460.2 99.71,102.35 99.25,102.35 99.19,102.41 R329.2 98.01,102.41 v2(97.95,102.47) 97.69,102.73 97.04,102.73 94.93,104.84 93.92,104.84 91.71,107.05 89.72,107.05 89.46,107.31 C461.1 88.72,107.56 L8.2 88.46,107.55 88.2,107.81 87.26,107.81 87.05,107.6 87.05,105.74 v1(88.05,104.74) 88.05,102.7 87.56,102.22 C462.1
  BOTTOM w0.254: U8.M6 98.33,102.09 v2(97.95,102.47)
SPI1_CLK: length 4.4
  TOP w0.102: v2(85.74,39.56) 85.66,39.64 85.66,40.45 85.25,40.85 85.25,42.68 TP9.1
  BOTTOM w0.079: v2(85.74,39.56) 85.41,39.89 U1.CF20
SPI1_CS#: length 1.3
  TOP w0.102: TP12.1 84.66,40.03 v2(84.66,39.41)
  BOTTOM w0.079: v2(84.66,39.41) 84.83,39.24 U1.CG20
SPI1_IO2: length 1.2
  TOP w0.102: v2(82.66,39.23) 82.66,39.33 TP10.1
  BOTTOM w0.079: U1.CG23 82.66,39.24 v2(82.66,39.23)
SPI1_IO3: length 3.3
  TOP w0.102: TP11.1 82.31,36.84 82.31,37.63 82.18,37.76 82.18,38.24 82.59,38.65 82.64,38.65 v2(82.66,38.66)
  BOTTOM w0.079: U1.CH23 83.14,38.61 82.71,38.61 v2(82.66,38.66)
SPI_TPM_CS#: length 96.3
  TOP w0.102: v2(121.04,21.05) 120.92,21.17 120.92,21.83 121.02,21.94 R586.1 121.02,22.41 120.97,22.46 R599.1
  IN1 w0.089: v2(121.04,21.05) 121.04,21.01 120.16,20.13 120,20.13 119.52,19.65 119.52,19.42 119.15,19.05 116.01,19.05 115.92,19.14 115.92,19.51 115.83,19.59 115.65,19.59 115.56,19.51 115.56,19.14 115.47,19.05 114.5,19.05 113.93,19.62 110.6,19.62 110.32,19.9 103.32,19.9 103.04,19.62 99.72,19.62 99.57,19.77 96.21,19.77 95.28,20.71 94.29,20.71 92.77,22.23 92.77,23.01 91.36,24.42 90.79,24.42 90.22,24.99 90.22,25.26 90.13,25.35 89.96,25.35 89.87,25.26 89.87,24.99 89.78,24.9 89.6,24.9 89.51,24.99 89.51,25.26 89.42,25.35 89.24,25.35 89.16,25.26 89.16,24.99 89.07,24.9 88.33,24.9 88.25,24.98 88.25,25.39 88.14,25.49 87.93,25.49 87.84,25.41 87.84,25.2 87.75,25.11 87.57,25.11 87.48,25.2 87.48,25.41 87.39,25.49 84.68,25.49 84.09,24.9 82.3,24.9 81.35,23.95 79.91,23.95 77.77,21.8 76.12,21.8 75.33,21.02 74.23,21.02 72.48,19.27 70.03,19.27 69.74,18.97 66.52,18.97 65.47,20.03 65.47,23.43 65.89,23.85 65.89,24.71 64.3,26.3 64.3,27.72 64.72,28.14 64.72,28.72 65.06,29.07 68.78,29.07 69.98,30.27 69.98,31.76 71.69,33.48 71.69,34.1 72.45,34.86 72.45,36.89 73.52,37.96 73.57,37.96 v2(73.67,38.06)
  BOTTOM w0.079: v2(73.67,38.06) 73.88,38.27 74.33,38.27 74.51,38.45 76.19,38.45 76.47,38.73 U1.CH34
SRTC_RST#: length 42.1
  TOP w0.102: v2(51.67,25.64) 51.67,26.02 51.31,26.38 Q6520.3 50.94,26.48 50.79,26.63 C1211.1 49.82,26.63 49.41,27.04 R971.2
  BOTTOM w0.079: 71,43.01 73.78,45.79 73.78,45.88 74.19,46.28 U1.BR37
  BOTTOM w0.102: v2(51.67,25.64) 51.78,25.53 54.4,25.53 54.76,25.89 55.74,25.89 56.38,26.53 57.36,26.53 58.25,27.41 59.9,27.41 60.56,28.07 61.75,28.07 62.29,28.61 v1(62.29,28.94) 62.5,29.15 62.5,40.75 63.01,41.26 68.31,41.26 70.06,43.01 71,43.01
STRAP0: length 6.8
  BOTTOM w0.102: R344.1 88.59,96.32 89.24,95.67 90.42,95.67 R353.2 91.41,96.13 91.93,95.6 93.89,95.6 94.06,95.43 U8.D1
STRAP1: length 7.3
  BOTTOM w0.102: R345.1 88.94,95.62 89.11,95.44 89.42,95.44 89.88,94.98 R354.2 90.59,95.48 91.73,95.48 91.83,95.38 93.72,95.38 94.04,95.06 94.5,95.06 94.87,95.43 U8.D2
STRAP2: length 10.3
  BOTTOM w0.102: U8.E4 96.27,95.82 95.77,95.82 95.54,95.59 95.54,95.31 95.29,95.06 95.01,95.06 94.73,94.78 94.73,94.4 94.55,94.22 94.19,94.22 94.09,94.32 92.97,94.32 91.6,92.95 R355.2 90.37,93.46 89.88,93.46 89.75,93.59 R346.1
STRAP3: length 8.8
  BOTTOM w0.102: U8.E3 95.72,96.28 95.29,95.85 92.57,95.85 91.27,97.14 R356.2 90.37,96.63 89.6,96.63 89.47,96.76 89.22,96.76 88.59,97.39 R347.1
STRAP4: length 9.9
  BOTTOM w0.102: R348.1 88.96,92.57 89.01,92.52 90.29,92.52 R357.2 91.5,92.56 93.8,92.56 94.19,92.95 94.19,93.08 94.34,93.23 94.58,93.23 94.8,93.46 95.31,93.46 95.54,93.69 95.54,94.83 95.93,95.22 U8.D3
STRAP5: length 6.3
  BOTTOM w0.102: U8.C1 94.25,94.55 92.52,94.55 91.93,93.97 R358.2 90.29,94.55 89.01,94.55 88.96,94.6 R349.1
SUS_STAT#: length 19.5
  IN1 w0.089: v2(72.35,33.31) 72.38,33.31 72.53,33.16 72.53,33.03 72.76,32.8 74.28,32.8 75.39,33.91 75.39,34.11 75.74,34.47 75.74,34.78 76.97,36.02 76.97,37.91 77.81,38.75 80.17,38.75 v2(80.66,39.23)
  BOTTOM w0.079: U1.CA27 81.44,41.97 81.44,39.66 81.01,39.23 v2(80.66,39.23)
  BOTTOM w0.102: v2(72.35,33.31) 72.35,32.55 71.92,32.12 C6626.1 71.66,31.73 71.26,31.33 v1(70.93,31.33)
