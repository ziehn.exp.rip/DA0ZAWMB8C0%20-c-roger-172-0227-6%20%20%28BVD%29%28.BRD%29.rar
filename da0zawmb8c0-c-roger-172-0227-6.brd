# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Nets (continued)
GND: C1.1 C2.1 C3.1 C5.2 C6.2 C7.2 C8.2 C9.1 C11.1 C12.1 C13.2 C14.1 C15.2 C16.1 C17.1 C18.1 C19.2 C20.1 C21.2 C22.1 C23.1 C24.1 C25.1 C26.2 C27.2 C28.2 C29.2 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.2 C45.1 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.1 C57.1 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.1 C67.1 C68.2 C69.1 C70.1 C71.1 C72.1 C73.2 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C88.1 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C116.1 C117.1 C118.2 C119.2 C122.1 C123.1 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.1 C131.1 C132.1 C133.1 C134.2 C135.1 C136.1 C137.1 C138.1 C139.1 C140.1 C141.1 C142.1 C143.1 C144.1 C145.2 C146.2 C147.2 C148.2 C149.2 C150.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.2 C162.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.2 C170.2 C171.2 C172.1 C173.1 C174.1 C175.1 C176.2 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 C188.1 C189.1 C190.2 C191.2 C204.1 C205.1 C206.1 C208.1 C209.1 C212.2 C213.1 C214.1 C215.1 C216.1 C217.1 C218.1 C219.1 C220.1 C221.1 C222.1 C223.1 C224.1 C225.1 C226.1 C227.1 C228.1 C229.1 C230.1 C231.1 C232.1 C233.1 C234.1 C235.1 C236.1 C237.1 C238.1 C239.1 C240.1 C241.1 C242.1 C243.1 C244.2 C245.1 C246.1 C247.1 C248.1 C249.1 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C277.2 C278.2 C279.2 C280.2 C281.1 C282.1 C283.1 C284.1 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C311.2 C312.2 C313.2 C314.2 C315.2 C316.2 C317.1 C318.2 C319.2 C320.1 C321.2 C322.1 C323.1 C324.1 C325.1 C326.1 C327.1 C328.1 C329.2 C330.2 C331.2 C332.2 C333.2 C334.2 C335.2 C336.1 C337.1 C338.1 C339.1 C340.1 C341.2 C342.1 C343.1 C344.2 C345.2 C346.1 C347.1 C348.1 C349.1 C350.1 C351.1 C352.1 C353.1 C354.2 C355.1 C356.1 C357.1 C359.1 C360.1 C362.2 C363.1 C364.2 C365.1 C366.2 C367.1 C368.1 C369.1 C371.2 C372.1 C373.1 C374.1 C375.1 C376.2 C377.1 C378.2 C379.1 C380.1 C381.1 C383.1 C385.2 C386.1 C387.1 C388.1 C389.1 C391.1 C392.2 C393.1 C394.2 C395.2 C396.1 C397.1 C398.2 C399.2 C400.1 C401.2 C402.2 C403.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.2 C414.2 C415.1 C416.2 C417.2 C418.1 C419.2 C420.2 C421.1 C422.1 C423.1 C424.1 C425.1 C426.1 C427.1 C428.1 C429.1 C430.1 C431.1 C432.1 C433.1 C438.1 C439.1 C440.1 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.2 C457.1 C458.1 C459.1 C460.1 C461.2 C462.2 C463.2 C464.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.1 C478.1 C479.1 C480.1 C481.1 C482.1 C483.1 C484.2 C485.2 C486.2 C487.2 C488.2 C489.2 C490.2 C491.1 C492.1 C493.1 C494.1 C495.1 C496.1 C497.1 C498.1 C499.1 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C508.2 C509.1 C510.1 C511.1 C512.2 C513.1 C514.1 C515.1 C516.1 C517.1 C518.1 C521.2 C522.2 C523.1 C524.2 C525.1 C526.1 C527.1 C528.1 C529.1 C532.2 C533.2 C536.2 C537.2 C542.2 C543.1 C544.1 C545.2 C546.1 C547.2 C548.2 C550.2 C558.2 C559.1 C560.2 C561.2 C562.2 C565.2 C567.2 C574.2 C575.2 C576.2 C577.2 C578.2 C580.2 C581.2 C583.1 C584.2 C585.2 C586.2 C587.1 C588.2 C595.2 C596.2 C597.1 C601.2 C602.2 C603.2 C604.2 C613.2 C614.2 C616.2 C618.1 C619.2 C628.1 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C638.1 C639.2 C641.2 C642.2 C643.2 C644.2 C645.2 C646.1 C664.1 C665.2 C675.1 C676.1 C691.1 C692.1 C695.2 C696.2 C697.2 C698.2 C699.2 C706.2 C707.2 C708.2 C709.2 C711.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.1 C735.1 C736.1 C737.1 C740.2 C741.2 C742.2 C743.1 C744.2 C745.1 C749.1 C750.1 C752.1 C753.1 C770.2 C771.2 C772.2 C773.1 C774.1 C775.1 C776.1 C777.2 C778.2 C779.2 C780.2 C785.1 C786.1 C800.2 C801.2 C802.2 C804.2 C805.1 C841.2 C842.2 C844.1 C1044.2 C1189.2 C1190.2 C1208.1 C1210.2 C1211.2 C1214.2 C1217.2 C1687.2 C1688.2 C1689.2 C1690.2 C1691.2 C1692.2 C1693.2 C2374.2 C2607.2 C2609.2 C2610.2 C2611.2 C2612.2 C2616.1 C6502.2 C6503.2 C6504.2 C6505.1 C6544.2 C6545.2 C6546.2 C6547.2 C6548.2 C6549.2 C6560.2 C6562.1 C6563.2 C6565.2 C6568.1 C6569.2 C6570.2 C6571.2 C6572.2 C6573.2 C6574.2 C6575.2 C6577.2 C6578.2 C6580.1 C6581.2 C6582.1 C6583.1 C6584.1 C6598.2 C6599.2 C6600.2 C6601.2 C6602.2 C6603.2 C6604.2 C6605.2 C6606.1 C6607.2 C6608.2 C6609.2 C6610.1 C6612.1 C6613.1 C6614.1 C6615.1 C6616.1 C6617.1 C6618.1 C6619.2 C6620.2 C6622.2 C6623.2 C6624.1 C6625.1 C6626.2 C20000.2 C20001.1 C20002.1 CN1.2 CN2.4 CN2.7 CN2.10 CN2.11 CN2.12 CN2.13 CN3.4 CN3.7 CN3.10 CN3.11 CN3.12 CN3.13 CN8.9 CN8.10 CN8.11 CN8.12(GND#4) CN10.1 CN10.2 CN10.3 CN10.4 CN10.5 CN10.6 CN10.7 CN10.8 CN10.9 CN10.10 CN10.A1 CN10.A12 CN10.B1 CN10.B12 CN13.1 CN13.5 CN13.6 CN14.5 CN14.9 CN14.10 CN15.1 CN15.4 CN15.7 CN15.17 CN15.18 CN15.19 CN15.20 CN16.1 CN16.3 CN16.9 CN16.15 CN16.21 CN16.27 CN16.33 CN16.39 CN16.45 CN16.51 CN16.57 CN16.71 CN16.73 CN16.75 CN16.76 CN16.77 CN17.1 CN17.7 CN17.13 CN17.18 CN17.19 CN17.33 CN17.39 CN17.45 CN17.51 CN17.57 CN17.63 CN17.69 CN17.75 CN17.76 CN17.77 CN18.2 CN18.29 CN18.30 CN19.2 CN19.29 CN19.30 CN24.1 CN24.5 CN24.6 CN29.3 CN29.6 CN29.9 CN29.12 CN29.15 CN29.18 CN29.21 CN29.41 CN29.42 CN33.4 CN33.9 CN33.10 CN35.14 CN35.17 CN35.20 CN35.27 CN35.41 CN35.42 CN36.5 CN36.6 CN37.2 CN37.5 CN37.8 CN37.11 CN37.17 CN37.20 CN37.21 CN37.22 CN37.23 CN38.1 CN38.5 CN38.6 D16.1 D17.1 D18.1 D19.1 D22.1 D33.2 D34.1 D50.1 D65.2 D6541.2 D6542.2 D13081.1 D13082.1 D13083.1 D13084.1 D13085.1 D13086.1 D13087.1 D13088.1 D13089.1 D13090.1 D13091.1 D13092.1 EC1.1 EC2.1 EC3.1 EC5.1 EC6.1 EC7.1 EC8.2 EC9.1 EC10.2 EC11.2 EC12.2 EC13.2 EC6500.2 FAN3.4 FAN3.5 FAN3.6 HD1.6 HD1.9 HD1.12 HD1.13 HD1.14 HE1.3 HOLE2.1 HOLE3.1 HOLE4.1 HOLE5.1 HOLE6.1 HOLE7.1 HOLE7.2 HOLE7.3 HOLE7.4 HOLE7.5 HOLE7.6 HOLE7.7 HOLE7.8 HOLE7.9 HOLE8.1 HOLE8.2 HOLE8.3 HOLE8.4 HOLE8.5 HOLE8.6 HOLE8.7 HOLE8.8 HOLE8.9 HOLE9.1 HOLE9.2 HOLE9.3 HOLE9.4 HOLE9.5 HOLE9.6 HOLE9.7 HOLE9.8 HOLE9.9 HOLE10.1 HOLE11.1 HOLE11.2 HOLE11.3 HOLE11.4 HOLE11.5 HOLE11.6 HOLE11.7 HOLE11.8 HOLE11.9 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 HOLE18.1 HOLE19.1 HOLE19.2 HOLE19.3 HOLE19.4 HOLE19.5 HOLE19.6 HOLE19.7 HOLE19.8 HOLE19.9 HOLE20.1 HOLE20.2 HOLE20.3 HOLE20.4 HOLE20.5 HOLE20.6 HOLE20.7 HOLE20.8 HOLE20.9 HOLE22.1 J9007.2 JDIM1.1 JDIM1.2 JDIM1.5 JDIM1.6 JDIM1.9 JDIM1.10 JDIM1.14 JDIM1.15 JDIM1.18 JDIM1.19 JDIM1.22 JDIM1.23 JDIM1.26 JDIM1.27 JDIM1.30 JDIM1.31 JDIM1.35 JDIM1.36 JDIM1.39 JDIM1.40 JDIM1.43 JDIM1.44 JDIM1.47 JDIM1.48 JDIM1.51 JDIM1.52 JDIM1.56 JDIM1.57 JDIM1.60 JDIM1.61 JDIM1.64 JDIM1.65 JDIM1.68 JDIM1.69 JDIM1.72 JDIM1.73 JDIM1.77 JDIM1.78 JDIM1.81 JDIM1.82 JDIM1.85 JDIM1.86 JDIM1.89 JDIM1.90 JDIM1.93 JDIM1.94 JDIM1.98 JDIM1.99 JDIM1.102 JDIM1.103 JDIM1.106 JDIM1.107 JDIM1.167 JDIM1.168 JDIM1.171 JDIM1.172 JDIM1.175 JDIM1.176 JDIM1.180 JDIM1.181 JDIM1.184 JDIM1.185 JDIM1.188 JDIM1.189 JDIM1.192 JDIM1.193 JDIM1.196 JDIM1.197 JDIM1.201 JDIM1.202 JDIM1.205 JDIM1.206 JDIM1.209 JDIM1.210 JDIM1.213 JDIM1.214 JDIM1.217 JDIM1.218 JDIM1.222 JDIM1.223 JDIM1.226 JDIM1.227 JDIM1.230 JDIM1.231 JDIM1.234 JDIM1.235 JDIM1.238 JDIM1.239 JDIM1.243 JDIM1.244 JDIM1.247 JDIM1.248 JDIM1.251 JDIM1.252 JDIM1.261 JDIM1.262 L11.2 PC4.1 PC5.2 PC6.1 PC7.2 PC8.1 PC9.2 PC10.2 PC11.2 PC12.2 PC13.2 PC14.2 PC16.2 PC18.1 PC19.2 PC20.1 PC35.2 PC36.1 PC37.1 PC51.2 PC81.2 PC82.2 PC83.1 PC152.2 PC162.2 PC164.2 PC165.2 PC166.2 PC167.1 PC168.2 PC170.2 PC172.2 PC185.2 PC188.2 PC217.2 PC218.2 PC219.2 PC220.2 PC221.2 PC222.2 PC224.2 PC227.2 PC229.2 PC230.2 PC231.2 PC233.2 PC234.2 PC236.1 PC242.2 PC268.1 PC276.2 PC280.2 PC283.2 PC285.1 PC288.2 PC289.2 PC290.1 PC292.1 PC293.2 PC294.2 PC295.2 PC296.2 PC297.2 PC298.2 PC299.2 PC300.1 PC302.2 PC304.2 PC305.2 PC306.2 PC423.2 PC551.1 PC561.2 PC562.2 PC563.2 PC571.2 PC572.2 PC581.2 PC756.2 PC6000.2 PC6002.1 PC6003.1 PC6004.2 PC6005.2 PC6006.2 PC6007.1 PC6008.2 PC6009.2 PC6010.2 PC6011.2 PC6012.2 PC6013.2 PC6014.2 PC6015.2 PC6016.2 PC6017.1 PC6018.2 PC6019.2 PC6020.2 PC6021.2 PC6022.2 PC6023.2 PC6025.2 PC6026.2 PC6027.2 PC6028.2 PC6029.2 PC6030.2 PC6031.1 PC6032.2 PC6033.2 PC6034.1 PC6036.2 PC6037.2 PC6038.2 PC6039.1 PC6040.2 PC6041.2 PC6042.2 PC6043.2 PC6044.2 PC6045.2 PC6046.2 PC6047.2 PC6048.2 PC6049.2 PC6050.2 PC6051.2 PC6052.2 PC6053.2 PC6054.2 PC6055.1 PC6056.2 PC6057.2 PC6058.2 PC6228.2 PC6229.1 PC6230.2 PC6231.2 PC7000.1 PC7001.2 PC7003.1 PC7004.2 PC7005.2 PC7006.2 PC7007.2 PC7009.2 PC7012.2 PC7013.2 PC7015.2 PC7018.2 PC7019.2 PC7023.2 PC7024.2 PC7025.1 PC7026.2 PC7027.1 PC7029.1 PC7030.1 PC7031.2 PC7032.2 PC7033.2 PC7034.2 PC7035.1 PC7036.2 PC7037.2 PC7038.2 PC7039.1 PC7040.2 PC7041.2 PC7042.2 PC7043.2 PC7044.2 PC7045.2 PC7046.1 PC7049.2 PC7050.2 PC7051.2 PC7052.2 PC7053.2 PC7054.1 PC7055.2 PC7057.1 PC7058.2 PC7059.2 PC7060.2 PC7061.2 PC7062.2 PC7063.1 PC7064.1 PC7066.2 PC7067.2 PC7068.2 PC7069.1 PC7070.2 PC7072.2 PC7073.2 PC7074.2 PC7075.2 PC7076.2 PC7077.2 PC7078.1 PC7080.2 PC7081.2 PC7082.2 PC7083.2 PC7084.2 PC7085.1 PC7086.2 PC7087.1 PC7088.2 PC7089.2 PC7090.2 PC7091.2 PC7092.2 PC7093.2 PC7094.2 PC7095.2 PC7096.1 PC7102.1 PC7104.1 PC7106.1 PC9000.2 PC9001.2 PC9002.2 PC9003.2 PC9004.2 PC9005.2 PC9006.2 PC9007.2 PC9009.2 PC9010.2 PC9011.2 PC9012.2 PC9013.2 PC9014.1 PC9015.2 PC9016.2 PC9017.2 PC9018.2 PC9019.2 PC9021.2 PC9022.2 PC9023.2 PC9024.2 PC9025.2 PC9026.2 PC9027.2 PC9029.2 PC9030.2 PC9053.2 PC9054.2 PC9055.2 PC9056.2 PC9057.2 PC9058.2 PC9059.2 PC9060.2 PC9062.2 PC9063.2 PC9064.2 PC9065.2 PC9066.2 PC9067.2 PC9068.2 PC9069.2 PC9071.2 PC9072.2 PC9073.2 PC9074.2 PC9075.2 PC9076.2 PC9077.2 PC9078.2 PC9080.2 PC9081.2 PC9082.2 PC9083.2 PC9084.2 PC9085.2 PC9086.2 PC9087.2 PC9088.2 PC9092.2 PC9093.2 PC9094.2 PC9095.2 PC9096.2 PC9098.2 PD2.2 PD3.2 PD4.2 PJ1.1 PJ1.2 PJ1.9 PJ1.10 PJ2.2 PJ2.4 PJ2.5(SPRING & SHELL(-) #3) PQ6.1(S) PQ7.1(EMITTER) PQ10.1(S) PQ12.1(S) PQ14.1(S) PQ16.1(EMITTER) PQ17.1(S) PQ19.1(S) PQ25.1(S) PQ29.1 PQ29.2 PQ29.3(S3) PQ6000.1(S) PQ6001.1(S) PQ7000.10(S2) PQ7001.10(S2) PQ7003.1 PQ7003.2 PQ7003.3(S3) PQ7004.10(S2) PQ9000.10(S2) PQ9001.10(S2) PQ9009.1(S) PQ9010.1(S) PQ9011.1(S) PQ9050.1(S) PQ9083.1(EMITTER) PQ9084.1(S) PQ9085.1(S) PQ9086.1(S) PR10.2 PR23.2 PR40.2 PR80.2 PR118.2 PR120.2 PR184.2 PR205.1 PR206.2 PR207.2 PR211.1 PR224.2 PR230.2 PR253.1 PR273.2 PR283.2 PR567.1 PR3021.2 PR6007.2 PR6012.2 PR6014.1 PR6024.2 PR6031.1 PR7033.2 PR7034.2 PR7038.2 PR7040.2 PR7041.1 PR7042.1 PR7045.2 PR7052.2 PR7061.2 PR7104.1 PR9011.2 PR9022.1 PR9030.1 PR9031.1 PR9032.1 PR9034.2 PR9077.2 PR9082.1 PR9098.1 PR9101.2 PR9104.2 PR9105.2 PR9274.2 PU1.22 PU1.29 PU1.30 PU1.31 PU1.32 PU1.33 PU1.34 PU1.35 PU1.36 PU1.37 PU1.38 PU14.8 PU14.9 PU16.12 PU16.13 PU16.14 PU16.15 PU16.19 PU26.13 PU26.14 PU26.15 PU26.16 PU26.17 PU26.18 PU26.26 PU26.28 PU3002.2 PU3002.4 PU3003.2 PU3004.4 PU3004.8 PU3004.9 PU6000.4 PU6000.8 PU6001.11 PU6001.15 PU6002.11 PU6002.15 PU6003.4 PU6003.8 PU7000.49 PU7001.6 PU7001.9 PU7002.6 PU7002.9 PU7003.6 PU7003.9 PU7004.6 PU7004.9 PU9000.25 PU9002.11 PU9002.15 PU9003.2 PU9004.12 PU9004.13 PU9004.14 PU9004.15 PU9004.19 Q14.1(S) Q16.1(S) Q20.1(S) Q22.1(S) Q31.1(EMITTER) Q34.1(S) Q81.1(S) Q6508.2 Q6509.1(S) Q6515.1(S) Q6519.1(S) Q6519.4 Q6520.1(S) Q6521.1(S) Q6521.4 Q6522.1(EMITTER) Q6533.1(S) R1.1 R16.2 R17.1 R18.1 R20.2 R21.1 R24.1 R25.1 R28.2 R29.1 R30.2 R34.1 R44.1 R45.2 R46.2 R56.1 R59.1 R73.1 R74.2 R82.2 R84.1 R85.1 R86.2 R87.2 R88.1 R90.1 R116.1 R121.2 R122.1 R124.1 R125.1 R136.2 R137.2 R138.2 R145.2 R146.1 R147.2 R148.1 R157.1 R158.1 R183.1 R209.2 R228.2 R229.2 R230.2 R243.2 R244.1 R245.2 R246.2 R247.2 R248.2 R253.2 R254.2 R255.2 R256.2 R257.1 R264.2 R267.2 R306.1 R311.2 R312.1 R313.2 R315.1 R317.2 R319.1 R320.2 R325.1 R331.2 R332.2 R350.1 R351.1 R352.1 R353.1 R354.1 R355.1 R356.1 R357.1 R358.1 R394.2 R396.2 R398.1 R405.1 R406.1 R409.1 R410.1 R414.1 R415.1 R416.2 R442.2 R446.1 R463.2 R464.2 R465.2 R467.2 R469.2 R470.2 R479.2 R497.1 R499.1 R504.1 R506.1 R507.2 R508.1 R510.1 R589.1 R654.1 R676.2 R677.2 R678.2 R679.1 R734.1 R748.2 R749.2 R825.1 R890.2 R951.2 R1234.1 R1235.1 R1236.1 R1250.1 R2660.2 R25270.2 R25272.1 R25275.1 R25277.1 R25279.1 R25282.1 R25298.1 R25303.2 R25311.2 R25316.2 R25320.2 R25358.1 R25369.2 R25375.1 R25378.1 R25379.1 R25380.1 R25385.1 R25386.1 R25387.1 R25391.1 R25392.1 R25393.1 R25394.1 R25403.2 R25431.2 R25433.2 R25481.2 R25485.2 R25495.2 R25499.1 R25501.2 RV1.3 RV2.3 RV2.8 RV3.3 RV3.8 SW1.3 SW1.4 SW3.1 SW3.2 SW3.5 SW3.6 U1.A3 U1.A4 U1.A32 U1.A36 U1.AB3 U1.AB4 U1.AB7 U1.AB27 U1.AB30 U1.AB33 U1.AB36 U1.AC5 U1.AC10 U1.AC27 U1.AC30 U1.AD33 U1.AD35 U1.AE7 U1.AE24 U1.AE25 U1.AE26 U1.AE27 U1.AE30 U1.AF3 U1.AF4 U1.AF7 U1.AF25 U1.AF27 U1.AF30 U1.AF33 U1.AF36 U1.AG5 U1.AG10 U1.AG24 U1.AG26 U1.AH24 U1.AH25 U1.AH27 U1.AH28 U1.AH29 U1.AH30 U1.AH31 U1.AH33 U1.AH35 U1.AJ7 U1.AJ25 U1.AJ28 U1.AK3 U1.AK4 U1.AK33 U1.AK36 U1.AL7 U1.AL28 U1.AL29 U1.AL32 U1.AM5 U1.AM10 U1.AM28 U1.AM33 U1.AM35 U1.AN7 U1.AN8 U1.AN25 U1.AN28 U1.AN29 U1.AN30 U1.AN31 U1.AP3 U1.AP4 U1.AP33 U1.AP36 U1.AR4 U1.AR28 U1.AT4 U1.AT33 U1.AT35 U1.AT36 U1.AU4 U1.AU10 U1.AU28 U1.AU29 U1.AU32 U1.AV3 U1.AV4 U1.AV6 U1.AV8 U1.AV25 U1.AV28 U1.AV33 U1.AV36 U1.AW1 U1.AW3 U1.AW4 U1.AW28 U1.AW29 U1.AW30 U1.AW31 U1.AY4 U1.AY33 U1.AY35 U1.B2 U1.B5 U1.B7 U1.B9 U1.B12 U1.B15 U1.B18 U1.B21 U1.B23 U1.B25 U1.B27 U1.B29 U1.B31 U1.B34 U1.B36 U1.B37 U1.BA3 U1.BA4 U1.BA6 U1.BA10 U1.BA28 U1.BB3 U1.BB4 U1.BB33 U1.BB36 U1.BC4 U1.BC8 U1.BC25 U1.BC29 U1.BC32 U1.BD4 U1.BD6 U1.BD7 U1.BD28 U1.BD33 U1.BD35 U1.BD36 U1.BE3 U1.BE4 U1.BE8 U1.BE10 U1.BE28 U1.BE29 U1.BE30 U1.BE31 U1.BF3 U1.BF4 U1.BF33 U1.BF36 U1.BG4 U1.BG25 U1.BG28 U1.BH28 U1.BH29 U1.BH32 U1.BH33 U1.BH35 U1.BJ7 U1.BK2 U1.BK3 U1.BK4 U1.BK7 U1.BK10 U1.BK28 U1.BK33 U1.BL7 U1.BL25 U1.BL28 U1.BL29 U1.BL30 U1.BL31 U1.BL32 U1.BM9 U1.BM33 U1.BM35 U1.BM36 U1.BN7 U1.BN30 U1.BP3 U1.BP4 U1.BP7 U1.BP12 U1.BP15 U1.BP19 U1.BP25 U1.BP32 U1.BP33 U1.BR16 U1.BR19 U1.BR22 U1.BR25 U1.BT5 U1.BT14 U1.BT15 U1.BT16 U1.BT25 U1.BT28 U1.BT33 U1.BT35 U1.BT36 U1.BU7 U1.BU11 U1.BU16 U1.BU20 U1.BU23 U1.BU24 U1.BU25 U1.BV3 U1.BV4 U1.BV11 U1.BV31 U1.BV33 U1.BW7 U1.BW11 U1.BW15 U1.BW24 U1.BY5 U1.BY11 U1.BY15 U1.BY18 U1.BY19 U1.BY22 U1.BY25 U1.BY28 U1.BY33 U1.BY35 U1.BY36 U1.C1 U1.C4 U1.C9 U1.C21 U1.C25 U1.C29 U1.C33 U1.C36 U1.C37 U1.CA11 U1.CA15 U1.CA22 U1.CA25 U1.CB2 U1.CB3 U1.CB4 U1.CB7 U1.CB11 U1.CB18 U1.CB19 U1.CB20 U1.CB24 U1.CB25 U1.CB33 U1.CC7 U1.CC11 U1.CC14 U1.CC16 U1.CC20 U1.CC24 U1.CC25 U1.CC28 U1.CC31 U1.CD11 U1.CD12 U1.CD14 U1.CD20 U1.CD24 U1.CD25 U1.CE7 U1.CE33 U1.CE35 U1.CE36 U1.CF2 U1.CF3 U1.CF4 U1.CF11 U1.CF14 U1.CF19 U1.CF23 U1.CF28 U1.CG7 U1.CG33 U1.CH31 U1.CJ2 U1.CJ3 U1.CJ4 U1.CJ11 U1.CJ14 U1.CJ19 U1.CJ23 U1.CJ28 U1.CJ33 U1.CJ35 U1.CJ36 U1.CK1 U1.CK4 U1.CK7 U1.CK37 U1.CL2 U1.CM1 U1.CM4 U1.CM5 U1.CM9 U1.CM13 U1.CM17 U1.CM21 U1.CM25 U1.CM29 U1.CM31 U1.CM33 U1.CM37 U1.CN1 U1.CN2 U1.CN5 U1.CN9 U1.CN13 U1.CN17 U1.CN21 U1.CN25 U1.CN29 U1.CN37 U1.CP1 U1.CP2 U1.CP9 U1.CP11 U1.CP13 U1.CP15 U1.CP19 U1.CP21 U1.CP27 U1.CP35 U1.CP37 U1.CR2 U1.CR6(VSS_433) U1.CR34 U1.CR36 U1.D1 U1.D5 U1.D6 U1.D8 U1.D9 U1.D21 U1.D25 U1.E9 U1.E23 U1.E27 U1.E29 U1.E31 U1.E33 U1.E35 U1.F2 U1.F3 U1.F4 U1.F12 U1.F15 U1.F18 U1.F21 U1.F24 U1.F33 U1.G9 U1.G21 U1.G27 U1.G33 U1.G35 U1.G36 U1.H9 U1.H21 U1.H27 U1.J5 U1.J6 U1.J12 U1.J15 U1.J18 U1.J21 U1.J24 U1.J33 U1.J36 U1.K3 U1.K4 U1.K9 U1.K21 U1.K22 U1.K24 U1.K25 U1.K27 U1.K28 U1.K29 U1.K30 U1.K31 U1.K32 U1.L6 U1.L27 U1.L33 U1.L35 U1.L36 U1.N6 U1.N25 U1.N27 U1.P3 U1.P4 U1.P7 U1.P10 U1.P33 U1.P36 U1.R27 U1.R28 U1.R29 U1.R30 U1.R31 U1.T7 U1.T27 U1.T30 U1.T33 U1.T35 U1.T36 U1.U7 U1.U24 U1.U26 U1.V3 U1.V4 U1.V26 U1.V27 U1.V30 U1.V33 U1.V36 U1.W7 U1.W10 U1.W27 U1.W30 U1.Y7 U1.Y26 U1.Y27 U1.Y30 U1.Y33 U1.Y35 U2.4 U3.2 U4.A2 U4.A8 U4.B2 U4.C9 U4.D2 U4.D8 U4.E1 U4.E3 U4.E8 U4.F1 U4.G8 U4.H1 U4.H9 U4.K1 U4.K9 U4.N1 U4.N9 U4.T1 U5.A2 U5.A8 U5.B2 U5.C9 U5.D2 U5.D8 U5.E1 U5.E3 U5.E8 U5.F1 U5.G8 U5.H1 U5.H9 U5.K1 U5.K9 U5.N1 U5.N9 U5.T1 U6.A2 U6.A8 U6.B2 U6.C9 U6.D2 U6.D8 U6.E1 U6.E3 U6.E8 U6.F1 U6.G8 U6.H1 U6.H9 U6.K1 U6.K9 U6.N1 U6.N9 U6.T1 U7.A2 U7.A8 U7.B2 U7.C9 U7.D2 U7.D8 U7.E1 U7.E3 U7.E8 U7.F1 U7.G8 U7.H1 U7.H9 U7.K1 U7.K9 U7.N1 U7.N9 U7.T1 U8.A2 U8.A26 U8.AA7 U8.AB7 U8.AB11 U8.AB14 U8.AB17 U8.AB20 U8.AB24 U8.AC2 U8.AC5 U8.AC8 U8.AC22 U8.AC26 U8.AD12 U8.AD13 U8.AD15 U8.AD16 U8.AD18 U8.AD19 U8.AD21 U8.AD22 U8.AE11 U8.AE14 U8.AE17 U8.AE20 U8.AF1 U8.AF5 U8.AF8 U8.AF11 U8.AF14 U8.AF17 U8.AF20 U8.AF23 U8.AG2 U8.AG26 U8.B1 U8.B5 U8.B8 U8.B11 U8.B14 U8.B17 U8.B20 U8.B23 U8.B27 U8.E2 U8.E5 U8.E8 U8.E11 U8.E14 U8.E17 U8.E20 U8.E22 U8.E25 U8.H2 U8.H5 U8.H23 U8.H25 U8.K11 U8.K13 U8.K15 U8.K17 U8.L2 U8.L5 U8.L10 U8.L12 U8.L14 U8.L16 U8.L18 U8.L23 U8.L25 U8.M11 U8.M13 U8.M15 U8.M17 U8.N10 U8.N12 U8.N14 U8.N16 U8.N18 U8.P2 U8.P5 U8.P11 U8.P13 U8.P15 U8.P17 U8.P23 U8.P26 U8.R10 U8.R12 U8.R14 U8.R16 U8.R18 U8.T11 U8.T13 U8.T15 U8.T17 U8.U2 U8.U5 U8.U10 U8.U12 U8.U14 U8.U16 U8.U18 U8.U23 U8.U26 U8.V11 U8.V13 U8.V15 U8.V17 U8.Y2 U8.Y5 U8.Y23 U8.Y26 U9.3 U11.3 U14.14 U14.17 U15.2 U16.3 U16.8 U16.9 U16.11 U17.3 U17.8 U17.9 U17.11 U18.2 U19.2 U20.49 U23.17 U23.33 U23.34 U23.35 U23.36 U23.37 U24.33 U25.25 U32.5 U32.10 U32.12 U32.13 U32.15 U32.16 U33.16 U33.23 U33.33 U35.3 U36.3 U37.1 U37.27 U37.49 U37.91 U37.104 U42.3 U42.13 U42.18 U42.21 U42.22 U42.23 U42.24 U42.25 U42.26 U6502.3 U6502.19 U6503.12 U6503.21 U6503.22 U6503.23 U6503.24 U6503.25 U6503.26 U6503.27 U6504.3 VC2.2 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.J1 VRAM1.J10 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM2.A1 VRAM2.A3 VRAM2.A12 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C3 VRAM2.C4 VRAM2.C11 VRAM2.C12 VRAM2.C14 VRAM2.D10 VRAM2.E1 VRAM2.E3 VRAM2.E12 VRAM2.E14 VRAM2.F5 VRAM2.F10 VRAM2.G5 VRAM2.G10 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.J1 VRAM2.J10 VRAM2.K1 VRAM2.K2 VRAM2.K13 VRAM2.K14 VRAM2.L5 VRAM2.L10 VRAM2.M5 VRAM2.M10 VRAM2.N1 VRAM2.N3 VRAM2.N12 VRAM2.N14 VRAM2.P10 VRAM2.R1 VRAM2.R3 VRAM2.R4 VRAM2.R11 VRAM2.R12 VRAM2.R14 VRAM2.T5 VRAM2.T10 VRAM2.U1 VRAM2.U3 VRAM2.U12 VRAM2.U14 Y2.2 Y2.4 Y3.2 Y3.4 Y4.2 Y4.4
V3A_BOOT: PR6000.2 PU6000.1
V3A_BOOT_R: PC6001.1 PR6000.1
V3A_EN: PC6007.2 PR6002.1 PR6006.2 PU6000.6
V3A_PWRGD: PR6005.1 PU6000.7
V3A_VBYP: PC6023.1 PR6009.2 PR6017.1 PU6000.11
V3A_VOUT: PC6017.2 PR6008.2 PR6010.2 PR6011.2 PU6000.10(VOUT)
V5P5A_BOOT: PR6018.2 PU6003.1
V5P5A_BOOT_R: PC6035.1 PR6018.1
V5P5A_EN: PC6039.2 PR6020.1 PR6021.2 PU6003.6
V5P5A_PWRGD: PR6022.1 PU6003.7
V5P5A_VOUT: PC6055.2 PR6026.1 PR6029.2 PR6030.2 PU6003.10(VOUT)
VCC1_CORE: PC7106.2 PR7108.2 PU7002.8(VCC)
VCC2_CORE: PC7063.2 PR7080.2 PU7001.8(VCC)
VCC_GT: PC7102.2 PR7112.2 PU7003.8(VCC)
VCC_SA: PC7104.2 PR7116.2 PU7004.8(VCC)
VCCA_19P2_1P05: R1271.1 U1.BR12
VCCA_OC_1P05: R1265.1 U1.BP14
VCCA_SRC_1P05: R1266.1 U1.BU12
VCCA_XTAL_1P05: C227.2 R1267.1 U1.CP5
VCCAMPHYPLL_1P05: C235.2 R1280.2 U1.BV2
VCCAPLL_1.05V: C232.2 C6623.1 L2.2 U1.BR14 U1.BR15 U1.BT12 U1.BU14
VCCDPHY_1P24: C228.2 R211.1 U1.CP25
VCCDSW_1P05: C229.2 U1.BT24
VCCDSW_3P32: R1270.1 U1.BT23
VCCDSW_GPIO: C236.2 R1281.2 U1.BR24
VCCDUSB_1P05: C6620.1 R1279.2 U1.CC12
VCCGT_SENSE: PR7050.1 PR7051.1 U1.E3
VCCHDA: C237.2 R1278.2 U1.BT20
VCCIO_VCCSENSE: R72.1 U1.BP28
VCCIO_VSSSENSE: R74.1 U1.BP29
VCCMPHYGTAON_1P05: C233.2 C234.2 C6622.1 R1277.2 U1.BV12 U1.BV14 U1.BW12 U1.BW14 U1.BY12 U1.BY14
VCCPRIM_1P05: C223.2 C238.2 R1262.1 R1264.1 R1275.2 R2525.2 U1.BP20 U1.BP22 U1.BR20 U1.BT18 U1.BT19 U1.BT22 U1.BU18 U1.BU19 U1.BW16 U1.BW18 U1.BW19 U1.BY16 U1.BY20 U1.CA14
VCCPRIM_1P8: C224.2 C230.2 R1253.2 R1272.1 U1.CC15 U1.CC18 U1.CC19 U1.CD15 U1.CD16 U1.CD18 U1.CD19 U1.CP17 U1.CP23
VCCPRIM_3P3: C220.2 C221.2 R1251.2 R1273.1 R1274.1 U1.BP23 U1.BW23 U1.CB22 U1.CB23 U1.CC22 U1.CC23 U1.CD22 U1.CD23 U1.CP29
VCCPRIM_3P33: C219.2 C222.2 R1260.1 U1.CB16
VCCSA_SENSE: PR7057.1 PR7058.1 U1.BG7
VCCSPI: R1276.2 U1.BV23
VSSGT_SENSE: PR7052.1 PR7053.1 U1.D2
VSSSA_SENSE: PR7061.1 PR7062.1 U1.BE7
1.03_GFX_PGD: PR9076.1 PR9078.2 PR9096.1
2ND_MBCLK: Q13.3 R383.1 R740.2 R25449.1 U37.115
2ND_MBDATA: Q13.6 R739.2 R25304.1 R25450.1 U37.116
27M_XTAL_IN: C463.1 U8.C11 Y3.3
27M_XTAL_OUT: C464.1 U8.B10 Y3.1
3602_ALERT#: PR7020.1 PU7000.33
3602_CLK: PR7015.2 PU7000.34
3602_DRON: PR7079.1 PR7107.1 PR7111.1 PR7115.1 PU7000.35
3602_PSYS: PC7006.1 PR7039.2 PR7042.2 PU7000.46
3602_SET1: PR7027.2 PR7035.2 PU7000.2
3602_SET2: PR7028.2 PR7036.1 PU7000.5
3602_SET3: PR7029.2 PR7037.1 PU7000.6
3602_TSENSE_CORE: PR7026.2 PR7032.1 PU7000.11
3602_TSENSE_GT: PR7018.2 PR7021.1 PU7000.23
3602_VCC: PC7026.1 PR7064.2 PU7000.13
3602_VDIO: PR7019.2 PU7000.32
3602_VIN: PC7000.2 PR7000.1 PU7000.12
3602_VREF: PR7004.1 PR7005.1 PR7006.2 PR7008.1 PR7009.1 PR7010.1 PR7013.1 PR7022.2 PR7023.2 PR7024.2 PU7000.42
3602_VRHOT: PR7011.1 PR7012.1 PU7000.31(V\R\H\O\T\)
5213EN_1.8V: PC581.1 PR566.1 PU3004.7
5213FB_1.8V: PC574.2 PR567.2 PR568.2 PU3004.1
5213FB_1.8V_S: PC574.1 PR568.1 PR569.1
5213LX_1.8V: PL551.1 PR551.1 PU3004.6
5213PG_1.8V: PR9256.2 PU3004.2
5416_VCC: PC268.2 PR256.1 PU26.7
5447_CC1_CON: C691.2 CN10.A5 D16.2 U6503.11
5447_CC2_CON: C692.2 CN10.B5 D17.2 U6503.13
8813BOOT1: PC9008.2 PU9000.1
8813BOOT2: PC9020.2 PU9000.18
8813EN: PC9013.1 PD9000.2 PR9012.1 PR9085.2 PU9000.3
8813ILIM: PC9030.1 PR9032.2 PU9000.12
8813ISEN1: PC9014.2 PR9013.2 PU9000.15
8813ISEN2: PR9025.2 PU9000.14
8813LGAT1: PQ9000.8 PR9011.1 PU9000.23
8813LGAT2: PQ9001.8 PU9000.20
8813PG: PR9008.2 PR9009.2 PU9000.16
8813PHASE1: PC9008.1 PL9001.1 PQ9000.5 PQ9000.6 PQ9000.7 PR9004.2 PU9000.24
8813PHASE2: PC9020.1 PL9000.1 PQ9001.5 PQ9001.6 PQ9001.7 PR9019.2 PU9000.19
8813PSI: PR9016.2 PR9018.2 PR9022.2 PU9000.4
8813PVCC: PC9000.1 PR9001.2 PU9000.21
8813REFADJ: PR9023.2 PU9000.6
8813REFIN: PC9026.1 PR9024.2 PR9027.1 PU9000.7
8813RGN: PC9028.2 PC9029.1 PR9029.1 PU9000.10
8813TON: PR9002.1 PU9000.9
8813UGATE1: PR9006.1 PU9000.2
8813UGATE1_1: PQ9000.1 PR9006.2
8813UGATE2: PR9014.1 PU9000.17
8813UGATE2_1: PQ9001.1 PR9014.2
9336ADJ: PR9081.2 PR9082.2 PU9003.5
9336DRV: PD9001.1(CATHODE) PQ9008.4 PR9080.1 PU9003.6
24780_ACDET: PQ17.3 PR31.2 PR211.2 PU1.6
24780_ACDRV: PR29.2 PU1.4
24780_ACN: PC25.2 PC35.1 PR2.2 PU1.1
24780_ACP: PC25.1 PC36.2 PR1.2 PU1.2
24780_BATDRV: PR4.2 PU1.18
24780_BATSRC: PR7.2 PU1.17
24780_BM#: PR9.1 PU1.16
24780_BST: PR11.1 PU1.25
24780_CMPIN: PR207.1 PU1.13
24780_CMPOUT: PR15.1 PU1.14
24780_CMSRC: PR28.2 PU1.3
24780_DH: PQ30.4 PU1.26
24780_DL: PQ29.4 PU1.23
24780_ILIM: PC8.2 PR204.1 PR206.1 PU1.21
24780_LX: PC15.1 PL5.1 PQ29.5 PQ30.1 PQ30.2 PQ30.3(S3) PR33.1 PU1.27
24780_SRN: PC3.1 PC4.2 PR6.2 PR208.1
24780_SRP: PC3.2 PC6.2 PR5.2 PR210.1
24780_VCC: PC16.1 PR16.1 PU1.28(VCC)
25810_AUO#: R6508.2 U6503.17
25810_DBG#: R6510.2 U6503.16
25810_FAULT#: R6504.2 U6503.1
25810_LD_DET#: R6505.2 U6503.20
25810_POL#: R9041.2 R9042.2 R25280.1 U6503.18
25810_REF: R6517.1 U6503.10
25810_REF_RTN: R6517.2 U6503.9
25810_UFP#: Q6505.3 Q6519.2 R6506.2 R25337.1 U6503.19
+1.03_GFX: C347.2 C348.2 C349.2 C350.2 C354.1 C363.2 C366.1 PJ9003.2 PR9081.1 U8.AA22 U8.AB23 U8.AC24 U8.AD25 U8.AE26 U8.AE27
+601_VCC: C6598.1 C6599.1 C6600.1 C6601.1 C6602.1 C6607.1 R495.2 R498.2 R500.2 R503.2 R505.2 R1237.2 R1238.2 R1239.1 U42.10 U42.20(VCC#2)
+AZA_VDD: C565.1 C580.1 C581.1 R455.2 R478.2 U20.1 U20.36
+FB_PLLAVDD: C453.2 C454.2 C455.2 C456.1 L5.2 L6.2 U8.F16 U8.H22 U8.P22
+G_SEN_PW: C6603.1 C6608.1 R582.2 R25355.1 R25356.1 U32.1(VDD_IO) U32.8 U32.14
+SMDDR_VREF_DIMM: C264.1 C265.1 JDIM1.164 R241.2 R242.2 R243.1
+SMDDR_VREF_DQ1_M1: C312.1 C314.1 C317.2 C320.2 C323.2 C326.2 C336.2 C337.2 C338.2 R261.2 R262.2 R263.2 R264.1 U4.M1 U5.M1 U6.M1 U7.M1
+TYPEC_VBUS: C675.2 C676.2 C6582.2 CN10.A4 CN10.A9 CN10.B4 CN10.B9(VBUSB9) D6541.1 Q6516.1 Q6516.2 Q6516.3(S3) Q6518.1 R25339.2 R25340.1 R25342.1
+TYPEC_VBUS_C: C6505.2 C6581.1 Q6516.5 U6503.14 U6503.15
+USBPWR0: C509.2 C510.2 C511.2 C514.2 CN2.1 R25363.1 R25364.1 U14.12(VOUT) U16.2(VDD)
+USBPWR1: C515.2 C516.2 C517.2 C525.2 CN3.1 R25363.2 R25364.2 U15.1(OUT) U17.2(VDD)
+VGPU_CORE: C351.2 C352.2 C353.2 C355.2 C356.2 C357.2 C359.2 C365.2 C367.2 C368.2 C369.2 C372.2 C373.2 C374.2 C385.1 C387.2 C388.2 C389.2 C391.2 C393.2 C396.2 C397.2 C400.2 C403.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.1 C414.1 C415.2 C416.1 C417.1 C418.2 C419.1 C420.1 C421.2 C422.2 C423.2 C424.2 C426.2 C427.2 C428.2 C430.2 C432.2 PC9009.1 PC9010.1 PC9011.1 PC9021.1 PC9022.1 PL9000.2 PL9001.2 PR9026.1 U8.K10 U8.K12 U8.K14 U8.K16 U8.K18 U8.L11 U8.L13 U8.L15 U8.L17 U8.M10 U8.M12 U8.M14 U8.M16 U8.M18 U8.N11 U8.N13 U8.N15 U8.N17 U8.P10 U8.P12 U8.P14 U8.P16 U8.P18 U8.R11 U8.R13 U8.R15 U8.R17 U8.T10 U8.T12 U8.T14 U8.T16 U8.T18 U8.U11 U8.U13 U8.U15 U8.U17 U8.V10 U8.V12 U8.V14 U8.V16 U8.V18
AC_PRESENT_EC: R35.1 U1.BU35 U37.84
ACCEL_INT2: D21.1(CATHODE) R25483.2
ACCEL_INT2_R: D21.2 U32.9
ACCEL_INTA: C6606.2 D20.1(CATHODE) R25474.1 U1.CR14
ACCEL_INTA_R: D20.2 U32.11
ACIN: PR30.1 PR39.2 PR40.1 U37.72
ACZ_BCLK: R187.2 U1.BN37
ACZ_RST#: C214.2 C217.2 R194.2 U1.BL35
ACZ_SDIN0: C215.2 R191.2 U1.BN35
ACZ_SDOUT: C213.2 C218.2 R117.1 R118.2 R25374.2 U1.BN36
ACZ_SPKR: D11.2 R116.2 U1.CF35
ACZ_SYNC: R186.2 R188.2 U1.BN34
ADOGND: C563.1 C564.2 C568.2 C569.2 C572.1 C573.2 C586.1 C588.1 C590.1 C591.1 C592.1 C593.1 C598.1 C599.2 C845.2 CN35.1 CN35.3 CN35.5 CN35.12 R447.1 R463.1 R464.1 R465.1 R467.1 R469.1 R470.1 R474.2 R475.2 U20.25 U20.38
ADP_ID: PJ2.3 PQ17.2 PR230.1 PR235.2
ALERT: R397.1 U8.F8
AMP_MUTE#: D13.1(CATHODE) U37.108
AP_EQ: R25273.1 R25279.2 U6502.9
BAT-V: PC164.1 PC165.1 PC166.1 PC167.2 PC168.1 PJ1.7 PJ1.8 PR208.2 PR209.2
BATLED0#: CN35.24 U37.29
BATLED1#: CN35.23 U37.25
BI: PJ1.6 PR10.1 R25321.2 SW2.1 SW2.2
BIOS_WP#: R110.1 R112.1 TP18.1 U2.3
BL#: Q6521.2 Q6521.3 R25368.1
BL_ON: CN29.26 D3.2 Q6521.6 Q6522.3 R25367.1
BOARD_ID0: R25392.2 R25395.1 U1.CH36
BOARD_ID1: R73.2 R25396.1 U1.CL35
BOARD_ID2: R25393.2 R25397.1 U1.CL36
BOARD_ID3: R25394.2 R25399.1 U1.CM35
BOARD_ID4: C20001.2 R59.2 R25398.1 R25521.1 U1.CN35
BOARD_ID5: R25390.1 R25391.2 U1.CH35
BOARD_ID6: C20002.2 R25386.2 R25388.1 R25522.1 U1.CK36
BOARD_ID7: R25387.2 R25389.1 U1.CK34
BRIGHT: R439.2 R441.1 R443.2
BT_EN: CN17.54(W_DISABLE2#) R671.1 R960.2
BXTALOUT: R330.1 R332.1 U8.C10
C_IN_CLK: C1681.2 CN37.10 R489.1 R703.2 R706.1
C_IN_CLK#: C1679.2 CN37.12 R489.2 R702.2 R707.1
C_IN_CLK#_R: C847.2 U23.31
C_IN_CLK_R: C849.2 U23.32
C_TX0_HDMI+: C1684.2 CN37.7 R487.1 R697.2 R712.1
C_TX0_HDMI+_R: C852.2 U23.26
C_TX0_HDMI-: C1685.2 CN37.9 R487.2 R696.2 R713.1
C_TX0_HDMI-_R: C853.2 U23.25
C_TX1_HDMI+: C1683.2 CN37.4 R486.1 R699.2 R710.1
C_TX1_HDMI+_R: C851.2 U23.28
C_TX1_HDMI-: C1680.2 CN37.6 R486.2 R698.2 R711.1
C_TX1_HDMI-_R: C848.2 U23.27
C_TX2_HDMI+: C1686.2 CN37.1 R484.1 R701.2 R708.1
C_TX2_HDMI+_R: C854.2 U23.30
C_TX2_HDMI-: C1682.2 CN37.3 R484.2 R700.2 R709.1
C_TX2_HDMI-_R: C850.2 U23.29
CATERR#: R10.2 U1.AA4
CFG0: R216.1 R218.1 U1.T4
CFG1: TP28.1 U1.R4
CFG2: TP30.1 U1.T3
CFG3: R86.1 R217.1 U1.R3
CFG4: R87.1 TP34.1 U1.J4
CFG5: TP36.1 U1.M4
CFG6: TP38.1 U1.J3
CFG7: TP40.1 U1.M3
CFG8: TP31.1 U1.R2
CFG9: TP33.1 U1.N2
CFG10: TP35.1 U1.R1
CFG11: TP37.1 U1.N1
CFG12: TP42.1 U1.J2
CFG13: TP44.1 U1.L2
CFG14: TP46.1 U1.J1
CFG15: TP48.1 U1.L1
CFG16: TP29.1 U1.L3
CFG17: TP27.1 U1.L4
CFG18: TP41.1 U1.N3
CFG19: TP39.1 U1.N4
CFG_RCOMP: R82.1 U1.AB5
CHA_SA0: JDIM1.256 R225.2 R228.1
CHA_SA1: JDIM1.260 R226.2 R229.1
CHA_SA2: JDIM1.166 R227.2 R230.1
CK_XDP_N: TP47.1 U1.AU1
CK_XDP_P: TP45.1 U1.AU2
CLK_24M_DEBUG: EC3.2 R92.2 R655.1 R674.2
CLK_24M_DEBUG_R: CN17.60 R674.1
CLK_PCI_EC: EC2.2 R91.2 R402.2 U37.13
CLK_PCI_EC_R: R91.1 U1.BV32
CLK_PCI_LPC_R: R92.1 U1.BV30
CLK_PCIE_LANN: U1.BA1 U24.16
CLK_PCIE_LANP: U1.BA2 U24.15
CLK_PCIE_REQ2#: R25440.1 TP9011.1 U1.CF30
CLK_PCIE_REQ3#: R25441.1 TP9012.1 U1.CE31
CLK_PCIE_SSDN: R2658.1 U1.BC1
CLK_PCIE_SSDN_C: CN16.53 R2658.2
CLK_PCIE_SSDP: R2659.1 U1.BC2
CLK_PCIE_SSDP_C: CN16.55 R2659.2
CLK_PCIE_WLANN: CN17.49 U1.BE1
CLK_PCIE_WLANP: CN17.47 U1.BE2
CLK_VGA_N: U1.AW2 U8.AD8
CLK_VGA_P: U1.AY3 U8.AE8
CLKRUN#: R96.2 U1.BY30 U37.93
CLR_CMOS: Q22.2 Q6520.2 R409.2 U37.19
CNV_BRI_DT: CN17.36 R664.2 R668.1
CNV_BRI_DT_R: R668.2 U1.CJ20
CNV_BRI_RSP: R662.2 R665.2 U1.CK20
CNV_BRI_RSP_L: CN17.22 R665.1
CNV_RF_RESET#: R677.1 U1.CJ32 U35.1 U35.2
CNV_RF_RESET#_L: CN17.10 R676.1 U35.4
CNV_RGI_DT: CN17.32 R180.2 R183.2 R666.1
CNV_RGI_DT_R: R666.2 U1.CG19
CNV_RGI_RSP: R663.2 R667.2 U1.CH19
CNV_RGI_RSP_L: CN17.34 R667.1
CNV_WR_CLK_DN: CN17.21 U1.CN31
CNV_WR_CLK_DP: CN17.23 U1.CP31
CNV_WR_LANE0_DN: CN17.15 U1.CR30
CNV_WR_LANE0_DP: CN17.17 U1.CP30
CNV_WR_LANE1_DN: CN17.9 U1.CM30
CNV_WR_LANE1_DP: CN17.11 U1.CN30
CNV_WT_CLK_DN: CN17.71 U1.CP34
CNV_WT_CLK_DP: CN17.73 U1.CN34
CNV_WT_LANE0_DN: CN17.65 U1.CN32
CNV_WT_LANE0_DP: CN17.67 U1.CM32
CNV_WT_LANE1_DN: CN17.59 U1.CP33
CNV_WT_LANE1_DP: CN17.61 U1.CN33
CNV_WT_RCOMP: R146.2 U1.CP32 U1.CR32
CODEC_VREF: C563.2 U20.28(VREF)
COMP_CORE: PC7011.1 PR7048.2 PU7000.4
COMP_GT: PC7017.1 PR7055.2 PU7000.26
COMP_SA: PC7021.1 PR7060.2 PU7000.43
CON_DE: R25275.2 R25278.1 U6502.15
CON_EQ: R25272.2 R25274.1 U6502.18
CPU_C10_GATE#: R161.1 U1.CN27
CPU_C10_GATE#_R: PQ35.4 PR2060.1 PR9272.2 R161.2 R1252.1
CTL2: R418.2 U14.7
CTL3: R417.2 U14.8
D/C#: PC20.2 PR26.1 TP9001.1
DC-DET: R732.1 R25495.1 U20.4
DCPRTC: C225.2 U1.BP24
DDCCLK_RIN: Q41.4 R775.2
DDCDATA_RIN: Q41.1(S) R777.2
DDR4_DRAMRST#: C3.2 C249.2 JDIM1.108 R27.1 U4.P1 U5.P1 U6.P1 U7.P1
DDR4_SUSON_2V5: PR9252.1 PR9273.2 U37.122
DDR_VTT_CNTL: TP1.1 U1.C35
DE1: R503.1 R1235.2 U42.9
DE2: R504.2 R505.1 U42.8
DEVSLP0: R25434.1 R25484.2 U1.CP8
DEVSLP0_R: HD1.5 R25484.1
DEVSLP1: R554.1 U1.CR8
DEVSLP2: R551.1 R645.2 U1.CM8
DEW1: R499.2 R500.1 U42.16
DEW2: R506.2 R1237.1 U42.6
DGPU_EDIDCLK: R363.1 U8.A9
DGPU_EDIDDATA: R366.1 U8.B9
DGPU_HOLD_RST#: R25428.2 U1.CE28 U9.1
DGPU_OPP#: Q6512.3 R378.1 U37.71
DGPU_OVT#_EC: Q15.3 R340.1 R385.1 U37.68
DGPU_PROCHOT_EC#: Q6512.1(S) R25322.1 U8.D7
DGPU_PSI: PR9016.1 R376.1 R391.1
DGPU_PW_CTRL#: R25375.2 R25377.2 U1.CB34
DGPU_PWR_EN: PR9070.2 R323.1 R25403.1 R25429.2 U1.CE27
DGPU_PWROK: Q9.2 R25376.1 R25468.1 U1.CA31
DISP_ON: R445.1 R446.2 U19.3
DMIC-DATA34: R453.1 TP9024.1
DMIC_CLK: R461.2 U20.3
DMIC_CLK_2: CN38.3 R25498.1
DMIC_CLK_2_R: C6617.2 R25498.2 U1.CP24
DMIC_CLK_L: C583.2 L12.2 R461.1
DMIC_CLK_L_C: C548.1 CN29.1 L12.1
DMIC_DAT: R459.1 U20.2
DMIC_DAT_2: CN38.2 R25497.1
DMIC_DAT_2_R: R25497.2 U1.CN24
DMIC_DAT_L: L13.2 R459.2
DMIC_DAT_L_C: C547.1 CN29.2 L13.1
DNBSWON#: U1.BU28 U37.123
DRAM_RESET#: R26.1 R27.2 U1.BU31
DRVEN_SET: PR7103.1 PR7104.2 PU7000.18
DSWROK_EC: R41.2 R51.2 TP9026.1
DSWROK_EC_R: C8.1 R46.1 R47.1 R51.1 U1.BP30
EC_FPBACK#: Q6522.2 U37.86
EC_ODD_EJ#: CN15.16 R638.1 R25328.1
EC_ODD_EJ_R#: C2607.1 R25328.2 U37.94
EC_PECI: R380.2 U1.AR1
EC_PECR_R: R380.1 U37.117
EC_PWROK: R25358.2 R25362.2 U37.33 U6504.1
EC_TYPEC_CHG: R6515.2 U6503.7
EC_TYPEC_CHG_HI: R6516.2 U37.3 U6503.8
EC_TYPEC_EN: R2356.1 U37.80
EC_TYPEC_EN_R: R2356.2 R25504.1 U6503.6
ECAGND: C6564.1 C6566.2 L11.1 U37.75
EDP_RCOMP: R2.2 U1.AM6
EDRAM_OPIO_RCOMP: R20.1 U1.L5
EMMC_RCOMP: R147.1 U1.CK15
EN: R1236.2 R1238.1 U42.7
EN1_CORE: PR7107.2 PU7002.1
EN2_CORE: PR7079.2 PU7001.1
EN_GT: PR7111.2 PU7003.1
EN_SA: PR7115.2 PU7004.1
EOPIO_RCOMP: R21.2 U1.N5
EQ1: R497.2 R498.1 U42.17
EQ2: R495.1 R1234.2 U42.19
EXT_PWR_GATE#: R40.1 U1.CC37
FAN1_RPM: FAN3.2 R25372.2 U37.47
FAN_PWM: Q6523.1(EMITTER) U37.32
FAN_PWM_C: FAN3.3 Q6523.3 R25373.2
FB_CAL_PD_VDDQ: R318.2 U8.D22
FB_CAL_PU_GND: R319.2 U8.C24
FB_CAL_TERM_GND: R320.1 U8.B25
FB_CORE: PC7010.2 PC7011.2 PR7047.1 PR7048.1 PR7049.2 PU7000.3
FB_GT: PC7016.1 PC7017.2 PR7054.1 PR7055.1 PR7056.2 PU7000.24
FB_SA: PC7020.1 PC7021.2 PR7059.1 PR7060.1 PR7063.1 PU7000.45
FBA_CMD0: U8.C27 VRAM1.G12
FBA_CMD1: U8.C26 VRAM1.H10
FBA_CMD2: U8.E24 VRAM1.H11
FBA_CMD3: U8.F24 VRAM1.K11
FBA_CMD4: U8.D27 VRAM1.K10
FBA_CMD5: U8.D26 VRAM1.L12
FBA_CMD6: U8.F25 VRAM1.K4
FBA_CMD7: U8.F26 VRAM1.K5
FBA_CMD8: U8.F23 VRAM1.J4
FBA_CMD9: U8.G22 VRAM1.J5
FBA_CMD10: U8.G23 VRAM1.H4
FBA_CMD11: U8.G24 VRAM1.H5
FBA_CMD12: U8.F27 VRAM1.G3
FBA_CMD13: R315.2 U8.G25 VRAM1.J2
FBA_CMD14: R316.2 U8.G27 VRAM1.J3
FBA_CMD15: U8.G26 VRAM1.L3
FBA_CMD16: U8.M24 VRAM2.G12
FBA_CMD17: U8.M23 VRAM2.H10
FBA_CMD18: U8.K24 VRAM2.H11
FBA_CMD19: U8.K23 VRAM2.K11
FBA_CMD20: U8.M27 VRAM2.K10
FBA_CMD21: U8.M26 VRAM2.L12
FBA_CMD22: U8.M25 VRAM2.K4
FBA_CMD23: U8.K26 VRAM2.K5
FBA_CMD24: U8.K22 VRAM2.J4
FBA_CMD25: U8.J23 VRAM2.J5
FBA_CMD26: U8.J25 VRAM2.H4
FBA_CMD27: U8.J24 VRAM2.H5
FBA_CMD28: U8.K27 VRAM2.G3
FBA_CMD29: R317.1 U8.K25 VRAM2.J2
FBA_CMD30: R314.1 U8.J27 VRAM2.J3
FBA_CMD31: U8.J26 VRAM2.L3
FBA_DBI0: U8.D19 VRAM1.D2
FBA_DBI1: U8.D14 VRAM1.D13
FBA_DBI2: U8.C17 VRAM1.P13
FBA_DBI3: U8.C22 VRAM1.P2
FBA_DBI4: U8.P24 VRAM2.P13
FBA_DBI5: U8.W24 VRAM2.P2
FBA_DBI6: U8.AA25 VRAM2.D2
FBA_DBI7: U8.U25 VRAM2.D13
FBA_EDC0: U8.E19 VRAM1.C2
FBA_EDC1: U8.C15 VRAM1.C13
FBA_EDC2: U8.B16 VRAM1.R13
FBA_EDC3: U8.B22 VRAM1.R2
FBA_EDC4: U8.R25 VRAM2.R13
FBA_EDC5: U8.W23 VRAM2.R2
FBA_EDC6: U8.AB26 VRAM2.C2
FBA_EDC7: U8.T26 VRAM2.C13
FBA_VREFC_1: C505.1 R407.2 R410.2 R411.2 VRAM1.J14
FBA_VREFC_2: C506.1 R25282.2 R25283.2 R25284.2 VRAM2.J14
FBVDD_EN: R325.2 R25469.1 U11.4(Y)
FBVDDQ_EN: PR9095.2 R25469.2
G5335-AGND-1: PC228.2 PC232.2 PR270.2 PR272.2 PR273.1 PU16.4
G5335-AGND-2: PC9090.2 PC9091.2 PR9093.2 PR9097.2 PR9098.2 PU9004.4
G5335-BST-1: PR277.2 PU16.20
G5335-BST-2: PR9089.2 PU9004.20
G5335-EN-1: PC228.1 PR274.1 PU16.2
G5335-EN-2: PC9090.1 PQ9086.2 PR9095.1 PR9096.2 PU9004.2
G5335-FB-1: PC225.1 PR269.2 PR270.1 PU16.5
G5335-FB-2: PC9089.1 PR9094.2 PR9097.1 PU9004.5
G5335-LX-1: PC235.1 PL12.1 PR99.1 PU16.10 PU16.11 PU16.16 PU16.17 PU16.18 PU16.25
G5335-LX-2: PC9079.1 PL9002.1 PR9092.1 PU9004.10 PU9004.11 PU9004.16 PU9004.17 PU9004.18 PU9004.25
G5335-PFM-1: PR98.1 PR272.1 PU16.3
G5335-PFM-2: PR9091.1 PR9093.1 PU9004.3
G5335-PWRGD-1: PR276.1 PU16.1
G5335-PWRGD-2: PR9090.1 PU9004.1
G5335-SS-1: PC232.1 PU16.23
G5335-SS-2: PC9091.1 PU9004.23
G5335-TON-1: PR268.1 PU16.6
G5335-TON-2: PR9086.1 PU9004.6
G5335-VCC-1: PC234.1 PR104.2 PU16.21(VCC)
G5335-VCC-2: PC9075.1 PR9087.2 PU9004.21(VCC)
G5719LX1.5V: PL14.1 PU3003.3
G_MBCLK_R: C6605.1 R591.2 R25356.2 U32.4
G_MBDATA_R: C6604.1 R590.2 R25355.2 U32.6
GC6_FB_EN: Q16.2 R372.1 R394.1
GC6_FB_EN_N17: R372.2 U8.B2
GC6_FB_EN_Q: Q14.3 R25430.2 R25431.1 U1.CC29 U11.1
GC6FBEN_Q_EC: TP9021.1 U37.2
GPD7: R152.1 R157.2 U1.BV35
GPD9: TP6.1 U1.BT30
GPIO10_VREF: Q20.2 R398.2 U8.C5
GPP_B18: R120.1 R122.2 U1.CE29
GPP_B23: R89.1 R90.2 U1.CC34
GPP_F10: TP21.1 U1.CK17
GPP_F23: R153.1 R158.2 U1.CF17
GPP_H21: R144.1 U1.CF25
GPP_H23: TP20.1 U1.CM26
GPU_CHOKE_THERMAL: PR9025.1 R25502.1 U37.126
GPU_EVENT#: D4.1(CATHODE) R25482.2 U1.CC30
GPU_EVENT#_GPU: D4.2 R373.1 R25490.1
GPU_GPIO0: R370.2 U8.C6
GPU_GPIO2: R373.2 U8.D6
GPU_GPIO6: R376.2 U8.A4
GPU_GPIO21: R404.1 U8.C4
GPU_PEX_RST_HOLD#: R399.1 U8.D5
GPU_PWR_GD: PR9008.1 PR9079.2 R324.1
GPUT_CLK_L: Q13.4(S2) R365.1 U8.D9
GPUT_DATA_L: Q13.1 R362.1 U8.D8
GSPI1_MOSI: R124.2 U1.CA30
H_CPU_SVIDALRT#: R64.1 U1.AA3
H_CPU_SVIDCLK: PR7003.2 PR7015.1 R65.2 R66.2
H_CPU_SVIDDAT: PR7001.2 PR7019.1 R68.2
H_CPU_SVIDDAT_R: R67.2 R68.1 U1.AA2
H_PROCHOT#: C6618.2 PR22.1 PR7012.2 PU1.10 Q6509.3 R9.1 R23.1
H_VCCST_PWRGD: R54.2 U1.BJ2
H_VCCST_PWRGD_R: C9.2 D1.2 R52.1 R54.1
HDMI_EQ0: R746.1 R749.1 U23.8
HDMI_EQ1: R747.1 R748.1 U23.2
HDMI_HPD: Q6507.3 R1250.2 R25297.1 U23.21 VC2.1
HDMI_HPD_C: C616.1 CN37.19 R25297.2
HDMI_HPD_CON: R750.1 U1.CN6
HDMI_MB_HPD_R: Q6507.1(S) R750.2 R25294.1 U23.5
HDMI_SCLK: C614.1 CN37.15 D13089.2 Q41.3 R490.2 U23.19
HDMI_SDATA: C613.1 CN37.16 D13090.2 Q41.6 R491.2 U23.20
HOLD#: R107.2 R109.2 TP19.1 U2.7
HOOK3: C248.2 R221.1 R222.2 TP55.1
HP-L2: C589.2 R472.2 R474.1 R476.2 U20.32
HP-L3: C592.2 CN35.4 R472.1
HP-R2: C594.2 R473.2 R475.1 R477.2 U20.33
HP-R3: C593.2 CN35.2 R473.1
HP_JD#: CN35.13 R451.2
HWPG: D1.1(CATHODE) D51.2 D60.2 D61.2 D62.2 D64.2 D2016.2 R25312.1 U37.21
HWPG_1.5V: D61.1(CATHODE) PR284.1 PR6416.2
HWPG_1.8VS5: D62.1(CATHODE) PR9255.2 PR9256.1
HWPG_1.35VGFX: PR9088.2 PR9090.2 R25468.2
HWPG_1VS5: D64.1(CATHODE) PR275.2 PR276.2
HWPG_2.5V: D2016.1(CATHODE) PR186.2 PU14.1
HWPG_VDDR: D51.1(CATHODE) PR267.2 PR9265.1
I2CA_SCL: R326.1 U8.B7
I2CA_SDA: R25492.1 U8.A7
ICMNT: C6564.2 PC37.2 PR32.1 U37.67
ILIM_HI: R414.2 U14.16
ILIM_LO: R415.2 U14.15
IMON_CORE: PR7014.2 PU7000.1
IMON_GT: PC423.1 PR7004.2 PU7000.30
IMON_SA: PC7003.2 PR7005.2 PU7000.39
IMVP_PWRGD: PR7067.1 PR7068.2 Q85.2 R25359.2 U6504.2
IN_CLK: C849.1 R1291.1 U1.AE6
IN_CLK#: C847.1 R1290.1 U1.AE5
IN_CLK#_R: C1679.1 D13087.2 R1290.2
IN_CLK_R: C1681.1 D13088.2 R1291.2
IN_D0: C852.1 R1285.1 U1.AF5
IN_D0#: C853.1 R1284.1 U1.AF6
IN_D0#_R: C1685.1 D13081.2 R1284.2
IN_D0_R: C1684.1 D13082.2 R1285.2
IN_D1: C851.1 R1287.1 U1.AJ6
IN_D1#: C848.1 R1286.1 U1.AJ5
IN_D1#_R: C1680.1 D13083.2 R1286.2
IN_D1_R: C1683.1 D13084.2 R1287.2
IN_D2: C854.1 R1289.1 U1.AL6
IN_D2#: C850.1 R1288.1 U1.AL5
IN_D2#_R: C1682.1 D13085.2 R1288.2
IN_D2_R: C1686.1 D13086.2 R1289.2
INT_AMIC-VREFO: C564.1 R447.2 U20.27
INT_EDP_AUXN: C556.2 U1.AH4
INT_EDP_AUXN_C: C556.1 CN29.22 R25271.1
INT_EDP_AUXP: C557.2 U1.AH3
INT_EDP_AUXP_C: C557.1 CN29.23 R25270.1
INT_EDP_TXN0: C553.2 U1.AG4
INT_EDP_TXN0_C: C553.1 CN29.19
INT_EDP_TXN1: C555.2 U1.AG2
INT_EDP_TXN1_C: C555.1 CN29.16
INT_EDP_TXN2: C1675.2 U1.AJ4
INT_EDP_TXN2_C: C1675.1 CN29.13
INT_EDP_TXN3: C1678.2 U1.AJ2
INT_EDP_TXN3_C: C1678.1 CN29.10
INT_EDP_TXP0: C552.2 U1.AG3
INT_EDP_TXP0_C: C552.1 CN29.20
INT_EDP_TXP1: C554.2 U1.AG1
INT_EDP_TXP1_C: C554.1 CN29.17
INT_EDP_TXP2: C1676.2 U1.AJ3
INT_EDP_TXP2_C: C1676.1 CN29.14
INT_EDP_TXP3: C1677.2 U1.AJ1
INT_EDP_TXP3_C: C1677.1 CN29.11
INT_HDMICLK+_OUT: R702.1 U23.10
INT_HDMICLK-_OUT: R703.1 U23.9
INT_HDMITX0N_OUT: R697.1 U23.15
INT_HDMITX0P_OUT: R696.1 U23.16
INT_HDMITX1N_OUT: R699.1 U23.13
INT_HDMITX1P_OUT: R698.1 U23.14
INT_HDMITX2N_OUT: R701.1 U23.11
INT_HDMITX2P_OUT: R700.1 U23.12
INTRUDER#_R: R42.1 U1.BR35
ISEN1N_CORE: PC7025.2 PC7047.2 PR7074.2 PR7075.2 PU7000.7
ISEN1N_GT: PC7030.2 PC7097.2 PC7100.2 PR7097.2 PR7100.2 PR7101.2 PU7000.28
ISEN1N_SA: PC7029.2 PC7079.2 PC7099.2 PR7089.2 PR7092.2 PR7093.2 PU7000.41
ISEN1P_CORE: PC7047.1 PR7075.1 PR7076.2 PU7000.10
ISEN1P_GT: PC7097.1 PC7100.1 PR7098.2 PR7099.1 PU7000.29
ISEN1P_SA: PC7079.1 PC7099.1 PR7090.1 PR7091.2 PU7000.40
ISEN2N_CORE: PC7027.2 PC7065.2 PR7066.1 PR7083.2 PR7085.1
ISEN2P_CORE: PC7065.1 PR7065.2 PR7084.2 PR7085.2 PU7000.9
ISOLATEB: R509.1 R510.2 U24.20
JTAG_TCK: TP70.1 U8.AE5
JTAG_TCK_PCH: R17.2 TP50.1 U1.W6
JTAG_TDI: TP72.1 U8.AE6
JTAG_TDI_PCH: R3.1 R13.2 U1.U5
JTAG_TDO: TP73.1 U8.AF6
JTAG_TDO_PCH: R4.1 R14.2 U1.W5
JTAG_TMS: TP71.1 U8.AD6
JTAG_TMS_PCH: R5.1 R12.2 U1.P5
JTAG_TRST#: R396.1 U8.AG4
JTAGX_PCH: R7.1 R11.2 U1.P6
KB_BL_LED: Q31.2 U37.113
KL_NO_EC: PR9269.2 PR9271.2 U37.70
L_SPK+: R483.1 U20.42
L_SPK+_1: C604.1 CN36.4 R483.2
L_SPK-: R482.1 U20.43
L_SPK-_1: C603.1 CN36.3 R482.2
LAD0_R: CN17.58 R673.1
LAD1: CN17.66 R2662.1
LAD2: CN17.68 R2663.1
LAD3: CN17.70 R2664.1
LAN_AMBLED#: TP74.1 U24.27
LAN_LED1: TP75.1 U24.26
LAN_LED2: TP76.1 U24.25
LAN_MCTG0: R516.2 U25.24
LAN_MCTG1: R517.2 U25.21
LAN_MCTG2: R518.2 U25.18
LAN_MCTG3: R519.2 U25.15
LAN_WAKE#: R36.1 U1.BU32
LAN_XTAL1: C638.2 R511.1 Y4.1
LFRAME#_R: CN17.62 R675.1
LGATE1_CORE: PQ7000.8 PU7002.7
LGATE2_CORE: PQ7001.8 PU7001.7
LGATE_GT: PQ7004.8 PU7003.7
LGATE_SA: PQ7003.4 PU7004.7
LID#: C841.1 CN24.4 D3.1(CATHODE) D13091.2 HE1.1 R25315.2 R25370.2
LID#_C: C6572.1 D65.1 R25315.1 U37.118
LINE1-L: C589.1 U20.22
LINE1-R: C594.1 U20.21
LINE1-VREFO-L: R476.1 U20.31
LINE1-VREFO-R: R477.1 U20.30
LPC_LAD0: R673.2 U1.CA29 U37.10
LPC_LAD1: R2662.2 U1.BY29 U37.9
LPC_LAD2: R2663.2 U1.BY27 U37.8
LPC_LAD3: R2664.2 U1.BV27 U37.7
LPC_LFRAME#: R675.2 U1.CA28 U37.6
M_A_A0: JDIM1.144 U1.AC37
M_A_A1: JDIM1.133 U1.AC36
M_A_A2: JDIM1.132 U1.AC34
M_A_A3: JDIM1.131 U1.AC35
M_A_A4: JDIM1.128 U1.AA35
M_A_A5: JDIM1.126 U1.AB35
M_A_A6: JDIM1.127 U1.AA37
M_A_A7: JDIM1.122 U1.AA36
M_A_A8: JDIM1.125 U1.AB34
M_A_A9: JDIM1.121 U1.W36
M_A_A10: JDIM1.146 U1.Y31
M_A_A11: JDIM1.120 U1.W34
M_A_A12: JDIM1.119 U1.AA34
M_A_A13: JDIM1.158 U1.AC32
M_A_ACT#: JDIM1.114 U1.V35
M_A_ALERT#: JDIM1.116 U1.W37
M_A_BG#0: JDIM1.115 U1.V34
M_A_BG#1: JDIM1.113 U1.W35
M_A_BS#0: JDIM1.150 U1.W32
M_A_BS#1: JDIM1.145 U1.AB31
M_A_CAS#: JDIM1.156 U1.AB32
M_A_CB0: JDIM1.92 R233.2
M_A_CB1: JDIM1.91 R234.2
M_A_CB2: JDIM1.101 R235.2
M_A_CB3: JDIM1.105 R236.2
M_A_CB4: JDIM1.88 R237.2
M_A_CB5: JDIM1.87 R238.2
M_A_CB6: JDIM1.100 R239.2
M_A_CB7: JDIM1.104 R240.2
M_A_CKE0: JDIM1.109 U1.U36
M_A_CKE1: JDIM1.110 U1.U37
M_A_CLKN0: JDIM1.139 U1.V32
M_A_CLKN1: JDIM1.140 U1.T32
M_A_CLKP0: JDIM1.137 U1.V31
M_A_CLKP1: JDIM1.138 U1.T31
M_A_CS#0: JDIM1.149 U1.AE32
M_A_CS#1: JDIM1.157 U1.AF32
M_A_DIM0_ODT0: JDIM1.155 U1.AE31
M_A_DIM0_ODT1: JDIM1.161 U1.AF31
M_A_DQ0: JDIM1.3 U1.A26
M_A_DQ1: JDIM1.4 U1.D26
M_A_DQ2: JDIM1.16 U1.D28
M_A_DQ3: JDIM1.21 U1.C28
M_A_DQ4: JDIM1.7 U1.B26
M_A_DQ5: JDIM1.8 U1.C26
M_A_DQ6: JDIM1.20 U1.B28
M_A_DQ7: JDIM1.17 U1.A28
M_A_DQ8: JDIM1.25 U1.B30
M_A_DQ9: JDIM1.24 U1.D30
M_A_DQ10: JDIM1.41 U1.B33
M_A_DQ11: JDIM1.37 U1.D32
M_A_DQ12: JDIM1.29 U1.A30
M_A_DQ13: JDIM1.28 U1.C30
M_A_DQ14: JDIM1.42 U1.B32
M_A_DQ15: JDIM1.38 U1.C32
M_A_DQ16: JDIM1.46 U1.H37
M_A_DQ17: JDIM1.45 U1.H34
M_A_DQ18: JDIM1.62 U1.K34
M_A_DQ19: JDIM1.59 U1.K35
M_A_DQ20: JDIM1.50 U1.H36
M_A_DQ21: JDIM1.49 U1.H35
M_A_DQ22: JDIM1.58 U1.K36
M_A_DQ23: JDIM1.63 U1.K37
M_A_DQ24: JDIM1.67 U1.N36
M_A_DQ25: JDIM1.66 U1.N34
M_A_DQ26: JDIM1.84 U1.R37
M_A_DQ27: JDIM1.80 U1.R34
M_A_DQ28: JDIM1.71 U1.N37
M_A_DQ29: JDIM1.70 U1.N35
M_A_DQ30: JDIM1.79 U1.R36
M_A_DQ31: JDIM1.83 U1.R35
M_A_DQ32: JDIM1.173 U1.AN35
M_A_DQ33: JDIM1.174 U1.AN34
M_A_DQ34: JDIM1.186 U1.AR35
M_A_DQ35: JDIM1.183 U1.AR34
M_A_DQ36: JDIM1.170 U1.AN37
M_A_DQ37: JDIM1.169 U1.AN36
M_A_DQ38: JDIM1.182 U1.AR36
M_A_DQ39: JDIM1.187 U1.AR37
M_A_DQ40: JDIM1.190 U1.AU35
M_A_DQ41: JDIM1.194 U1.AU34
M_A_DQ42: JDIM1.208 U1.AW35
M_A_DQ43: JDIM1.203 U1.AW34
M_A_DQ44: JDIM1.191 U1.AU37
M_A_DQ45: JDIM1.195 U1.AU36
M_A_DQ46: JDIM1.204 U1.AW36
M_A_DQ47: JDIM1.207 U1.AW37
M_A_DQ48: JDIM1.215 U1.BA35
M_A_DQ49: JDIM1.212 U1.BA34
M_A_DQ50: JDIM1.225 U1.BC35
M_A_DQ51: JDIM1.224 U1.BC34
M_A_DQ52: JDIM1.211 U1.BA37
M_A_DQ53: JDIM1.216 U1.BA36
M_A_DQ54: JDIM1.228 U1.BC36
M_A_DQ55: JDIM1.229 U1.BC37
M_A_DQ56: JDIM1.233 U1.BE35
M_A_DQ57: JDIM1.246 U1.BE34
M_A_DQ58: JDIM1.232 U1.BG35
M_A_DQ59: JDIM1.236 U1.BG34
M_A_DQ60: JDIM1.250 U1.BE37
M_A_DQ61: JDIM1.237 U1.BE36
M_A_DQ62: JDIM1.249 U1.BG36
M_A_DQ63: JDIM1.245 U1.BG37
M_A_DQSN0: JDIM1.11 U1.C27
M_A_DQSN1: JDIM1.32 U1.D31
M_A_DQSN2: JDIM1.53 U1.J35
M_A_DQSN3: JDIM1.74 U1.P34
M_A_DQSN4: JDIM1.177 U1.AP35
M_A_DQSN5: JDIM1.198 U1.AV34
M_A_DQSN6: JDIM1.219 U1.BB35
M_A_DQSN7: JDIM1.240 U1.BF34
M_A_DQSN8: JDIM1.95 R232.1
M_A_DQSP0: JDIM1.13 U1.D27
M_A_DQSP1: JDIM1.34 U1.C31
M_A_DQSP2: JDIM1.55 U1.J34
M_A_DQSP3: JDIM1.76 U1.P35
M_A_DQSP4: JDIM1.179 U1.AP34
M_A_DQSP5: JDIM1.200 U1.AV35
M_A_DQSP6: JDIM1.221 U1.BB34
M_A_DQSP7: JDIM1.242 U1.BF35
M_A_DQSP8: JDIM1.97 R231.1
M_A_PARITY: JDIM1.143 U1.W31
M_A_RAS#: JDIM1.152 U1.Y32
M_A_WE#: JDIM1.151 U1.AC31
M_B1_ZQ0: R253.1 U4.F9(ZQ)
M_B2_ZQ0: R254.1 U5.F9(ZQ)
M_B3_ZQ0: R255.1 U7.F9(ZQ)
M_B4_ZQ0: R256.1 U6.F9(ZQ)
M_B_A0: R274.2 U1.AG36 U4.P3 U5.P3 U6.P3 U7.P3
M_B_A1: R275.2 U1.AG35 U4.P7 U5.P7 U6.P7 U7.P7
M_B_A2: R276.2 U1.AF34 U4.R3 U5.R3 U6.R3 U7.R3
M_B_A3: R277.2 U1.AG37 U4.N7 U5.N7 U6.N7 U7.N7
M_B_A4: R279.2 U1.AE35 U4.N3 U5.N3 U6.N3 U7.N3
M_B_A5: R278.2 U1.AF35 U4.P8 U5.P8 U6.P8 U7.P8
M_B_A6: R280.2 U1.AE37 U4.P2 U5.P2 U6.P2 U7.P2
M_B_A7: R281.2 U1.AC29 U4.R8 U5.R8 U6.R8 U7.R8
M_B_A8: R282.2 U1.AE36 U4.R2 U5.R2 U6.R2 U7.R2
M_B_A9: R283.2 U1.AB29 U4.R7 U5.R7 U6.R7 U7.R7
M_B_A10: R284.2 U1.AG34 U4.M3 U5.M3 U6.M3 U7.M3
M_B_A11: R285.2 U1.AC28 U4.T2 U5.T2 U6.T2 U7.T2
M_B_A12: R286.2 U1.AB28 U4.M7 U5.M7 U6.M7 U7.M7
M_B_A13: R287.2 U1.AK35 U4.T8 U5.T8 U6.T8 U7.T8
M_B_ACT#: R292.2 U1.W28 U4.L3 U5.L3 U6.L3 U7.L3
M_B_ALERT#: R271.1 U1.Y29 U4.P9 U5.P9 U6.P9 U7.P9
M_B_BG#0: R270.2 U1.W29 U4.M2 U5.M2 U6.M2 U7.M2
M_B_BG#1: R252.1 R294.2 U1.Y28
M_B_BG#1_R: R252.2 R257.2 U4.M9 U5.M9 U6.M9 U7.M9
M_B_BS#0: R268.2 U1.AJ37 U4.N2 U5.N2 U6.N2 U7.N2
M_B_BS#1: R269.2 U1.AJ36 U4.N8 U5.N8 U6.N8 U7.N8
M_B_CAS#: R289.2 U1.AK34 U4.M8 U5.M8 U6.M8 U7.M8
M_B_CKE0: R272.2 U1.T28 U4.K2 U5.K2 U6.K2 U7.K2
M_B_CLKN0: C310.1 R266.1 U1.AF28 U4.K8 U5.K8 U6.K8 U7.K8
M_B_CLKP0: C310.2 R265.1 U1.AF29 U4.K7 U5.K7 U6.K7 U7.K7
M_B_CS#0: R273.2 U1.AL37 U4.L7 U5.L7 U6.L7 U7.L7
M_B_DIM0_ODT0: R291.2 U1.AL36 U4.K3 U5.K3 U6.K3 U7.K3
M_B_DQ0: U1.J22 U6.A3
M_B_DQ1: U1.H25 U6.C8
M_B_DQ2: U1.G22 U6.C3
M_B_DQ3: U1.H22 U6.C2
M_B_DQ4: U1.F25 U6.B8
M_B_DQ5: U1.J25 U6.D7
M_B_DQ6: U1.G25 U6.C7
M_B_DQ7: U1.F22 U6.D3
M_B_DQ8: U1.D22 U6.H3
M_B_DQ9: U1.C22 U6.G2
M_B_DQ10: U1.C24 U6.H7
M_B_DQ11: U1.D24 U6.J7
M_B_DQ12: U1.A22 U6.J3
M_B_DQ13: U1.B22 U6.H2
M_B_DQ14: U1.A24 U6.F7
M_B_DQ15: U1.B24 U6.H8
M_B_DQ16: U1.G31 U7.G2
M_B_DQ17: U1.G32 U7.H3
M_B_DQ18: U1.H29 U7.H8
M_B_DQ19: U1.H28 U7.F7
M_B_DQ20: U1.G28 U7.J3
M_B_DQ21: U1.G29 U7.H2
M_B_DQ22: U1.H31 U7.H7
M_B_DQ23: U1.H32 U7.J7
M_B_DQ24: U1.L31 U7.D3
M_B_DQ25: U1.L32 U7.C3
M_B_DQ26: U1.N29 U7.C8
M_B_DQ27: U1.N28 U7.D7
M_B_DQ28: U1.L28 U7.C2
M_B_DQ29: U1.L29 U7.A3
M_B_DQ30: U1.N31 U7.B8
M_B_DQ31: U1.N32 U7.C7
M_B_DQ32: U1.AJ29 U5.C2
M_B_DQ33: U1.AJ30 U5.D3
M_B_DQ34: U1.AM32 U5.C7
M_B_DQ35: U1.AM31 U5.D7
M_B_DQ36: U1.AM30 U5.B8
M_B_DQ37: U1.AM29 U5.C8
M_B_DQ38: U1.AJ31 U5.A3
M_B_DQ39: U1.AJ32 U5.C3
M_B_DQ40: U1.AR31 U5.G2
M_B_DQ41: U1.AR32 U5.H2
M_B_DQ42: U1.AV30 U5.H8
M_B_DQ43: U1.AV29 U5.J7
M_B_DQ44: U1.AR30 U5.H3
M_B_DQ45: U1.AR29 U5.J3
M_B_DQ46: U1.AV32 U5.H7
M_B_DQ47: U1.AV31 U5.F7
M_B_DQ48: U1.BA32 U4.H2
M_B_DQ49: U1.BA31 U4.H3
M_B_DQ50: U1.BD31 U4.F7
M_B_DQ51: U1.BD32 U4.J7
M_B_DQ52: U1.BA30 U4.J3
M_B_DQ53: U1.BA29 U4.G2
M_B_DQ54: U1.BD29 U4.H8
M_B_DQ55: U1.BD30 U4.H7
M_B_DQ56: U1.BG31 U4.A3
M_B_DQ57: U1.BG32 U4.C3
M_B_DQ58: U1.BK32 U4.B8
M_B_DQ59: U1.BK31 U4.C8
M_B_DQ60: U1.BG29 U4.D3
M_B_DQ61: U1.BG30 U4.C2
M_B_DQ62: U1.BK30 U4.C7
M_B_DQ63: U1.BK29 U4.D7
M_B_DQSN0: U1.H24 U6.A7
M_B_DQSN1: U1.C23 U6.F3
M_B_DQSN2: U1.G30 U7.F3
M_B_DQSN3: U1.L30 U7.A7
M_B_DQSN4: U1.AL31 U5.A7
M_B_DQSN5: U1.AU31 U5.F3
M_B_DQSN6: U1.BC31 U4.F3
M_B_DQSN7: U1.BH31 U4.A7
M_B_DQSP0: U1.G24 U6.B7
M_B_DQSP1: U1.D23 U6.G3
M_B_DQSP2: U1.H30 U7.G3
M_B_DQSP3: U1.N30 U7.B7
M_B_DQSP4: U1.AL30 U5.B7
M_B_DQSP5: U1.AU30 U5.G3
M_B_DQSP6: U1.BC30 U4.G3
M_B_DQSP7: U1.BH30 U4.B7
M_B_PARITY: R293.2 U1.AE34 U4.T3 U5.T3 U6.T3 U7.T3
M_B_RAS#: R290.2 U1.AJ34 U4.L8 U5.L8 U6.L8 U7.L8
M_B_WE#: R288.2 U1.AJ35 U4.L2 U5.L2 U6.L2 U7.L2
MAIND: PC51.1 PQ6.3 PQ9.2 PR59.2 PR2060.2
MAINON: PQ16.2 PR120.1 PR265.2 PR6016.1 PR6028.1 PR6417.2 PR9268.2 PR9270.2 R890.1 U37.30
MAINON_ON_G: PQ6.2 PQ12.2 PQ14.2 PQ16.3 PQ19.2 PQ9050.2 PR116.2 PR118.1
MBCLK: PC11.1 PD4.1 PR12.2 PR17.1 R361.1 U37.110
MBDATA: PC10.1 PD3.1 PR13.2 PR19.1 R369.1 U37.111
MDI0+: U24.1 U25.9
MDI0+_1: CN8.1 U25.16
MDI0-: U24.2 U25.8
MDI0-_1: CN8.2 U25.17
MDI1+: U24.4 U25.12(TD4-)
MDI1+_1: CN8.3 U25.13
MDI1-: U24.5 U25.11
MDI1-_1: CN8.6 U25.14
MDI2+: U24.6 U25.2
MDI2+_1: CN8.4 U25.23
MDI2-: U24.7 U25.3
MDI2-_1: CN8.5 U25.22
MDI3+: U24.9 U25.6
MDI3+_1: CN8.7 U25.19
MDI3-: U24.10 U25.5
MDI3-_1: CN8.8 U25.20
ME_WR#: R118.1 U37.109
MEM_VREF_CTL_QA: Q20.3 R411.1 R25283.1
MIC2-VREFO: R468.1 R471.1 U20.29
MINICAR_PME#: CN17.55 Q33.1(S) R651.1
MODEM_CLKREQ: R679.2 U1.CH29 U36.1 U36.2
MODEM_CLKREQ_L: CN17.14 R678.1 U36.4
MX0: C725.1 CN18.10 CN19.10 U37.58
MX1: C727.1 CN18.9 CN19.9 U37.59
MX2: C723.1 CN18.8 CN19.8 U37.60
MX3: C722.1 CN18.7 CN19.7 U37.61
MX4: C720.1 CN18.6 CN19.6 U37.62
MX5: C726.1 CN18.5 CN19.5 U37.63
MX6: C721.1 CN18.4 CN19.4 U37.64
MX7: C724.1 CN18.3 CN19.3 U37.65
MY0: C719.1 CN18.26 CN19.26 U37.36
MY1: C716.1 CN18.25 CN19.25 U37.37
MY2: C717.1 CN18.24 CN19.24 U37.38
MY3: C708.1 CN18.23 CN19.23 U37.39
MY4: C718.1 CN18.22 CN19.22 U37.40
MY5: C707.1 CN18.21 CN19.21 U37.41
MY6: C706.1 CN18.20 CN19.20 U37.42
MY7: C709.1 CN18.19 CN19.19 U37.43
MY8: C711.1 CN18.18 CN19.18 U37.44
MY9: C713.1 CN18.17 CN19.17 U37.45
MY10: C714.1 CN18.16 CN19.16 U37.46
MY11: C715.1 CN18.15 CN19.15 U37.51
MY12: C728.1 CN18.14 CN19.14 U37.52
MY13: C729.1 CN18.13 CN19.13 U37.53
MY14: C730.1 CN18.12 CN19.12 U37.54
MY15: C731.1 CN18.11 CN19.11 U37.55
MY16: C732.1 CN18.28 CN19.28 U37.56
MY17: C733.1 CN18.27 CN19.27 U37.57
N12E_SCL: R367.1 U8.C9
N12E_SDA: R368.1 U8.C8
NBSWON#: C6615.2 CN19.1 D34.2 R720.2 R25314.1 SW1.1 SW1.2 U37.107
NGFF_SATA_DET: R134.1 R653.1 U1.CP10
NV_PLLVDD: C457.2 C458.2 L7.2 U8.L6
ODD_PRSNT#: C780.1 R640.2 R25475.2 U1.CP14
ODD_PRSNT#_C: C779.1 CN15.8 R640.1 R641.1
PBA_FP_PWREN#: R609.1 U37.76
PBA_PWR: C749.2 Q32.1(S) R608.1 R25295.2
PBA_PWR_C: CN14.8 R614.2
PBA_PWR_R: C752.2 C753.2 Q32.3 R608.2 R614.1
PCBEEP_EC: D6543.2 U37.34
PCBEEP_EC_C: C843.2 C844.2 C846.2 R734.2 R25371.1
PCH_AZ_CODEC_BITCLK: C587.2 R187.1 U20.6
PCH_AZ_CODEC_RST#: C216.2 Q21.1(S) R194.1 R738.2
PCH_AZ_CODEC_SDIN0: R191.1 U20.8
PCH_AZ_CODEC_SDOUT: R25374.1 U20.5
PCH_AZ_CODEC_SYNC: R188.1 U20.10
PCH_BLON_C: Q6521.5 R440.2 R25365.2 R25366.2 R25369.1
PCH_BLON_EC: R25366.1 U37.88
PCH_DISP_ON: R445.2 U1.CG11
PCH_DPST_PWM: C2.2 R443.1 U1.CH11
PCH_LVDS_BLON: C1.2 R25365.1 U1.CK11
PCH_OPI_RCOMP: R18.2 U1.BW25
PCH_PWROK: R25357.2 U37.78
PCH_PWROK_R: R25357.1 R25501.1 U1.BP31
PCH_SLP_S0_N: R38.1 R592.1 U1.BJ37
PCH_SPI1_CLK: R88.2 R111.2 R596.1 U1.CH37
PCH_SPI1_CLK_R: C191.1 R111.1 TP15.1 U2.6 U37.105
PCH_SPI1_SI: R113.2 R221.2 R597.1 U1.CF36
PCH_SPI1_SI_R: R113.1 R25303.1 TP16.1 U2.5 U37.102
PCH_SPI1_SO: R108.2 R583.1 R598.1 U1.CF37
PCH_SPI1_SO_R: R108.1 R25316.1 TP17.1 U2.2 U37.103
PCH_SPI_CS0#: R106.2 U1.CG36
PCH_SPI_CS0#_R: R106.1 TP14.1 U2.1 U37.101
