# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VIN_BLIGHT:
  vias: v1(63.74,105.93)
AVDD2: length 6.7
  BOTTOM w0.203: L28.2 210.01,34.1 208.87,34.1 208.4,33.63 U20.40
  BOTTOM w0.508: L28.2 210.16,36.93 v1(210.42,37.2) 210.42,37.65 C845.1
DVDD_IO: length 2.5
  BOTTOM w0.203: U20.9 203.66,28.7 v2(203.53,28.57) 202.89,27.93 202.65,27.93 C584.1
  vias: v1(202.93,28.74)
GND: length 2070.3
  TOP w0.102: 103.69,26.74 103.69,27.04 104.84,28.18 104.84,28.56 104.46,28.94 103.31,28.94 101.92,30.34 101.92,30.82 100.11,32.63 99.5,32.63 98.36,33.77 v2(98.36,34.16) 97.85,33.64 97.6,33.64 96.71,34.53 96.71,35.55 96.97,35.81 R148.1 ; 103.69,26.74 v2(102.72,26.74) ; 103.69,26.74 103.95,26.49 104.44,26.49 104.9,26.95 104.9,27.23 105.73,28.05 105.73,28.94 105.09,29.58 103.57,29.58 102.93,30.21 102.93,30.82 v1(102.8,30.95) 102.8,31.1 100.9,33.01 100.9,33.44 99.81,34.53 99.25,34.53 98.99,34.78 98.99,35.35 C204.1 ; v1(53.1,124.83) 53.1,125.06 52.73,125.42 PC293.2
  TOP w0.152: U37.91 199.68,26.18 200.13,26.63 C6565.2
  TOP w0.203: v2(97.01,38.52) 97.01,38.8 96.81,39 R138.2 ; v2(89.6,33.34) 89.6,33.36 89.1,33.86 R125.1 ; C246.1 63.91,23.54 63.16,24.29 v1(63.16,24.4) ; C278.2 55.94,32.73 v1(56.35,33.13) ; PU6002.11 20.2,27.42 20.04,27.25 19.48,27.25 PC6057.2 ; v2(93.03,53.8) 92.65,53.43 C18.1 ; C1189.2 179.64,24.47 C1190.2 179.87,24.44 180.2,24.11 v2(180.25,24.11) ; 52.41,68.67 v1(52.41,68.68) 52.41,68.92 51.88,69.46 C249.1 ; C1214.2 45.81,26.5 45.91,26.4 v1(45.91,26.28) ; C6612.1 93.86,38.11 v2(93.79,38.04) ; C236.1 84.14,29.91 v2(84.11,29.88) ; C744.2 121.83,18.4 v2(121.65,18.22) ; C744.2 C741.2 ; C744.2 121.85,19.21 U33.23 ; C189.1 157.2,31.99 156.98,32.21 v2(156.98,32.96) ; R24.1 102.78,73.95 103.04,73.7 v2(103.06,73.7) ; v2(89.95,37.6) 89.95,36.53 R147.2 ; C16.1 94.21,56.48 v2(94.32,56.59) ; v2(82.54,62.47) 82.95,62.06 C78.1 ; R25394.1 65.35,25.63 65.48,25.5 v1(65.76,25.5) 65.76,25.68 66.07,26 66.08,26 C240.1 66.23,26.86 C239.1 ; C190.2 163.87,34.1 v2(164.2,34.1) ; PU9002.11 22.54,95.49 v1(22.67,95.62) ; C508.2 16.7,45.71 R414.1 ; v2(207.05,14.13) 206.97,14.13 206.59,14.51 R1234.1 ; U37.104 194.45,31 v2(194.45,31) ; U17.11 18.93,34.58 U17.3 ; C264.2 51.56,53.58 v1(51.62,53.52) ; v2(95.9,56.91) 95.59,57.21 C37.1 ; v1(185.76,33.13) 185.76,33.01 186.17,32.6 186.95,32.6 C6574.2 ; U37.1 184.11,28.18 184.25,28.04 v2(184.66,28.04) ; R25.1 104.99,70.19 104.81,70.01 v1(104.58,70.01) 104.48,70.12 R17.1 ; R82.2 104.38,68.11 103.83,67.56 103.83,67.46 103.26,66.89 v2(103.14,66.89) ; C261.2 50.63,31.26 C3.1 ; C1211.2 50.28,25.91 v2(50.49,25.7) 50.49,25.44 50.35,25.31 C1217.2 ; C222.1 100.11,35.9 100.39,36.18 v2(100.39,36.49) ; PR9034.2 77.99,111.06 v1(78.29,111.37) ; U16.8 18.04,55.43 v1(17.59,54.98) 17.93,54.63 U16.9 ; R497.1 R499.1 206.16,12.56 206.11,12.51 v2(205.65,12.51) ; v2(202.42,17.61) 202.4,17.59 202.4,17.41 202.22,17.23 R25311.2 ; v2(82.26,46.89) 82.26,46.85 82.2,46.79 C6.2 ; C6573.2 184.57,31.36 184.47,31.25 v2(184.39,31.25) 184.31,31.25 184.14,31.43 C6563.2 ; v1(216.47,15.48) 216.37,15.48 216.09,15.76 215.58,15.76 215.2,16.14 C6598.2 C6599.2 213.62,16.14 213.4,16.37 U42.18 ; R122.1 76.31,22.92 76.11,22.71 75.78,22.71 75.61,22.54 R146.1 ; v1(98.06,31.51) 97.62,31.51 97.6,31.48 C224.1 ; R25303.2 R25316.2 194.24,32.85 v2(194.07,33.03) ; v1(53.91,21.68) 53.91,20.89 53.94,20.86 C6603.2 ; C6606.1 55.76,27.19 v2(55.59,27.01) ; v1(37.55,26.96) 37.32,27.19 PC561.2 ; C25.1 95.21,58.21 v2(95.26,58.25) ; PU6001.15 PU6001.11 ; C227.1 99.93,29.63 v2(100.47,29.63) 100.47,29.88 99.35,31 C6613.1 ; v2(79.94,48.35) 79.94,48.31 79.46,47.82 R74.2 ; R25481.2 92.75,33.74 v2(92.45,34.03) 92.37,34.12 R25433.2 ; R25320.2 181.72,29.7 181.98,29.45 v2(181.98,29.15) ; R1236.1 206.59,18.15 v2(206.79,18.35) 206.59,18.55 R506.1 ; C24.1 82.06,54.75 v2(82.54,54.27) 81.89,53.61 C47.2 ; C6575.2 191.4,33.08 191.07,33.41 v2(191.07,33.97) ; v2(92.87,57.46) 92.88,57.47 C17.1 ; PR10.2 99.02,20.21 v2(98.99,20.18) ; U37.49 191.25,13.17 ; C87.1 76.5,55.84 v2(76.4,55.75) ; v2(200.8,26.27) 200.8,26.27 200.44,26.63 C6565.2 ; R137.2 97.24,37.4 97.8,37.96 v2(98.06,37.96) ; C36.1 93.82,55.03 94.35,55.56 v2(94.35,55.71) ; C742.2 131.89,22.94 ; C95.1 77.59,51.55 v2(78.07,51.08) ; C6600.2 208.72,12.13 C6602.2 208.72,13.19 v1(208.98,13.45) ; U17.9 17.55,34.18 v1(17.14,34.59) 17.53,34.98 U17.8 ; PC9094.2 22.65,23.17 22.77,23.05 v1(22.77,22.67) ; v2(178.27,16.42) 178.27,16.85 178.72,17.31 180.2,17.31 180.66,17.77 C6577.2 C6578.2 ; C219.1 98.34,36.82 v2(97.87,36.34) ; v1(67.3,119.72) 66.81,119.72 66.79,119.7 PU26.26 ; R654.1 22.06,10.75 22.03,10.78 v1(22.03,10.88) ; PU26.28 66.79,120.5 ; U37.27 182.32,17.78 181.93,17.39 180.84,17.39 180.43,16.98 179.19,16.98 178.94,16.72 178.94,16.5 v2(178.85,16.42) ; R148.1 97.28,35.75 v2(97.88,35.75) ; v1(67.83,42.02) 66.28,40.47 R124.1 ; D13089.1 16.32,82.94 v2(16.44,82.82) 16.44,82.51 16.22,82.28 D13090.1 ; v1(107.07,32.5) 107,32.43 R183.1 ; U16.3 v1(20.86,55.03) ; v2(80.73,45.57) 81.19,45.11 R44.1 ; v1(13.65,86.98) R1250.1 ; v2(205.6,17.18) 206.03,16.75 R504.1 ; R890.2 180.1,16.09 181.39,16.09 181.71,16.41 v2(181.71,16.42) ; v2(77.48,65.71) 77.4,65.79 C76.1 ; v2(199.32,11.72) 199.33,11.71 C6568.1 ; C237.1 88.65,33.7 v2(88.41,33.95) ; v2(206.01,15.71) 206.11,15.61 R1235.1 ; v1(216.44,16.14) C6601.2 ; R16.2 77.69,47 v2(77.25,47.43)
  TOP w0.254: v2(67.5,125.59) 67.5,125.36 67.89,124.97 PC283.2 ; U5.N9 37.07,51.03 v1(37.07,51.01) ; v1(37.07,85.74) 37.07,85.76 U6.N9 ; PR253.1 68.17,121.18 67.83,120.84 67.32,120.84 67.22,120.74 v1(67.09,120.74) 67.03,120.74 66.79,120.5 ; v1(43.27,15.07) 43.29,15.1 43.29,15.39 PR6024.2 ; v2(97.88,35.75) 97.85,35.77 97.85,35.78 97.88,35.8 98.06,35.8 98.06,35.81 C204.1 ; v2(125.56,25.11) 125.56,24.52 125.22,24.18 124.46,24.18 123.94,23.66 U33.16 ; U35.3 147.12,25.23 R677.2 147.66,24.68 147.66,24.26 v2(147.67,24.24) 147.66,24.23 147.66,23.85 R678.2 ; v2(135.32,34.99) 135.32,35.19 134.99,35.52 133.56,35.52 133.16,35.93 PR230.2 ; PC7023.2 144.46,56.13 v1(144.46,57.14) 144.46,57.69 PC7004.2 ; v2(106.36,98.84) 106.36,98.71 C380.1 ; v1(64.17,125.59) 64.17,125.14 PC276.2 ; v1(48.19,103.49) 48.25,103.44 49.54,103.44 49.98,103.88 R510.1 ; U7.N9 37.07,72.46 v1(37.07,72.44) ; v2(189.8,10.98) 189.8,11.21 189.9,11.31 189.9,11.82 191.25,13.17 ; v1(210.78,19.19) 210.78,19.16 210.88,19.06 U42.3 ; v2(108.39,100.15) 108.68,100.44 C443.1 ; v2(147.64,29.07) 147.64,29.2 147.26,29.57 R676.2 ; v2(107.77,99.22) 107.77,98.67 C449.1 ; v1(52.28,57.77) 52.28,57.54 52,57.26 51.37,57.26 51.12,57.52 EC6.1 ; U23.17 18.69,75.92 v1(18.45,76.16) ; C455.1 105.97,97.17 v2(105.45,96.65) ; v2(201.82,29.09) 201.97,28.94 201.97,28.54 201.4,27.98 C2607.2 ; v1(52.31,55.18) 52.31,54.93 52.65,54.59 R230.2 ; v1(23.18,46.39) 23.56,46.77 R416.2 ; v2(166.08,23.89) 166.19,23.89 166.33,23.75 166.38,23.75 PC6229.1 ; v1(36.76,37.58) 36.55,37.8 36.55,38.16 U4.N9 ; v1(210.88,13.45) U42.13
  TOP w0.305: U32.13 57.74,25.1 57.77,25.13 57.77,25.82 v1(57.97,26.02) 58.24,25.76 U32.12 ; U5.G8 v1(41.87,52.63) ; v1(53.91,21.68) 54.13,21.46 U32.16 ; v2(61.53,17.05) 61.89,17.41 61.89,17.84 59.74,19.99 U32.5 ; Q6521.4 57.23,102.71 57.69,102.25 57.69,101.61 58.05,101.26 v2(58.46,101.26) ; v1(53.27,21.7) 53.27,21.96 53.64,22.33 C6608.2 54.3,22.33 54.68,21.96 U32.15 ; C429.1 99.81,110.65 v2(99.65,110.81) ; v1(13.04,16.24) 12.13,16.24 12,16.12 RV3.3 ; D33.2 148.85,16.6 148.14,16.6 147.09,17.65 U36.3 ; v1(55.33,100.52) 55.33,100.72 55.93,101.32 Q6521.1 55.1,101.67 54.8,101.98 C6616.1 ; v2(105.53,107.23) 105.99,107.69 C428.1 ; v1(75.53,23.96) 75.53,23.61 76.02,23.12 R122.1 ; C698.2 74.66,19.42 v2(75.02,19.77) ; U14.14 17.31,48.88 16.79,49.4 R415.1 ; U4.F1 v1(42.67,45.08) ; v2(112.11,109.11) 111.23,109.11 C366.2 ; v2(103.48,105.23) 103.76,105.51 C351.1 ; v2(111.26,111.61) 111.26,111.6 C354.2 ; v1(9.84,16.12) RV3.8 ; U4.K9 v1(38.67,37.88) ; v1(59.24,26.05) U32.10
  TOP w0.33: U5.H9 40.79,51.31 40.79,50.73 40.4,50.33
  TOP w0.356: v2(108.82,102.22) 109.09,102.48 C353.1 ; C408.1 102.07,105.9 v2(102.42,106.25) ; U6.T1 33.62,93.2 v1(33.44,93.2) ; v2(128.21,86.21) 128.08,86.34 C483.1 ; U7.G8 v1(41.07,73.26) ; C365.1 104.07,101.8 v2(103.57,101.29) ; U7.A2 v1(46.67,78.06) ; v2(108.82,104.23) 108.54,104.52 C357.1 ; U5.H1 v1(41.07,57.43) ; C421.1 105.01,101.96 v2(104.63,102.35) ; U7.E8 v1(42.67,74.06) ; C369.1 105.99,101.02 v2(105.57,101.43) ; C410.1 107.89,107.61 v2(107.4,107.12) ; U4.E1 v1(43.47,45.08) ; U4.C9 44.27,37.88 v1(44.27,37.88) ; U5.E3 v1(43.47,56.63) ; v2(101.23,101.23) 101.5,100.96 C406.1 ; C477.1 128.2,105.42 v2(128.21,105.41) ; U4.H1 41.22,45.23 41.72,45.23 v1(41.87,45.08) ; v1(45.87,44.28) 46.27,43.88 U4.A2 ; U4.B2 45.47,43.88 v1(45.07,44.28) ; U7.H1 v1(41.07,78.86) ; Q6519.1 20.57,14.04 v1(20.23,13.7) ; v2(138.61,113.41) 138.5,113.3 C498.1 ; U6.K1 39.43,92.92 39.43,93 v1(39.46,93.03) ; U5.F1 v1(42.67,57.43) U5.E1 ; v1(36.16,59.02) 36.29,59.02 36.67,58.63 U5.N1 ; U7.E1 43.39,79.58 v1(43.39,80.38) ; U7.H9 v1(41.07,72.46) ; v1(136.21,101.58) Q20.1 ; v2(135.41,109.46) 134.93,109.46 C482.1 ; C496.1 131.3,87.12 v2(131.41,87.01) ; v1(30.54,45.38) 30.54,45.22 31.63,44.13 33.72,44.13 U4.T1 ; U6.E8 v1(42.67,87.36) ; v2(106.36,104.25) 106.62,104.52 C418.1 107,104.54 C374.1 ; v1(46.54,75.07) 46.85,74.76 46.85,74.24 U7.A8 ; Q6519.4 21.87,16.99 v1(21.95,17.07) ; v1(46.8,37.91) 46.8,38.55 U4.A8 ; C439.1 109.89,104.79 v2(109.41,105.27) 109.89,105.75 C448.1 ; v2(106.36,102.22) 106.62,101.96 C412.1 ; v2(131.41,112.61) 131.74,112.61 C480.1 ; v2(139.41,86.21) 139.26,86.35 C478.1 ; C375.1 102.66,99.05 v2(102.17,99.05) 101.53,99.05 C378.2 ; U7.K1 39.37,79.55 39.41,79.55 40.84,80.99 v1(41.72,80.99) ; C501.2 135.99,90.21 v2(135.41,90.21) ; C372.1 106.99,100.41 v2(106.52,99.95) ; U5.A2 v1(46.67,56.63) ; U5.K1 39.37,58.13 39.41,58.13 40.12,58.84 41.01,58.84 41.36,59.19 v1(41.36,59.22) ; v2(100.44,101.61) 100.44,102.32 C460.1 ; v2(102.58,100.28) 103.05,100.75 C407.1 ; v2(103.48,107.18) 102.68,107.99 C402.2 ; U6.H1 v1(41.07,92.16) ; v1(44.27,52.63) U5.D8 U5.E8 ; U4.K1 39.12,44.68 39.64,45.2 40.15,45.2 v1(40.27,45.08) ; v1(45.87,51.83) 46.27,52.23 U5.A8 ; v2(102.4,102.35) 102.01,101.96 C373.1 ; U4.E3 v1(43.47,42.68) ; v1(41.07,37.88) U4.H9 ; U6.E1 43.1,92.56 43.72,93.18 43.72,93.2 v1(43.72,93.2) ; U6.D8 v1(44.27,86.56) ; U7.C9 v1(45.07,72.46) ; v2(133.81,115.81) 134.44,115.18 C481.1 ; U6.K9 39.07,85.64 39.59,85.12 v1(39.99,85.12) ; U7.D2 v1(44.27,78.06) ; v2(101.42,105.13) 101.42,104.94 C409.1 ; C411.1 105.02,104.52 v2(104.63,104.12) 104.23,104.52 C430.1 ; U7.F1 42.78,79.77 v1(42.78,79.84) ; U6.E3 v1(42.67,91.36) ; U7.K9 v1(39.47,72.46) ; C471.2 142.04,117.22 141.57,116.75 v1(141.57,116.67) ; v1(29.93,60.46) 29.8,60.33 C307.2 29.8,59.53 30.47,58.86 30.82,58.86 31.69,57.99 34.11,57.99 U5.T1 ; v1(36.67,93.71) U6.N1 ; v1(46.67,86.56) U6.A8 v1(45.87,87.36) ; C491.1 140.28,94.14 v2(140.21,94.21) ; v2(108.39,107.3) 108.52,107.3 108.88,106.95 C445.1 ; U4.E8 v1(42.67,39.48) ; v1(42.76,93.05) U6.F1 ; v2(126.63,105.42) 126.21,105 C475.2 ; U4.N1 36.21,45.14 36.21,46.06 36.16,46.11 36.16,46.16 36.13,46.19 v1(36.13,46.21) ; U6.B2 v1(45.87,91.36) ; 40.4,50.33 v1(40.27,50.33) 40.17,50.33 U5.K9 ; U7.T1 34.11,79.42 33.36,79.42 33.34,79.39 30.76,79.39 C315.2 ; U7.B2 v1(45.87,78.06) ; U7.N1 36.67,80.06 36.29,80.44 v1(36.16,80.44) ; v2(108.8,106.21) 108.8,106.06 108.26,105.51 C352.1 ; C493.1 133.61,117.21 v2(133.01,116.61) ; v2(109.49,104.28) 109.92,103.85 C444.1 ; v2(132.21,116.61) 131.6,117.22 C492.1 ; v2(105.78,105.24) 105.51,105.51 C424.1 ; C495.1 130.78,108.47 131.24,108.47 v2(131.41,108.64) ; v2(89.75,29.4) 89.75,29.2 89.13,28.58 C243.1 ; U6.C9 v1(45.07,85.76) ; U4.D8 v1(44.27,38.68) ; C459.1 100.36,103.46 v1(100.36,103.97) ; U6.G8 v1(41.07,86.56) ; U4.G8 v1(41.07,38.68) ; U5.D2 v1(44.27,56.63) ; U4.D2 v1(44.27,44.28) ; U6.H9 v1(41.07,85.76) ; U7.E3 v1(43.47,78.06) ; v2(107.52,101.42) 108.06,101.96 C367.1 ; U7.D8 v1(44.27,73.26) ; U5.C9 v1(45.07,51.03) ; U6.A2 v1(46.67,91.36) ; U6.D2 v1(43.47,92.16) ; U5.B2 v1(45.87,56.63)
  TOP w0.381: C6604.2 62.29,18.78 62.76,18.31 63.3,18.31 v2(63.66,18.68) ; C550.2 62.5,101.17 v2(62.5,101.78) ; C545.2 63.69,99.94 64.54,100.78 v2(64.54,101.08) ; PQ17.1 135.52,34.78 v2(135.32,34.99) ; v1(144.3,53.17) 143.94,52.82 PC7007.2 ; C368.1 100.65,104.25 v1(100.36,103.97) ; v2(95.89,39.89) 95.83,39.95 R136.2 ; C453.1 109.78,98.42 109.24,98.96 109.24,99.2 C447.1 109.02,99.52 v2(108.39,100.15) ; v2(50.81,108.32) 50.26,107.77 C632.2 50.26,106.82 C633.2 ; R25495.2 206.65,27.2 207.19,26.66 v2(207.33,26.66) ; v2(76.52,48.34) 76.81,48.63 R30.2 ; C376.2 100.39,95.96 100.47,95.88 v2(100.47,95.85) ; v2(100.26,99.68) 100.26,99.26 C371.2 ; v1(132.41,77.12) PQ9086.1 ; v2(140.21,116.61) 140.21,116.84 140.59,117.22 C485.2 ; C267.2 57.97,53.44 57.59,53.07 56.75,53.07 v1(56.2,53.63) ; R158.1 97.94,29.87 v2(98.41,29.4) ; PC9014.1 71.42,106.28 v1(71.28,106.41) ; v2(97.12,105.8) 97.12,106.44 97.97,107.29 C431.1 ; Q22.1 53.03,25.1 53.3,25.1 53.33,25.12 v2(53.35,25.12) ; R463.2 211.95,37.83 v1(212.2,38.09) ; v1(94.21,61.16) 94.2,61.17 C162.1 ; v2(112.11,103.31) 111.45,102.65 C454.1 ; PC6037.2 22.8,31.35 C523.1 v1(24.32,31.35) ; PC6043.2 21.39,31.01 v1(20.81,31.58) ; v1(89.44,96.1) 89.44,96.1 89.44,96.07 89.13,95.76 88.41,95.76 Q14.1 ; v2(110.41,112.43) 110.25,112.27 C399.2 ; R228.2 47.92,33.26 v1(47.38,32.73) 47.09,32.44 R229.2 ; v2(68.46,111.52) 68.46,111.39 68.84,111.02 PC9029.2 PC9027.2 ; v1(26.3,25.61) 26.25,25.67 PC6036.2 PC6052.2 v1(26.35,26.63) ; PC6053.2 v1(26.25,28.56) ; C386.1 103.18,99.42 102.78,99.02 C375.1 ; PC7087.1 93.86,79.64 v2(94.09,79.87) ; R267.2 56.2,99.17 56.45,99.43 v2(56.45,99.76) ; PC6041.2 20.16,22.28 v1(20.13,22.31) ; v2(138.61,109.41) 138.67,109.47 C484.2 ; v2(80.67,62.92) 80.86,62.92 81.55,62.24 C81.1 ; 182.55,29.15 182.53,29.12 182.03,29.12 182,29.15 v2(181.98,29.15) ; 182.55,29.15 C6572.2 ; 182.55,29.15 182.58,29.17 182.58,29.56 182.55,29.59 D65.2 ; v1(18.45,76.16) 17.71,75.42 C618.1 ; PC6013.2 158.06,33.56 158.31,33.56 158.79,33.09 v2(158.79,32.96) ; v2(76.41,53.21) 76.64,53.44 C77.1 ; C699.2 71.11,21.7 71.66,22.26 v2(71.66,22.52) ; R589.1 64.08,21.87 v2(64.3,21.65) ; v1(57.09,77.21) 57.09,77.2 C276.2 ; v2(97.97,100.83) C394.2 ; v1(79.26,25.26) 79.26,25.83 R25403.2 ; R317.2 118.81,104.63 118.17,105.27 116.68,105.27 116.01,104.6 v2(116.01,104.13) ; C494.1 131.41,91.8 v2(131.41,91.81) ; v1(211.59,39.46) 211.59,39.31 211.14,38.85 R469.2 C586.2 ; v1(133.08,76.31) 133.08,76.49 133.54,76.95 PR9101.2 ; v2(67.8,112.74) 67.91,112.84 PR9031.1 ; PC9076.2 139.26,70.45 v1(140.17,71.36) ; v1(20.38,62.34) 20.52,62.21 C613.2 ; v1(19.62,32.04) 19.04,32.04 PC6042.2 ; C511.1 16.44,51.7 v1(15.84,51.7) ; C1210.2 202.2,23.89 C1208.1 202.83,23.94 v2(202.86,23.96) ; v1(135.7,79.11) 135.7,77.86 PQ9085.1 ; R25369.2 59.38,109.72 59.62,109.97 v1(59.62,109.99) ; v2(100.14,100.32) 100.02,100.2 C398.2 C401.2 ; R398.1 98.32,97.02 v2(97.98,96.68) ; v2(94.05,81.68) 93.95,81.78 C140.1 ; C457.1 v1(90.87,106.03) ; C6584.1 20.11,18.08 19.72,17.69 v1(19.72,17.36) ; v2(60.74,26.15) 60.74,25.52 61.17,25.1 R25393.1 ; R59.1 62.7,27.67 62.67,27.7 v1(62.6,27.7) ; v1(52.26,46.47) 52.26,47.09 C252.2 ; C6562.1 177.68,22.71 v2(177.89,22.5) 177.9,22.5 178,22.6 C6571.2 ; C634.2 C636.2 42.98,110.49 42.93,110.54 42.93,110.98 43.24,111.29 v1(43.24,111.37) ; C82.1 82.55,59.74 82.54,59.73 v2(82.53,59.73) 82.52,59.74 C83.1 ; R25499.1 204.24,21.09 v2(203.13,21.09) 202.61,21.09 L11.2 ; v1(20.72,10.75) D6542.2 ; v2(180.77,19.15) 180.77,19.18 180.88,19.28 C2374.2 ; C518.1 v1(23.71,55.24) ; v2(132.79,34) 132.86,34.06 133.54,34.06 PR40.2 ; PC236.1 102.73,40.81 v1(102.73,40.04) 102.73,39.6 102.56,39.43 C231.1 ; C6605.2 59.13,16.41 v2(58.74,16.8) ; PC6023.2 146.27,36.77 v2(146.01,36.51) ; C8.2 R46.2 65.34,43.67 v1(65.59,43.42) ; v2(203.39,26.25) 203.31,26.33 203.31,26.87 203.55,27.1 C585.2 ; Q16.1 88.52,93.45 89.09,94.02 v1(89.22,94.02) ; v1(137.58,78.29) 137.63,78.24 137.7,78.24 138.22,77.73 PC9085.2 ; v2(141.01,29.63) 141.01,30.5 PR6012.2 ; v1(67.63,116.19) 67.64,116.21 PC9004.2 ; C419.2 103.98,108.63 v2(103.69,108.34) ; PC7069.1 139.88,38.9 v1(140.14,38.9) ; v2(82.26,46.89) 82.46,47.09 82.46,47.37 R29.1 82.65,48.04 R28.2 ; C362.2 109.08,108.69 v2(109.58,108.19) ; v1(123.25,94.6) 123.25,94.1 C440.1 ; C506.2 v1(132.26,103.75) R25282.1 ; v2(87.82,32.37) 87.82,31.84 88.06,31.6 C241.1 ; C422.1 98.05,105.8 v2(98.74,105.8) 99.23,106.29 C432.1 ; C461.2 v1(90.92,107.56) ; R479.2 v1(211.67,29.3) ; EC3.1 64.57,46.99 64.03,46.99 v1(63.92,46.87) ; C740.2 130.37,23 v1(129.65,23) ; v1(56.41,109.56) Q6522.1 ; C6580.1 197.12,33.23 196.66,33.69 196.66,36.23 196.94,36.51 v2(197.04,36.51) ; PC6051.2 v1(26.25,27.6) ; v1(55.69,109.49) 55.69,109.36 54.83,108.5 54.83,108.12 R442.2 C558.2 ; v2(91.84,79.64) 92.14,79.93 C157.1 ; C164.1 92.47,60.63 v2(92.87,60.23) ; PC6007.1 144.91,30.83 144.91,29.74 143.49,28.32 PQ6000.1 142.83,28.32 142.51,28 v2(142.51,27.77) ; v2(178.51,20.38) 178.51,20.07 178.27,19.82 177.78,19.82 R25298.1 ; C479.1 131.61,90.4 v2(131.41,90.21) ; v2(106.52,99.95) 106.91,99.56 C450.1 ; v1(28,83.81) 28.45,83.36 C334.2 C341.2 ; v2(99.2,42.4) 99.21,42.4 C232.1 ; v2(99.83,101.61) 99.59,101.61 C458.1 ; R464.2 211.14,35.46 211.57,35.04 v1(211.72,35.04) ; C596.2 206.93,30.47 206.55,30.85 v1(206.44,30.85) ; PC7009.2 143.75,51.29 143.5,51.04 v1(143.27,51.04) ; v2(201.82,29.09) 202.29,29.56 ; PC7068.2 141.28,38.48 v1(140.78,38.98) ; v1(89.33,92.09) 89.51,92.09 90.13,92.71 R394.2 ; v2(68.46,33.51) 68.44,33.51 68.27,33.35 67.82,33.35 66.46,31.98 R25375.1 ; C614.2 22.3,64.76 v1(21.78,64.25) ; v2(150.89,17.08) 150.89,17.65 D34.1 150.28,17.98 148.97,16.66 D33.2 ; v2(72.83,22.52) 72.85,22.5 C697.2 ; v1(63.94,51.52) 63.7,51.52 63.32,51.9 C216.1 ; 131.89,22.94 v1(131.89,23.1) ; PR7052.2 103.86,77.27 104.43,77.84 v1(104.51,77.84) ; PC9000.2 78.43,111.5 v1(78.29,111.37) ; v1(15.81,51.04) 16.08,51.04 C510.1 ; v2(91.07,37.61) 91.46,37.61 C2.1 91.67,37.32 92.45,36.54 C1.1 ; C502.2 128.98,90.28 v2(129.03,90.22) ; v2(69.02,22.71) C696.2 ; C415.1 100.26,107.04 100.19,106.97 v1(99.76,106.97) C425.1 ; C275.2 54.43,32.13 54.81,32.51 C280.2 54.93,32.63 v1(54.93,33.13) ; v2(91.6,63.9) 91.93,63.57 C163.1 ; C6610.1 180.92,21 181.34,21.42 v2(181.34,21.47) ; C595.2 211.16,30.39 211.64,29.91 211.65,29.91 v1(211.67,29.93) ; PR9022.1 71.99,116.43 71.99,116.5 v1(71.82,116.67) ; PC13.2 v1(11.69,118.04)
  TOP w0.406: C462.2 85.79,102.51 v1(85.79,103.26) ; C691.1 12,18.4 12.25,18.66 v1(12.48,18.66)
  TOP w0.457: v2(35.88,120.53) 35.55,120.53 34.9,121.18 HE1.3 ; v1(43.11,112.05) 43.45,112.05 44,111.5 C639.2 ; C442.1 137.01,105.4 v2(137.01,105.41) ; v2(140.21,105.41) 140.21,105.4 C441.1 ; v2(137.81,116.61) 137.74,116.68 C500.2 ; R319.1 120.61,94.09 v1(121.09,94.58) ; C161.2 95.55,78.17 v2(94.77,78.17)
  TOP w0.508: v1(17.71,27.8) 17.71,27.42 18.1,27.04 18.7,27.04 PC6056.2 ; R2660.2 32.45,2.65 32.95,3.16 v1(32.95,3.42) ; v1(52.54,94.45) 52.54,94.58 52,95.11 C343.1 ; C6504.2 27.48,13.74 v1(27.01,13.27) ; C302.2 32.47,99.56 32.45,99.59 ; v1(30.41,101.56) 30.41,101.85 C645.2 ; v1(121.75,94.6) 121.75,94.19 121.83,94.12 C438.1 ; C293.2 34,99.56 33.97,99.59 v1(33.97,99.61) ; v1(30.95,14.46) 30.22,13.74 C6549.2 ; v1(56.91,57.72) 56.96,57.77 C268.2 ; v1(36.05,48.8) 35.54,48.8 35.11,48.37 C338.1 ; v1(23.56,97.65) PC9063.2 ; v1(34.28,26.99) 34.28,26.68 34.65,26.31 PC562.2 ; Q6515.1 13.74,5.39 v1(14.29,4.84) ; v1(56.45,54.85) 56.45,55.36 56.7,55.61 57.71,55.61 C254.2 ; v1(26.35,94.22) 26.35,94.35 26.19,94.51 PC9058.2 ; v1(43.62,68.69) 43.23,69.08 R247.2 ; v2(216.98,31.94) 216.77,31.94 215.74,32.97 HOLE16.1 ; v1(21.78,85.71) 22.11,85.38 22.11,84.64 21.91,84.44 R748.2 ; v1(29.78,70.22) 29.77,70.23 C345.2 C346.1 ; C321.2 51.7,90.66 v1(51.73,90.69) ; v1(51.57,81.16) 50.96,81.77 C342.1 ; v1(138.49,40.5) 137.09,40.5 136.71,40.88 PC7070.2 ; C279.2 51.02,68.03 52.06,68.03 52.41,68.38 52.41,68.67 ; v1(23.23,40.55) 23.23,40.04 23.01,39.83 Q81.1 ; v1(27.65,25.39) 26.99,25.39 26.3,24.7 PR224.2 ; C532.2 20.84,35.74 v1(20.84,35.44) ; PQ6001.1 45.67,14.92 v1(45.62,14.97) ; R255.2 v1(41.46,68.75) ; C616.2 15.56,83.93 v1(15.94,84.31) ; C6582.1 15.4,17.08 v1(15.61,17.28) ; PR9104.2 119.35,123.14 v1(119.7,122.8) ; v1(10.6,19.17) 10.38,19.39 C675.1 ; v1(39.99,83.76) 39.82,83.59 C337.1 ; C522.2 22.35,59.43 22.74,59.04 v2(22.92,59.04) ; PC268.1 60.29,125.46 v1(60.02,125.2) ; v1(39.3,35.92) R253.2 ; v1(32.95,33.51) C281.1 ; R507.2 20.89,84.44 21.47,85.03 v1(21.47,85.08) ; PC9057.2 25.98,93.59 v1(26.35,93.59) 26.47,93.47 C296.2 ; v1(34.1,62.34) 34.1,62.06 33.96,61.93 C305.2 ; C332.2 v1(48.84,83.54) ; C320.1 37.26,83.18 v1(37.02,83.43) ; VC2.2 v1(13.65,85.97) ; v1(60.56,68.95) 60.65,69.03 C272.2 ; PR567.1 41.5,25.14 43.56,25.14 v1(44.24,24.46) ; v1(51.56,52.46) 51.45,52.56 C265.2 ; v1(38.72,100.9) 38.72,100.02 C297.2 C291.2 ; C256.2 52.51,63.87 53.05,64.4 v1(53.05,64.93) ; C340.1 v1(46.55,48.88) ; v1(51.71,88.95) 51.64,88.89 C303.2 ; v1(46.39,110.6) 46.55,110.76 C638.1 ; v1(51.55,50.6) 51.55,50.99 51.12,51.42 R243.2 ; v1(39.18,103.87) 39.18,103.5 39.48,103.2 C635.2 ; v1(51.65,62.29) 51.65,61.58 51.14,61.07 C250.2 ; R254.2 40.44,47.49 v1(40.51,47.42) 39.17,47.42 38.66,47.93 C319.2 ; v1(25.87,91.93) 26.11,91.7 PC9054.2 ; v1(36.51,62.72) 36.26,62.72 35.74,62.21 C317.1 ; v1(39.51,68.69) 39.06,68.69 38.55,69.2 C324.1 ; v1(24.98,52.06) 26.01,52.06 PR120.2 ; v1(45.02,60.79) 45.02,61.21 C286.2 ; v1(74.37,116.57) 74.23,116.72 74.23,117.71 74.61,118.1 PC9012.2 ; C513.1 v1(23.71,52.68) ; v1(31.94,33.51) C330.2 ; v1(26.86,18.41) C6547.2 ; J9007.2 48.61,23.46 48.2,23.46 v1(47.96,23.7) ; PQ9084.1 v1(122.28,120.72) ; C287.2 32.42,99.56 32.45,99.59 ; Y4.2 v1(43.71,113.44) ; v1(13.01,3.53) C6583.1 ; 32.45,99.59 v1(32.45,99.61) ; C263.2 56.98,61.2 v1(56.93,61.25) ; PQ9083.1 123.11,123.45 v1(122.87,123.68) ; Y4.4 46.2,112.34 46.67,111.87 v1(46.92,111.87) ; v1(22.92,97.65) 22.92,97.4 PC9062.2 ; v1(36.97,68.72) 36.38,68.72 35.87,69.23 C322.1 ; v1(132.17,52.64) 132.59,53.12 PR7034.2 ; PC9060.2 24.19,89.22 v1(24.27,89.14) ; v1(53.27,21.7) 53.15,21.7 52.64,21.2 C750.1 ; C1044.2 20.47,40.03 19.96,39.52 v1(19.65,39.52) ; v1(44.26,48.88) 44,48.62 C289.2 ; C270.2 51.07,72.95 v1(51.58,72.95) ; R244.1 48.97,46.73 v1(48.83,46.6) ; v1(202.88,30.72) 203.57,30.03 C597.1 ; v1(41.97,47.48) 42.22,47.73 R246.2 ; v1(28.94,49.39) C333.2 ; v1(29.98,79.01) 30.01,79.01 30.48,79.48 C315.2 ; PC6040.2 16.95,25.62 v1(16.95,26.3) ; v1(38.2,62.39) 38.3,62.29 C326.1 ; v1(41.85,35.92) R245.2 ; C277.2 55.54,67.74 v1(55.54,67.14) ; v1(43.23,60.8) C285.2 ; v1(51.85,30.66) 51.74,30.77 C273.2 51.42,31.3 51.36,31.36 C261.2 ; v1(40.45,46.57) 38.82,46.57 37.66,47.73 C312.2 ; PR118.2 29.48,33.98 v2(30.11,34.61) ; PC6017.1 PR6014.1 147.26,30.45 R676.2 ; R248.2 v1(44.5,83.44) ; C526.1 23.93,33.9 24.83,33.01 v1(24.83,32.88) ; C260.2 52,55.87 52.31,55.56 v1(52.31,55.18) ; v1(44.11,31.28) 44.11,31.25 44.69,30.67 44.69,29.58 44.77,29.49 PC571.2 PC572.2 ; C308.2 37.52,35.64 v1(37.77,35.9) ; C20000.2 46.16,114.54 46.52,114.9 v2(46.52,114.92) ; PC9013.2 72.96,116.1 72.96,116.45 v1(72.83,116.57) ; C262.2 56.7,65.65 56.58,65.52 55.66,65.52 55.28,65.9 v1(55.28,66.25) ; v1(48.91,41.95) 49.85,41.02 C258.2 ; v1(22.11,89.14) 22.16,89.19 PC9064.2 ; v1(19.67,38.73) C533.2 ; C456.2 88.73,100.66 v1(88.73,100.98) ; C292.2 v1(41.6,83.43) ; PC9077.2 140.23,64.46 v1(140.45,64.68) 139.86,65.26 PR9098.1 ; v1(42.98,35.92) C309.2 ; PC9059.2 v1(23.18,89.14) ; C628.1 23.95,82.28 24.32,81.91 24.32,81.77 24.42,81.67 v1(24.42,81.65) ; R749.2 16.7,84.39 v1(17.08,84.77) ; v1(51.78,64.91) 51.29,65.39 C274.2 ; C313.2 29.77,72.93 29.8,72.91 v1(29.8,72.88) ; v1(61.28,77.2) 61.78,76.7 C92.1 ; PC51.2 23.78,36.09 v1(23.38,36.09) ; v2(100.49,112.41) 100.87,112.41 101.28,112 C395.2 ; v1(209.46,10.78) 208.81,10.78 C6607.2 ; C288.2 26.47,90.27 v1(25.97,89.78) 25.97,89.39 C301.2 ; v1(117.41,47.99) 118.3,47.99 119.11,48.8 PR7045.2 ; v1(26.99,70.47) 26.22,70.47 25.72,69.97 C1692.2 ; v1(26.04,41.64) 26.16,41.53 PQ16.1 ; R825.1 137.85,33.78 138.29,34.23 v1(138.29,34.81) ; C318.2 40.72,61.61 41.69,61.61 42.2,61.1 v1(42.2,60.79) ; C298.2 R257.1 29.5,39.36 v2(29.14,39.71) ; v1(15.3,49.52) 16.2,49.52 16.32,49.4 R415.1 ; PR7061.2 114.8,46.35 v1(114.34,46.35) 114.34,45.67 114.01,45.34 PC83.1 ; v1(135.06,50.79) 134.9,50.62 PR7038.2 ; v1(28.94,50.41) C282.1 ; v1(18.35,27.8) 18.93,27.8 PC6057.2 ; PC9092.2 34.17,25.65 34.61,25.21 v1(34.61,24.04) 34.35,23.79 PC185.2 ; v1(40.19,68.69) 40.19,68.77 40.46,69.03 C295.2 ; v1(45.54,35.92) C339.1 ; C508.2 v1(14.79,45.71) ; PC299.2 68.16,118.4 68.4,118.16 PC285.1 68.62,117.74 v1(69.23,117.13) ; C304.2 v1(45.65,70.34) ; v1(51.55,93.31) 50.77,93.31 C328.1 ; v1(35.75,99.61) 35.75,99.59 35.77,99.56 C290.2 ; v1(21.04,89.14) 21.14,89.24 PC9053.2 ; Q6509.1 171.82,17.1 v2(171.82,17.69) ; C676.1 10.22,12.46 v1(10.35,12.33) ; C344.2 30.8,33.77 v1(31.05,33.51) ; v1(28.94,48.37) C329.2 ; v1(28.13,35.27) 27.72,35.27 27.51,35.48 PQ6.1 ; C521.2 23.02,56.87 23.68,56.21 v1(23.68,55.9) ; v1(32.17,37.02) 31.71,36.56 31.54,36.56 31.29,36.31 30.28,36.31 29.77,36.82 C311.2 ; R256.2 v1(42.6,83.44) ; D19.1 12.01,13.75 12.09,13.83 v1(12.63,13.83) ; C316.2 50.87,86.09 51.95,86.09 52.46,86.6 v1(52.46,86.9) ; v1(89.48,104.13) C392.2 ; C283.1 v1(46.28,83.44) ; R951.2 44.25,23.55 44.92,24.22 v1(44.92,24.47) ; PR9105.2 v1(126.77,123.01) ; v1(28.94,51.42) C306.2
  IN1 w0.089: 75.3,47.02 76.39,48.11 76.39,48.21 v2(76.52,48.34) 76.68,48.5 78.55,48.5 79.26,47.79 79.26,47.3 79.08,47.12 78.44,47.12 77.97,46.65 76.81,46.65 76.4,46.24 76.4,45.7 76.38,45.67 v2(76.35,45.67) 76.38,45.65 76.38,45.65 76.26,45.53 76.26,43.45 v2(76.36,43.35) 76.29,43.27 76.29,40.81 v2(76.35,40.75) 76.35,38.33 76.51,38.17 v2(76.54,38.17) 76.54,37.8 75.53,36.79 75.53,34.56 74.45,33.48 73.76,33.48 72.97,34.26 v2(72.97,34.52) 72.83,34.66 72.83,36.41 v2(73.56,37.15) 73.56,37.37 74.53,38.33 74.53,40.12 74.2,40.44 74.2,40.62 74.2,40.63 v2(74.15,40.63) 74.18,40.65 74.18,40.7 74.51,41.03 74.51,41.16 75.3,41.95 75.3,47.02 ; 189.34,16.39 188.89,16.85 188.89,19.04 188.02,19.9 187.47,19.9 184.8,22.57 177.96,22.57 177.9,22.5 v2(177.89,22.5) 177.89,22.49 177.73,22.34 176.44,22.34 175.88,22.9 174.93,22.9 173.66,21.62 v2(173.49,21.62) 173.26,21.39 171.04,21.39 170.45,21.98 169.47,21.98 v2(169.07,21.58) 168.67,21.98 165.27,21.98 164.2,23.05 159.27,23.05 158.66,23.66 153.53,23.66 152.54,24.64 148.06,24.64 147.67,24.26 v2(147.67,24.24) 147.27,24.64 145.06,24.64 144.84,24.42 137.53,24.42 136.87,25.08 132.6,25.08 132.43,24.91 125.76,24.91 v2(125.56,25.11) 124.47,26.2 119.19,26.2 118.83,25.84 104.51,25.84 104.1,26.25 102.96,26.25 102.72,26.49 v2(102.72,26.74) 103,26.74 103.59,27.34 104.71,27.34 105.73,26.32 118.29,26.32 118.65,26.68 125.28,26.68 126.56,25.41 132.01,25.41 132.17,25.56 137.2,25.56 137.68,25.08 144.79,25.08 144.86,25.15 152.87,25.15 153.86,24.17 159.09,24.17 159.65,23.61 164.41,23.61 165.56,22.46 170.68,22.46 171.27,21.87 172.8,21.87 173.31,22.39 173.69,22.39 174.69,23.39 176.17,23.39 176.74,22.82 177.06,22.82 177.64,23.4 178.27,23.4 178.62,23.05 185.06,23.05 187.55,20.56 188.23,20.56 190,18.78 190,17.82 189.6,17.41 v2(189.6,17.4) 190,17 190,16.6 189.8,16.39 189.34,16.39
  BOTTOM w0.079: 98.99,35.5 98.99,35.75 98.77,35.98 98.77,37.25 v2(98.06,37.96)
  BOTTOM w0.102: U8.E17 107.59,96.23 v2(108,95.82) ; 92.37,35.1 92.37,34.12 v2(92.45,34.03) ; v2(72.97,34.52) 73.37,34.12 73.37,32.8 74.94,31.22 v2(75.19,31.22) ; C206.1 75.75,29.13 76.03,28.84 80.73,28.84 80.74,28.85 80.8,28.85 80.9,28.96 80.9,30.7 80.63,30.97 80.41,30.97 C209.1 ; R145.2 101.89,31.43 101.28,32.04 101.28,34.56 100.88,34.96 C226.1 ; v2(97.88,35.75) 97.78,35.65 97.78,34.82 98.36,34.24 v2(98.36,34.16) 98.36,33.64 98.23,33.51 98.23,32.24 98.06,32.07 v1(98.06,31.51) 98.06,31.07 98.41,30.72 v2(98.41,29.4) ; C205.1 98.78,28.16 98.86,28.09 98.86,26.03 99.12,25.77 v2(99.53,25.77) 100.11,25.77 100.32,25.97 101.33,25.97 101.43,26.07 101.43,26.68 101.63,26.88 v2(101.63,27.59) ; v2(79.61,32.35) 78.52,32.35 78.09,32.78 77.14,32.78 76.72,33.2 76.28,33.2 75.55,33.93 75.55,34.3 ; v2(100.47,29.63) 100.44,29.66 100.44,32.9 99.86,33.49 99.86,34.63 98.99,35.5
  BOTTOM w0.127: 92.37,35.1 U1.CP9 U1.CN9 ; U1.G35 U1.G36 75.16,75.88 74.51,75.88 73.82,76.57 v2(73.57,76.57)
  BOTTOM w0.152: U1.CP15 88.58,35.01 88.58,34.14 88.44,34 88.44,33.97 v2(88.41,33.95) ; U1.BK4 95.57,49.49 95.89,49.49 96.27,49.56 U1.BK3 U1.BK2 ; U1.CF4 95.87,39.91 v2(95.89,39.89) 95.92,39.91 U1.CF3 U1.CF2 ; U1.CP11 91.1,34.37 91.18,34.3 v2(91.18,34.21) ; U1.P36 74.38,72.1 74.33,72.15 74.26,72.15 74.23,72.17 v2(74.15,72.17) ; U1.V36 74.89,69.76 74.15,69.76 73.65,70.27 v2(73.65,70.29) ; U1.BB36 75.06,54.47 74.43,54.47 74.3,54.34 74.1,54.34 74.08,54.32 v2(74.06,54.32) ; U1.BP4 v2(95.87,47.24) U1.BP3 ; U1.CB2 U1.CB3
  BOTTOM w0.178: U1.AV36 75.06,57.01 74.41,57.01 74.23,57.19 73.21,57.19 72.86,56.83 72.32,56.83 72.27,56.88 v2(72.25,56.88) ; U1.AP36 73.86,59.52 v2(73.84,59.54) ; U1.J36 75.06,74.63 74.43,74.63 74.32,74.75 73.89,74.75 73.59,75.04 73.57,75.04 73.52,75.09 v2(73.49,75.09) ; U8.P26 115.05,103.85 115.84,103.85 116.01,104.03 v2(116.01,104.13) ; v2(83.5,80.05) 83.53,80.02 U1.B23 ; PU1.36 133.02,28.71 PU1.22 ; v2(73.85,64.61) 73.9,64.55 U1.AF36 ; U1.AB36 75.06,67.08 74.44,67.08 74.25,67.27 73.53,67.27 73.01,67.78 72.12,67.78 71.94,67.6 v2(71.94,67.3) ; v2(81.03,79.83) 81.03,79.8 81.01,79.78 U1.B27 ; U1.B31 78.51,79.01 78.51,79.75 78.42,79.84 78.42,80 77.84,80.58 v2(77.33,80.58) ; CN10.A12 7.61,18.65 7.73,18.53 ; U1.BF36 74.47,51.97 v2(74.36,52.08) ; U1.AK36 73.37,62.03 73.35,62.05 73.27,62.05 v2(73.26,62.05)
  BOTTOM w0.203: v2(67.88,38.7) R157.1 ; v1(20.18,23.63) 20.35,23.81 R25272.1 ; C220.1 C221.1 87.69,32.06 87.82,32.19 v2(87.82,32.37) ; R25277.1 20.33,18.07 19.72,17.46 v1(19.72,17.36) ; v2(144,33.79) 144.22,33.58 144.37,33.58 144.6,33.35 PU6000.8 ; EC5.1 60.53,88.19 60.54,88.2 v1(60.54,88.21) ; v2(83.5,73.62) 83.47,73.65 83.34,73.65 U1.K24 ; v1(141.69,48.73) 141.41,49.01 PC7025.1 ; U6503.12 22.91,14.86 22.56,14.51 v1(22.46,14.51) ; C844.1 196.39,29.62 196.22,29.78 R734.1 ; v2(192.34,31.46) 192.52,31.28 C800.2 192.83,30.72 192.88,30.67 C801.2 ; PC7027.1 142.15,46.21 142.33,46.03 v1(142.33,45.83) ; C802.2 194.84,30.69 194.52,31 v2(194.45,31) ; v1(16.56,20.42) 16.73,20.26 R25279.1 ; D13088.1 16.57,81.55 v1(16.93,81.9) ; U1.CM4 95.56,36.95 95.38,37.12 U1.CK4 95.57,37.48 v2(95.81,37.72) 95.42,38.11 U1.CJ4 ; CN17.51 184.03,18.63 184.26,18.4 184.26,17.79 184.24,17.77 184.24,17.41 184.47,17.18 v2(184.47,16.95) 184.21,16.95 184.03,17.13 CN17.57 ; v1(134.28,62.06) 134.4,62.06 135.06,61.4 PC7030.1 ; D13085.1 17.42,77.77 v2(17.13,78.07) 16.71,77.65 D13084.1 ; v1(100.14,60.44) C6619.2 ; C841.2 40.42,123.25 v2(40.57,123.4) ; v2(97.01,38.52) 97.01,38.49 96.72,38.2 U1.CJ2 U1.CJ3 ; R25358.1 86.29,23.94 86.88,24.52 v2(86.88,24.87) ; U1.BT36 75.16,45.68 74.38,45.68 74.36,45.66 v2(74.33,45.66) ; C242.1 62.73,27.7 v1(62.6,27.7) ; C6626.2 71.03,32.12 70.83,32.32 R209.2 70.54,33.3 70.54,33.59 v2(70.61,33.67) ; v2(89.75,29.4) 89.75,29.18 89.44,28.87 R121.2 ; U1.AB4 95.38,66.58 95.07,66.26 94.7,66.26 U1.AC5 ; PC242.2 158.81,24.12 158.81,25.13 159.45,25.77 U2.4 159.45,27.21 159.12,27.55 v2(159.12,27.57) ; R145.2 102.45,30.59 v1(102.8,30.95) 102.83,30.92 C6622.2 ; v2(73.88,73.61) 74.37,73.61 74.51,73.47 75.06,73.47 U1.L36 U1.L35 ; v1(20.13,22.31) 20.1,22.34 U6502.3 ; v1(56.5,96.18) 56.5,96.04 57.33,95.21 JDIM1.5 ; U1.CK37 74.13,37.63 73.65,37.15 v2(73.56,37.15) ; R90.1 67.73,37.37 v2(67.75,37.4) ; C116.1 100.34,56.6 99.83,56.09 v2(99.83,55.87) ; v1(97.65,26.73) 97.72,26.73 98.03,26.43 C6614.1 ; v2(67.8,39.94) 67.79,39.92 C5.2 ; 181.49,15.18 C2610.2 181.62,14.13 CN17.69 ; U1.BY36 U1.BY35 76.17,43.16 v2(76.36,43.35) ; D13087.1 17.06,79.58 v2(17.16,79.49) 17.22,79.55 D13086.1 ; U1.CJ36 U1.CJ35 75.82,38.13 76.47,38.13 76.51,38.17 v2(76.54,38.17) ; PU7001.6 132.86,48.24 v1(133.11,47.99) ; R25275.1 16.42,26.09 16.75,26.09 16.95,26.3 v1(16.95,26.3) ; U1.A32 77.74,79.32 77.53,79.52 77.53,79.54 77.46,79.62 v2(77.46,79.64) ; U1.CM5 94.84,36.19 v2(94.91,36.13) 94.91,35.68 U1.CN5 ; v2(92.59,30.21) C7.2 ; D13083.1 17.07,75.87 v2(17.16,75.96) 17.52,76.32 D13082.1 ; v1(136.66,60.82) 136.66,60.59 136.79,60.46 PC423.2 ; C226.1 100.88,35.21 100.39,35.7 v2(100.39,36.49) ; PR7104.1 132.77,53.4 133.12,53.76 133.13,53.76 133.54,54.16 PC7018.2 ; R467.2 198.23,36.1 198.23,36.1 v1(197.65,36.69) ; CN17.33 184.32,23.13 184.92,23.74 v2(184.92,24.09) ; CN17.45 182.15,20.13 181.86,20.42 181.86,20.8 181.37,21.3 181.37,21.45 v2(181.34,21.47) 181.77,21.91 182.18,21.91 182.46,21.63 CN17.39 ; v2(74.15,40.63) 74.18,40.65 74.18,40.7 74.28,40.81 75,40.81 U1.CE36 U1.CE35 ; CN19.2 152.4,25.73 152.72,26.05 153.33,26.05 153.43,26.15 154.57,26.15 155.15,26.73 ; 181.73,15.42 181.67,15.48 181.67,16.37 181.71,16.41 v2(181.71,16.42) ; v2(67.75,36.28) R116.1
  BOTTOM w0.229: v1(43.27,15.07) 43.27,15.1 43.45,15.28 43.45,15.38 43.58,15.51 43.58,15.57 44,15.98 PR6031.1 ; PU6003.8 44.68,17.85 45.53,17 45.53,16.24 45.89,15.89 v1(46.52,15.89) ; R25485.2 211.52,15.51 U42.25
  BOTTOM w0.254: v1(59.85,80.02) 59.85,79.67 59.39,79.21 JDIM1.69 ; U8.B5 97.61,93.8 v2(97.61,92.87) ; v1(47.52,9.14) 46.73,9.92 46.73,11.13 46.45,11.41 CN24.1 46.45,11.96 47.01,12.52 47.01,13.06 PC6039.1 ; v1(52.46,86.9) 51.94,86.38 51.34,86.38 51.26,86.45 JDIM1.40 ; U1.CR6 94.37,34.61 v2(94.37,34.12) ; v1(57.08,50.74) 57.12,50.71 JDIM1.175 ; U1.BV31 77.93,43.78 v2(77.9,43.78) ; v1(48.58,71.36) 48.98,70.95 JDIM1.102 ; JDIM1.223 57,38.71 v1(56.91,38.8) ; v1(60.54,90.68) 60.54,90.28 59.96,89.7 JDIM1.27 ; PC9026.2 71.56,114.59 71.72,114.74 v1(72.1,114.74) ; PU7003.9 127.75,77.78 PU7003.6 ; v1(60.49,80.02) 60.49,80.66 59.94,81.21 JDIM1.61 ; U1.BJ7 93,50.91 v2(93,50.98) ; U1.BA10 91.67,55.29 v2(91.67,55.61) ; v1(57.06,75.23) 57.11,75.23 57.14,75.2 JDIM1.85 ; v1(51.47,96.4) 51.4,96.33 51.4,96.28 51.07,95.95 JDIM1.2 ; U1.CE35 75.84,40.67 76.27,40.67 v2(76.35,40.75) 76.91,40.75 U1.CE33 77.44,41.06 ; U1.BP7 93.38,46.7 v2(93.74,46.34) ; JDIM1.18 51.9,91.95 52.84,92.9 v1(52.84,93.31) ; JDIM1.197 55.81,45.2 55.56,45.45 v1(55.28,45.45) ; U1.D6 94.19,77.21 v2(94.54,76.86) 94.84,77.17 U1.D5 ; CN17.18 191.59,26.88 191.93,26.53 v2(191.93,26.52) ; v1(52.49,30.66) 52.49,31.13 52.39,31.23 51.72,31.23 51.5,31.45 JDIM1.252 ; JDIM1.234 48.8,35.95 v1(48.7,36.05) ; v1(59.8,71.46) 59.56,71.7 JDIM1.99 ; U1.BT28 80.37,46.06 80.68,45.75 80.68,45.72 80.73,45.67 v2(80.73,45.57) ; U1.BU11 91.18,45.24 91.18,44.64 U1.BV11 91.68,44.61 v2(91.81,44.49) 91.28,43.96 U1.BW11 91.3,43.82 91.3,43.46 U1.BY11 U1.CA11 U1.CB11 U1.CC11 U1.CD11 91.15,40.3 v2(91.07,40.22) ; v2(94.54,74.09) 94.07,73.63 U1.L6 94.03,73.38 93.89,73.24 v2(93.89,73.17) 93.89,73.14 94.03,73 U1.N6 ; v2(94.54,74.09) 94.68,74.23 U1.J5 ; v2(94.54,74.09) 94.07,74.55 U1.J6 ; U8.Y26 115.12,108.5 116.54,108.5 116.85,108.81 v2(116.85,108.96) ; U1.J15 88.88,74.44 v2(88.98,74.44) ; JDIM1.239 55.64,34.71 54.98,35.37 v1(54.98,35.7) ; v2(97.88,76.53) U1.F2 96.97,76.44 96.48,76.44 U1.F3 96.3,76.43 U1.F4 ; U1.D1 97.84,77.75 97.87,77.77 v2(97.87,77.77) ; CN29.9 47.85,107.68 47.6,107.94 47.08,107.94 v1(46.92,108.09) 46.9,108.06 46.67,108.06 46.35,107.74 CN29.6 ; U1.AV8 92.73,57.32 v2(92.87,57.46) ; v1(60.56,68.95) 60.56,69 59.86,69.7 JDIM1.107 ; U1.C25 U1.B25 ; JDIM1.77 57.09,77.2 v1(57.09,77.21) ; U1.J12 90.76,74.44 v2(90.86,74.44) ; v2(89.95,41.69) 89.9,41.64 89.75,41.64 U1.CC14 U1.CD14 89.47,40.51 89.93,40.06 v2(89.95,40.06) 89.78,39.89 U1.CF14 ; v1(52.44,79.28) 52.44,79.46 52.08,79.82 51.55,79.82 51.18,79.46 JDIM1.68 ; v2(91.67,58.39) 91.67,58.06 U1.AU10 ; U1.AG10 91.81,63.69 v2(91.6,63.9) ; U1.AN25 v2(82.53,59.73) ; JDIM1.23 59.8,90.7 v1(59.83,90.68) ; CN17.1 183.22,31.46 CN17.76 ; JDIM1.196 51.63,45.45 52.26,46.09 v1(52.26,46.47) ; 7.73,18.53 8.29,18.53 8.65,18.88 8.65,18.91 v1(8.65,18.91) 8.64,18.91 8.46,19.1 CN10.4 ; U1.AE7 U1.AF7 93.39,64.39 93.8,63.97 93.81,63.97 v2(93.82,63.96) ; U1.BD6 93.74,53.6 v2(93.74,53.8) ; 181.49,15.18 181.73,15.42 181.99,15.42 182.2,15.63 CN17.63 ; JDIM1.52 51.92,83.46 v1(52.54,82.84) ; U1.G9 92.07,75.94 v2(91.84,75.7) ; CN15.7 133.85,18.06 v2(133.46,18.45) ; U1.AB3 v2(95.89,66.76) U1.AB4 ; JDIM1.15 57.15,92.7 v1(57.03,92.82) ; U1.AF4 v2(95.89,64.32) U1.AF3 ; CN10.1 8.33,12.7 v1(8.57,12.94) 8.19,13.32 7.78,13.32 7.61,13.15 CN10.A1 ; v2(112.11,100.83) U8.L23 112.95,101.67 113.71,101.67 U8.L25 ; JDIM1.171 55.28,51.71 54.67,52.31 v1(54.67,53.61) ; JDIM1.213 57.37,41.2 v1(57.14,41.44) ; v1(51.62,43.98) 51.6,43.95 JDIM1.202 ; 95.05,50.18 95.05,50.84 v2(94.96,50.94) 95.08,50.94 95.42,51.28 U1.BG4 ; 88.28,46.89 88.12,46.89 U1.BR16 ; 88.28,46.89 v2(88.28,46.89) ; 88.28,46.89 88.6,47.21 U1.BP15 ; v2(93.03,39.99) 93.03,39.8 U1.CG7 ; JDIM1.193 57.33,46.2 57.3,46.18 56.51,46.18 56.07,46.62 v1(56.07,46.75) 56.07,46.95 56.44,47.32 56.85,47.32 56.96,47.2 JDIM1.189 ; JDIM1.238 52.29,34.95 v1(53.63,33.62) ; U1.C9 92.36,78.24 91.87,77.74 v2(91.84,77.74) 92.08,77.51 U1.D9 ; U8.B27 116.14,93.42 v2(116.14,93.08) ; v2(136.74,18.45) 136.74,18.32 136.85,18.21 CN15.1 ; v1(94.87,61.16) 94.87,60.89 U1.AM5 ; U1.AN8 92.73,60.09 v2(92.87,60.23) 92.92,60.23 U1.AN7 ; U8.E2 95.08,96.23 93.51,96.23 v2(93.48,96.25) ; v1(67.09,120.74) 67.91,120.74 68.42,121.25 PC298.2 68.42,122.11 PC280.2 ; U1.AM10 91.81,61.02 v2(91.67,61.16) ; v1(56.98,73.24) 57.42,73.24 57.45,73.2 JDIM1.93 ; JDIM1.217 57.17,40.2 v1(57.03,40.07) ; CN29.21 53.85,107.62 53.15,108.32 v2(53.07,108.32) 52.35,107.6 CN29.18 ; v2(109.89,92.57) 109.99,92.67 U8.B20 ; U8.B11 102.67,93.71 v2(102.67,93.31) ; JDIM1.26 51.19,89.95 51.32,89.83 52.44,89.83 53.02,90.41 v1(53.02,90.69) ; v2(91.07,40.22) 90.81,40.22 U1.CD12 ; v2(91.07,40.22) 91.4,39.89 U1.CF11 ; v2(91.48,71.39) 91.48,71.45 U1.P10 ; v1(57.16,94.09) 57.34,94.09 57.45,94.21 JDIM1.9 ; v2(113.74,96.73) 113.74,96.67 U8.E25 ; U1.BV33 77.2,44.24 77.2,43.91 v2(77.3,43.81) 77.02,43.53 U1.BY33 ; U1.CH31 78.39,38.6 78.71,38.28 v2(78.71,38.22) ; U1.B12 90.76,78.34 v2(90.86,78.34) ; v2(81.24,33.82) 81.24,34.23 81.02,34.45 U1.CP27 ; CN35.27 211.86,34.9 v1(211.72,35.04) ; JDIM1.251 56.35,31.71 v1(54.93,33.13) ; U1.CG33 77.2,39.38 77.36,39.22 v2(77.56,39.22) 77.56,39.21 77.2,38.85 77.2,38.7 77.02,38.51 U1.CJ33 77.02,38.17 v2(76.54,38.17) ; v1(52.36,42.48) 52.36,42.58 51.96,42.98 51.31,42.98 51.29,42.95 JDIM1.206 ; U1.CD20 86.1,39.89 U1.CF19 ; CN15.17 128.85,18 v2(129.17,18.32) 129.09,18.4 128.71,18.4 128.35,18.04 CN15.18 ; PU9004.19 v1(137.06,69.54) ; v1(48.84,78.46) JDIM1.72 ; CN29.3 44.85,106.37 v1(44.77,106.29) ; v1(48.91,41.95) JDIM1.210 ; v1(51.54,37.95) JDIM1.226 ; JDIM1.103 57.49,70.7 57.31,70.88 57.31,71.13 v1(56.98,71.46) ; U1.BC8 92.73,54.06 92.98,53.81 93.02,53.81 v2(93.03,53.8) 93.03,53.78 93.38,53.43 U1.BD7 ; PC6231.2 168.57,22.18 169.07,21.67 v2(169.07,21.58) ; CN35.20 212.77,38.4 212.46,38.09 v1(212.2,38.09) ; U1.BY18 86.92,43.31 v2(86.59,42.99) 86.27,43.31 U1.BY19 ; U1.B18 87,78.34 v2(87.1,78.34) ; JDIM1.188 52.87,47.46 53.17,47.76 v1(53.17,48.35) ; U1.BM36 75.03,48.33 74.53,48.33 74.46,48.4 v2(74.43,48.4) ; U1.CB3 v2(95.89,42.36) U1.CB4 95.38,42.44 U1.BY5 ; v2(89.6,33.34) 89.77,33.51 89.77,35.03 U1.CP13 U1.CN13 ; v1(51.57,81.16) 51.57,81.2 51.32,81.46 JDIM1.60 ; U1.AV25 v2(82.52,57) ; v1(48.86,80.46) JDIM1.64 ; JDIM1.48 51.71,84.45 52.34,85.08 v1(52.34,85.1) 51.85,85.58 51.37,85.58 51.24,85.45 JDIM1.44 ; v2(82.72,48.89) 82.65,48.81 82.55,48.81 82.54,48.8 U1.BL25 ; v1(51.55,50.6) 51.41,50.46 JDIM1.176 ; U1.CC31 78.31,41.51 77.86,41.06 77.44,41.06 ; v1(52.89,40.96) 52.89,40.83 52.07,40.01 51.36,40.01 51.31,39.95 JDIM1.218 ; v2(100.47,95.85) 100.47,95.88 100.46,95.89 100.41,95.89 U8.E8 ; v1(51.55,40.95) JDIM1.214 ; JDIM1.94 v1(51.58,72.95) 51.6,72.97 51.6,73.78 51.42,73.95 JDIM1.90 ; U1.P7 93.43,71.78 v2(93.89,72.24) ; U8.B17 107.63,93.71 v2(107.63,93.2) ; U1.AG5 94.68,63.73 v2(94.45,63.96) ; U1.E27 81.33,77.04 81.45,76.91 v2(81.48,76.91) ; JDIM1.222 51.32,38.95 51.65,39.28 v1(51.65,39.46) ; U1.K3 96.07,74.09 v2(95.82,74.33) 95.57,74.09 U1.K4 ; U1.BT14 89.47,45.89 89.16,45.58 v2(89,45.58) ; v2(93.54,93.19) 93.55,93.19 94.19,93.83 U8.B1 ; v2(91.67,68.55) 91.81,68.69 U1.W10 ; v2(88.98,76.39) 88.88,76.39 U1.F15 ; v1(53,75.96) 53,75.68 52.27,74.95 JDIM1.86 ; U6504.3 87.79,24.53 87.45,24.87 v2(86.88,24.87) ; JDIM1.73 60.63,78.2 61.28,77.56 v1(61.28,77.2) ; U1.CN29 79.81,35.81 79.81,36.58 U1.CM29 79.76,36.86 79.79,36.9 v2(79.79,37.25) 79.79,37.36 80.29,37.86 U1.CJ28 ; v1(52.84,50.6) 52.84,50.35 51.94,49.46 JDIM1.180 ; U1.CE7 93.13,40.62 v2(93.13,40.83) 93.38,41.08 U1.CC7 93.28,41.39 93.28,42.12 U1.CB7 ; 141.62,42.23 142.22,42.23 142.8,42.8 PC7104.1 ; v2(166.08,23.89) 166.08,24.09 165.87,24.29 164.66,24.29 164.32,23.95 164.32,23.63 163.94,23.25 PU3003.2 ; U1.CJ23 82.97,37.94 82.61,37.58 82.61,37.17 v2(82.71,37.07) U1.CM25 U1.CN25 ; v2(147.53,48.96) 147.08,48.5 146.75,48.5 146.54,48.3 145.26,48.3 PC7012.2 ; v1(48.83,46.6) 48.97,46.45 JDIM1.192 ; U1.AC10 91.81,65.92 v2(91.67,65.78) ; U1.CJ14 89.72,37.6 v2(89.95,37.6) 89.84,37.49 U1.CM13 ; v1(94.21,61.16) 93.84,61.16 U1.AL7 93.48,61.73 93.48,62.44 U1.AJ7 ; 77.44,41.06 77.02,41.47 U1.CB33 ; U1.BV3 v2(95.87,44.8) U1.BV4 95.38,44.97 94.98,45.38 94.98,45.62 U1.BT5 ; v1(55.76,75.2) 55.76,74.54 56.09,74.2 JDIM1.89 ; U1.CM33 77.23,36.37 v2(77.42,36.19) ; U1.AB7 93.15,67.39 93.15,67.86 U1.Y7 93.33,68.09 v2(92.87,68.55) 93.33,69.01 U1.W7 ; JDIM1.19 57.31,91.7 57.19,91.58 v1(57.16,91.58) ; v1(52.61,31.96) 52.12,32.45 JDIM1.248 ; v1(56.38,80.8) 56.38,80.47 56.65,80.21 JDIM1.65 ; v1(55.79,49.21) 55.79,49.03 56.62,48.2 JDIM1.185 ; v2(89,45.58) 89.09,45.49 89.09,44.38 88.67,43.96 ; v2(89,45.58) 89,45.59 88.67,45.91 U1.BT15 ; U1.F12 90.76,76.39 v2(90.86,76.39) ; U1.B15 88.88,78.34 v2(88.98,78.34) ; U1.D8 93.06,77.05 92.87,76.86 92.87,76.86 92.86,76.87 92.86,76.88 92.86,76.89 ; U1.BW24 82.75,43.91 83.03,43.64 v2(83.24,43.64) ; U1.BT16 87.95,45.91 v2(88.28,45.59) 88.13,45.59 87.81,45.26 U1.BU16 ; JDIM1.172 51.26,51.46 51.36,51.55 52.03,51.55 52.89,52.41 v1(52.89,52.46) ; U1.CF28 80.34,39.67 v2(79.89,39.23) ; PC7005.2 140.98,61.6 140.7,61.89 v1(140.7,62.24) 140.2,62.24 PC9074.2 ; v1(48.87,87.48) 48.9,87.45 JDIM1.36 ; U1.B9 92.36,79.14 91.87,79.64 v2(91.84,79.64) ; U8.H2 95.13,98.71 v2(94.73,98.31) ; U1.T7 93.38,70.85 v2(93.84,70.4) 93.38,69.94 U1.U7 ; U8.U23 112.53,106.29 v2(112.14,106.68) ; U1.BU7 93.4,44.99 93.68,44.72 v2(93.68,44.46) 93.68,44.32 93.42,44.07 U1.BW7 ; U1.V3 v2(95.89,69.2) U1.V4 ; v1(56.2,53.63) 56.45,53.63 57.38,52.71 JDIM1.167 ; CN29.12 49.38,107.15 49.38,107.64 50.05,108.32 v2(50.81,108.32) 50.81,107.63 50.85,107.59 CN29.15 ; v2(80.09,41.01) 80.09,41.04 80.12,41.07 80.12,41.29 U1.CC28 ; U1.H9 92.27,74.91 v2(91.84,74.48) 92.23,74.09 U1.K9 ; v1(57.08,43.96) 57.33,44.2 JDIM1.201 ; JDIM1.22 51.46,90.95 v1(51.73,90.69) ; v1(51.83,48.35) 51.72,48.46 JDIM1.184 ; 214.82,13.45 214.45,13.82 HD1.6 ; v2(105.45,96.65) U8.E14 ; v1(60.62,77.2) 60.62,76.92 59.9,76.2 JDIM1.81 ; v2(86.63,47.56) 86.28,47.21 U1.BP19 U1.BR19 ; v2(87.1,76.39) 87,76.39 U1.F18 ; U1.CP19 86.06,34.43 85.7,34.07 85.46,34.07 85.27,33.89 v2(85.27,33.89) 85.05,34.1 85.05,34.85 U1.CP21 U1.CN21 U1.CM21 ; v2(75.19,31.22) 75.56,30.85 C206.1 ; U1.BT33 v2(76.35,45.67) U1.BT35 ; U1.B5 94.77,78.53 v2(94.77,78.17) 94.78,78.16 95.25,78.16 U1.C4 ; JDIM1.6 51.37,94.95 51.4,94.98 52.01,94.98 v1(52.54,94.45) 52.02,93.93 51.28,93.93 51.25,93.95 JDIM1.10 ; JDIM1.43 59.48,85.7 60.06,85.13 v1(60.06,85.12) ; 58.45,37.71 56.96,37.71 56.88,37.78 56.27,37.78 55.92,37.43 v1(55.92,37.24) ; v2(94.09,79.87) 94.01,79.87 93.63,79.48 U1.B7 ; CN15.4 135.35,18.23 v2(135.57,18.45) ; 92.86,76.89 92.84,76.89 92.82,76.86 U1.E9 ; 92.86,76.89 v2(92.87,76.89) ; U8.A2 95.13,92.95 94.89,92.71 v2(94.52,92.71) ; JDIM1.47 57.5,84.7 57.39,84.59 56.88,84.59 56.4,85.08 v1(56.4,85.1) ; U1.AK4 95.56,61.71 v2(95.9,61.71) 96.22,61.71 U1.AK3 ; U8.AC26 115.16,111.41 116.26,111.41 v2(116.44,111.6) ; v2(82.54,54.27) 82.54,54.27 U1.BC25 ; v2(94.32,56.59) 94.32,56.61 94.03,56.9 U1.AV6 ; v2(94.35,55.71) 94.35,55.47 U1.BA6 ; U1.BP12 90.31,47.89 v2(89.98,48.22) ; U1.BP25 81.93,47.21 v2(82.26,46.89) 82.26,46.89 81.93,46.56 U1.BR25 81.77,46.42 81.77,46.06 U1.BT25 U1.BU25 U1.BU24 83.08,44.94 v2(83.24,44.94) 83.34,44.94 83.59,45.19 U1.BU23 ; JDIM1.98 51.47,71.95 51.73,71.7 v1(51.73,71.36) 51.73,70.45 51.23,69.95 JDIM1.106 ; v2(97.98,96.68) U8.E5 ; U1.P4 v2(95.89,71.65) U1.P3 ; v1(112.46,92.32) 112.64,92.5 112.64,93.67 U8.B23 ; JDIM1.51 59.9,83.7 60.03,83.57 60.03,82.91 v1(59.93,82.81) 59.93,82.54 59.6,82.21 JDIM1.57 ; v2(80.01,42.87) 80.03,42.89 80.03,43 80.34,43.3 U1.BY28 ; U1.C21 85.21,78.25 v2(85.31,78.34) 84.78,78.86 U1.B21 ; JDIM1.31 59.5,88.7 59.55,88.76 60.13,88.76 60.54,88.35 v1(60.54,88.21) ; v2(93.79,38.04) 93.79,37.99 93.4,37.6 U1.CK7 93.33,37.6 U1.CM9 U1.CN9 ; JDIM1.14 51.27,92.95 51.53,93.21 51.53,93.28 v1(51.55,93.31) ; v1(59.83,95.64) 59.83,95.79 59.41,96.21 JDIM1.1 ; JDIM1.244 51.49,33.45 v1(51.54,33.5) ; D13081.1 17.14,74.54 v2(16.98,74.38) ; v1(51.56,52.46) JDIM1.168 ; v1(83.02,51.93) 82.96,51.93 82.57,51.53 U1.BG25 ; v2(84.89,45.58) 84.94,45.58 85.26,45.26 U1.BU20 ; JDIM1.30 v1(51.71,88.95) ; v1(55.05,37.25) 55.6,36.71 JDIM1.231 ; U1.BP32 77.31,47.41 77.28,47.41 v2(77.25,47.43) 77.25,47.41 77.02,47.17 U1.BP33 ; v2(84.89,46.89) 84.56,46.56 U1.BR22 ; v2(102.92,95.86) U8.E11 ; U8.H5 97.12,98.36 v2(97.12,98.36) ; v1(55.48,42.28) 55.56,42.2 JDIM1.209 ; U1.BW15 88.67,43.96 ; 88.67,43.96 88.67,43.35 U1.BY15 88.7,43.31 v2(89.03,42.99) 88.96,42.99 U1.CA15 88.24,42.27 88.24,41.81 U1.CC16 ; JDIM1.205 57.47,43.2 57.43,43.17 56.37,43.17 55.71,43.83 v1(55.71,43.96) ; v2(98.13,57.16) 98.13,57.1 U1.AW1 ; U1.BE10 91.67,52.24 91.67,52.17 91.51,52.01 v2(90.93,52.01) ; JDIM1.247 57.44,32.71 57.36,32.63 56.68,32.63 56.35,32.96 v1(56.35,33.13) 56.35,33.26 56.79,33.71 JDIM1.243 ; U8.L5 97.95,100.83 v2(97.97,100.83) ; PC6022.2 144.12,33.91 v2(144,33.79) ; v2(184.39,31.25) 184.41,31.23 184.41,29.96 184.09,29.63 CN17.7 ; JDIM1.235 v1(56.32,35.71) ; U1.CJ19 86.05,37.71 v2(85.82,37.71) ; JDIM1.35 57.21,87.7 v1(56.98,87.93) ; U1.CJ11 91.4,37.94 v2(91.07,37.61) ; CN17.19 184.14,26.63 184.29,26.48 184.29,25.87 184.92,25.23 v2(184.92,25.16) ; v2(78.36,36.72) 78.36,36.71 78.53,36.54 U1.CM31 ; JDIM1.230 52.12,36.95 52.84,37.68 v1(52.84,37.93) ; v1(51.54,76.95) JDIM1.78 ; v1(57.06,49.2) JDIM1.181 ; v2(93.02,51.97) 93.02,52.03 92.73,52.33 U1.BE8 ; v2(87.1,74.44) 87,74.44 U1.J18 ; JDIM1.56 51.37,82.46 v1(51.75,82.84) ; HD1.9 214.82,12.32 ; U1.CN17 U1.CM17 87.73,37.05 87.74,37.05 v2(87.77,37.07) ; v1(51.68,75.95) JDIM1.82 ; JDIM1.39 v1(56.99,86.7) ; U1.CB18 86.92,42.01 v2(86.59,41.69) 86.27,42.01 U1.CB19 85.97,42.01 v2(85.64,41.69) 85.31,42.01 U1.CB20 ; U8.H23 v2(112.93,98.37)
  BOTTOM w0.305: U8.AB7 v2(99.65,110.81) U8.AC8 ; CN16.51 v1(27.35,8.24) 26.15,8.24 25.85,8.55 CN16.57 ; v2(114.53,99.21) 114.53,99.17 U8.H25 ; U8.V13 v2(103.48,107.18) U8.U12 102.9,106.73 v2(102.42,106.25) 102.03,105.86 U8.T11 102.02,105.73 v2(101.42,105.13) 101.03,104.74 U8.R10 ; PU7002.9 118.96,68.87 PU7002.6 ; R306.1 C364.2 99.5,125.34 v1(99.12,124.95) ; U8.AF11 102.94,114.02 v2(102.96,114.02) ; v2(94.14,111.49) 94.82,111.49 U8.AC2 ; CN16.39 v1(30.35,8.11) ; R331.2 97.46,87.48 97.98,88 v1(98.23,88) 98.23,88.5 R332.2 ; v1(94.52,103.73) U8.P2 ; U8.AF14 105.41,113.25 v2(105.41,113.23) ; HD1.13 217.53,17.43 217.36,17.26 v1(217.36,17.13) ; U8.B14 105.02,93.83 v2(104.65,93.46) ; v1(13.04,16.24) 12.13,16.24 12,16.12 RV3.3 ; U8.AF20 v2(110.39,113.23) ; VRAM2.U1 139.81,116.2 v2(140.21,116.61) ; v1(96.45,118.71) 95.92,119.24 R396.2 ; v2(97.12,109.1) U8.Y5 ; v2(109.57,111.63) 109.17,112.03 U8.AD19 ; U1.CK1 97.67,37.15 v2(97.8,37.15) ; v2(108.8,106.21) 109.03,106.44 U8.U18 ; U8.B8 99.96,93.72 99.96,92.29 v2(100.06,92.19) ; v2(136.21,83.01) 136.22,83.01 VRAM1.E1 ; U1.CD20 85.32,40.71 v2(85.64,41.04) 85.6,41.04 U1.CC20 ; v2(99.99,114.46) 99.99,114.26 99.93,114.2 99.93,113.77 U8.AF8 ; VRAM1.B10 139.01,90.6 v2(138.61,90.21) ; v2(93.92,113.22) U8.AF1 ; U1.BY22 84.76,42.99 v2(84.9,42.99) 84.59,42.68 84.59,42.66 U1.CA22 ; U8.Y2 94.45,108.69 v2(94.42,108.72) ; v2(113.73,110.78) 113.33,110.38 U8.AB24 ; v2(97.18,111.58) U8.AC5 ; v2(211.63,40.31) 211.63,40.77 212.27,41.4 CN35.14 ; U8.U26 114.91,106.21 114.53,105.83 v2(114.53,105.81) ; U8.AD15 v2(106.28,112.44) ; CN35.17 214.33,39.9 216.98,37.25 v2(216.98,32.63) ; v1(9.03,14.21) 8.93,14.21 8.24,14.9 CN10.2 ; v2(94.72,114.84) U8.AG2 ; U8.AF17 107.5,113.63 107.1,113.23 107.09,113.23 v2(107.09,113.23) ; v1(212.94,10.76) 213,10.82 HD1.12 ; U8.AE17 107.11,112.43 v2(107.09,112.43) ; U8.AD22 v2(111.23,112.43) U8.AD21 ; CN16.45 v1(28.85,8.24) ; EC7.1 53.58,22.52 53.41,22.35 53.41,21.84 v1(53.27,21.7) ; U8.N10 101.03,102.99 v2(101.31,103.26) 101.56,103.26 U8.P11 102.03,103.78 v2(102.4,104.15) 102.45,104.15 U8.R12 103.48,105.18 v2(103.48,105.23) 103.53,105.23 U8.T13 104.03,105.8 104.53,106.3 104.53,106.3 104.53,106.3 104.96,106.73 U8.U14 v2(105.53,107.23) U8.V15 ; v2(110.41,112.43) 110.39,112.43 U8.AE20 ; v2(184.66,28.04) 184.57,28.13 CN17.13 182.31,28.13 181.98,28.46 v2(181.98,29.15) ; U8.AB17 107.87,110.75 v2(107.87,110.77) ; U9.3 95.55,124.33 95.06,124.83 95.06,125.08 v1(94.55,125.59) ; U8.U2 95.13,106.15 94.83,105.85 94.55,105.85 v2(94.5,105.9) ; v2(107.77,99.22) 107.77,99.47 U8.K17 108.39,100.09 v2(108.39,100.15) 108.44,100.15 109.01,100.73 U8.L18 ; v2(102.95,113.22) 102.94,113.22 U8.AE11 ; U8.L2 95.16,101.25 95.57,100.84 v2(95.57,100.83) ; U8.U10 101.5,107.2 v2(101.5,107.23) 101.53,107.23 U8.V11 ; U8.AB20 v2(109.59,110.79) ; U8.K15 106.22,99.92 106.5,99.92 v2(106.52,99.95) 106.52,100.13 107.03,100.63 U8.L16 107.03,100.73 107.49,101.19 107.49,101.39 v2(107.52,101.42) 107.72,101.42 U8.M17 108.52,102.22 v2(108.82,102.22) 109.03,102.43 U8.N18 ; v2(116.14,93.08) 115.38,93.08 115.33,93.03 U8.A26 ; CN16.33 31.85,8.41 v1(31.68,8.24) ; VRAM1.C3 138.6,84.61 v2(138.61,84.61) ; CN16.9 37.85,8.06 v1(36.89,7.1) ; U8.AC22 v2(111.26,111.61) ; v2(112.87,114.02) U8.AF23 ; v2(103.8,112.42) 103.78,112.42 U8.AD12 ; CN10.3 8.21,16.9 8.72,17.41 v1(8.95,17.41) ; U8.V17 107.47,107.17 107.45,107.17 v2(107.4,107.12) 107.38,107.1 107.38,107.08 U8.U16 106.59,106.29 v2(106.36,106.29) 106.36,106.06 U8.T15 106.03,105.73 105.78,105.48 v2(105.78,105.24) 105.54,105.24 105.03,104.73 U8.R14 104.63,104.33 v2(104.63,104.12) 104.4,104.12 104.03,103.75 U8.P13 104.03,103.73 v2(103.53,103.23) 103.53,103.23 U8.N12 102.81,102.73 102.42,102.35 v2(102.4,102.35) 102.4,102.2 102.03,101.83 U8.M11 101.81,101.73 101.38,101.31 101.36,101.31 101.31,101.26 101.28,101.26 101.26,101.23 v2(101.23,101.23) 101.23,101.15 101.03,100.95 U8.L10 100.61,100.73 v2(100.39,100.95) ; U8.P23 v2(112.11,103.31) ; U8.K13 104.03,99.76 v2(104.58,100.32) 105,100.73 U8.L14 105.03,100.76 105.55,101.28 105.55,101.41 v2(105.57,101.43) 105.7,101.43 106,101.73 U8.M15 106.11,101.73 106.36,101.98 v2(106.36,102.22) 106.65,102.22 107.03,102.6 U8.N16 v2(107.59,103.29) U8.P17 108.33,104.03 108.45,104.03 108.65,104.23 v2(108.82,104.23) 108.82,104.53 U8.R18 ; U8.AB11 v2(102.97,110.81) ; CN17.75 183.22,12 ; v2(98.87,109.08) 98.87,109.17 U8.AA7 ; C433.1 97.82,121.08 v1(98.11,120.79) ; U8.AF5 97.42,113.79 97.42,114.97 v1(97.32,115.07) ; U8.U5 97.52,106.21 v2(97.12,105.8) ; v2(115.34,114.86) 114.93,114.45 U8.AG26 ; v2(104.56,110.8) 104.97,110.39 U8.AB14 ; CN33.4 73.32,21.93 72.83,22.41 v2(72.83,22.52) ; CN16.27 v1(33.35,8.24) ; v2(102.17,99.05) 102.03,99.19 U8.K11 v2(102.58,100.28) U8.L12 103.57,101.27 v2(103.57,101.29) 103.59,101.29 U8.M13 104.03,101.8 104.55,102.32 104.58,102.32 104.6,102.35 v2(104.63,102.35) 104.65,102.35 U8.N14 105.06,102.73 105.57,103.24 v2(105.6,103.24) 105.6,103.3 U8.P15 106.03,103.73 106.36,104.06 v2(106.36,104.25) 106.55,104.25 107.03,104.73 U8.R16 107.53,105.23 108.03,105.73 U8.T17 ; U8.Y23 v2(112.11,109.11) ; CN16.15 v1(36.35,8.24) ; CN14.5 58.45,21.67 58.61,21.83 59.12,21.83 59.44,22.15 EC8.2 59.98,22.52 60.88,21.61 60.88,20.76 61.44,20.2 63.61,20.2 v2(63.99,19.82) ; CN16.21 v1(34.85,8.24) ; v2(104.61,111.63) 104.21,112.03 U8.AD13 ; v2(107.93,111.63) 108.33,112.03 U8.AD18 ; v1(9.84,16.12) RV3.8 ; v2(138.61,113.41) 138.61,113.4 VRAM2.T5 ; v1(103.39,124.2) R325.1 C452.1 ; U8.AD16 v2(106.27,111.63) ; v2(105.41,112.43) 105.41,112.45 U8.AE14 ; v2(97.13,103.33) U8.P5
  BOTTOM w0.33: VRAM2.A14 127.01,105.8 v2(126.63,105.42) ; VRAM2.C14 128.61,105.8 v2(128.21,105.41) ; v2(138.61,109.41) 139.01,109.01 VRAM2.T10 ; VRAM2.C12 128.59,107.4 v2(128.21,107.78) 128.22,107.78 128.61,108.17 VRAM2.C11 ; VRAM1.R3 128.64,85 v2(129,85.37) 128.61,85.76 VRAM1.R4 ; VRAM2.B5 127.81,113 128.2,113.4 v2(128.21,113.4) 128.21,113.4 VRAM2.C4 ; VRAM1.G5 135.01,86.61 v2(135.41,87.01) 135.81,86.61 VRAM1.F5 ; v2(134.61,94.21) 134.21,93.81 VRAM1.H14 ; VRAM1.B5 139.02,86.6 v2(139.41,86.21) ; VRAM2.R14 138.21,105.8 v2(137.81,105.41) ; VRAM2.K2 133.81,115.8 v2(133.81,115.81) 133.82,115.81 VRAM2.K1 ; VRAM1.R11 128.61,91.4 v2(129.01,91.81) 128.62,92.2 VRAM1.R12 ; VRAM2.P10 137.41,109.01 v2(137.81,109.41) ; VRAM1.D10 137.41,90.61 v2(137.01,91.01) ; VRAM1.J1 133.42,83.4 v2(133.81,83.01) 134.21,83.4 VRAM1.H1 ; v2(132.21,93.41) 132.61,93.01 VRAM1.K13 ; v2(133.01,109.46) 133.01,109.41 133.41,109.01 VRAM2.J10 ; VRAM2.F5 131.02,113 131.41,112.61 v2(131.41,112.61) 131.42,112.61 131.81,113 VRAM2.G5 ; VRAM2.L10 135.01,109.01 135.41,109.41 ; VRAM1.C11 138.21,91.41 v2(137.81,91.81) ; VRAM2.A1 v2(126.57,116.64) ; v2(126.43,92.06) 126.57,92.2 VRAM1.U12 ; v2(129.01,109.46) 129.01,109.41 129.41,109.01 VRAM2.D10 ; v2(137.01,84.61) 136.62,85 VRAM1.E3 ; VRAM1.R1 128.61,83.4 v2(128.21,83.01) ; VRAM1.L10 131.81,90.6 v2(131.41,90.21) 131.02,90.6 VRAM1.M10 ; VRAM1.C1 138.21,83.4 v2(137.81,83.01) ; v2(136.21,116.56) 136.26,116.56 136.61,116.21 VRAM2.N1 ; VRAM2.U3 139.82,114.6 v2(140.21,114.21) ; VRAM2.K13 134.21,106.55 v2(133.81,106.16) 133.85,106.16 VRAM2.K14 ; VRAM2.A3 126.65,114.96 v2(126.62,114.96) ; VRAM2.R3 138.22,114.6 v2(138.61,114.21) 138.21,113.8 VRAM2.R4 ; VRAM2.R12 138.6,107.01 v2(138.61,107.01) ; v2(129.82,116.59) VRAM2.E1 ; VRAM1.A1 139.81,83.4 v2(139.41,83.01) ; VRAM1.K2 132.61,84.2 v2(132.21,83.81) 132.61,83.41 VRAM1.K1 ; v2(136.21,91.81) 136.61,92.2 VRAM1.E12 ; VRAM1.A12 139.82,92.2 v2(140.21,91.81) ; v2(126.66,107.78) 126.66,107.75 VRAM2.A12 ; VRAM2.M10 135.81,109.01 135.41,109.41 ; VRAM2.U12 140.21,107.8 v2(140.21,107.81) ; VRAM2.C1 128.98,115.83 v2(129.01,115.83) ; VRAM1.E14 136.61,93.81 v2(136.21,94.21) ; v2(135.41,109.46) 135.41,109.41 ; v2(127.42,90.19) 127.81,90.59 VRAM1.T10 ; v2(128.21,86.21) 127.82,86.6 VRAM1.T5 ; VRAM1.C12 138.21,92.21 v2(137.81,92.61) ; VRAM2.U14 139.82,105.8 v2(140.21,105.41) ; VRAM1.R14 128.61,93.81 v2(128.21,94.21) ; VRAM1.C14 138.21,93.81 v2(137.81,94.21) ; VRAM1.N12 130.21,92.21 v2(129.81,92.61) ; v2(129.81,114.96) 129.86,114.96 130.21,114.61 VRAM2.E3 ; VRAM2.F10 131.06,109 v2(131.41,108.64) ; VRAM1.H13 134.21,93.01 v2(134.61,93.41) ; v2(132.21,116.61) 132.61,116.21 VRAM2.H1 ; v2(129.82,94.19) VRAM1.N14 ; VRAM1.G10 135.02,90.6 v2(135.41,90.21) 135.81,90.6 VRAM1.F10 ; v2(127.39,85.38) VRAM1.U3 ; v2(130.21,105.27) VRAM2.E14 ; VRAM1.L5 131.81,86.61 v2(131.41,87.01) 131.01,86.6 VRAM1.M5 ; VRAM2.H14 132.57,105.8 v2(132.21,106.16) 132.21,106.2 VRAM2.H13 ; VRAM2.M5 135.81,113 v2(135.41,112.61) 135.02,113 VRAM2.L5 ; v2(137.01,105.41) 136.62,105.8 VRAM2.N14 ; v2(131.26,109.46) 131.35,109.46 VRAM2.G10 ; v2(129.79,82.47) 130.21,82.89 VRAM1.N1 ; v2(129.03,90.22) VRAM1.P10 ; VRAM2.C3 128.61,114.6 128.61,114.61 128.26,114.96 v2(128.21,114.96) ; v2(133.81,83.81) 134.21,84.2 VRAM1.H2 ; v2(140.21,84.61) 139.82,85 VRAM1.A3 ; v2(140.21,94.21) 139.81,93.8 VRAM1.A14 ; VRAM1.N3 130.21,85 v2(130.61,85.41) ; VRAM1.K14 132.61,93.81 v2(132.21,94.21) ; v2(137.01,106.97) 137.01,107 VRAM2.N12 ; VRAM2.R1 138.21,116.21 v2(137.81,116.61) ; v2(138.61,107.81) 138.22,108.2 VRAM2.R11 ; v2(126.5,93.53) 126.77,93.8 VRAM1.U14 ; v2(133.01,116.61) 133.41,116.21 VRAM2.J1 ; VRAM1.U1 v2(126.6,82.99)
  BOTTOM w0.356: v2(69.02,22.71) 69.16,22.85 C695.2 ; R315.1 120.1,99.05 120.58,99.53 v1(120.58,100.06) ; U8.E22 111.68,96.23 v2(112.07,95.84) ; v1(132.9,98.67) 132.9,98.17 R405.1 ; VRAM2.H2 VRAM2.H1 ; v2(138.61,85.41) 138.22,85.8 VRAM1.C4 ; VRAM2.B10 127.84,109 128.2,108.64 v2(128.21,108.64)
  BOTTOM w0.381: v1(208.24,38.64) 208.24,38 C565.2 ; R354.1 91.25,94.98 91.27,94.96 v2(93.48,94.96) ; v2(114.44,20.23) 114.44,19.11 115,18.55 CN36.6 ; U3.2 61.15,26.02 61.1,26.07 60.82,26.07 v2(60.74,26.15) 60.74,26.11 60.36,25.73 C247.1 ; v1(62.8,105.65) 63,105.45 SW3.1 ; C20001.1 56.51,103.43 56.7,103.24 C546.1 ; v2(180.77,19.15) 180.77,19.34 EC13.2 ; v1(211.9,31.2) 211.87,31.2 211.59,31.48 C574.2 ; v2(121.65,18.22) 121.58,18.22 121.55,18.2 121.3,18.2 120.7,17.6 CN36.5 ; v1(100.77,120.86) 100.38,120.47 U11.3 ; VRAM1.J10 133.41,90.66 v2(133.79,91.05) ; Q6508.2 17.75,81.44 17.38,81.44 v1(16.93,81.9) ; v1(67.83,42.02) 67.7,41.9 EC1.1 ; v1(143.27,51.04) 143.44,51.04 143.82,51.42 PC7019.2 ; v2(75.02,19.77) 75.63,19.77 76.12,19.28 76.77,19.28 77.5,18.55 CN33.9 ; v2(176.24,32.91) 176.24,32.47 176.65,32.06 FAN3.4 ; v2(100.77,86.3) 100.48,86 Y3.4 ; CN33.10 66.38,18.55 65.85,18.02 64.14,18.02 63.66,18.49 v2(63.66,18.68) ; PU3002.4 104.16,25.81 103.73,26.24 PC6228.2 103.13,26.24 102.75,26.62 102.75,26.72 v2(102.72,26.74) ; C20002.1 57.19,103.84 57.15,103.8 C546.1 ; C595.2 211.16,30.39 211.64,29.91 211.65,29.91 v1(211.67,29.93) ; v1(129.65,23) 129.2,22.54 128.7,22.54 C777.2 ; C546.1 57.15,102.56 v2(58.46,101.26) ; v1(101.87,89.8) 101.87,89.57 102.31,89.13 C463.2 102.31,88.56 101.87,88.13 Y3.2 ; v2(67.73,34.25) 67.2,34.25 R25392.1 ; C567.2 207.23,39.1 v1(207.45,39.1) ; v1(63.18,44.44) 63.21,44.44 63.47,44.17 C215.1 ; PC292.1 v1(67.1,114.05) ; v1(64.83,98.06) 64.83,98.54 64.45,98.92 63.43,98.92 63,98.48 SW3.2 ; v2(103.57,91.68) 104.84,90.41 105.47,90.41 105.86,90.02 R350.1 R351.1 ; R356.1 89.93,97.14 v1(89.42,97.65) 89.93,98.16 R313.2 ; C575.2 212.02,33.38 v1(212.02,33.56) ; R358.1 89.92,94.14 89.34,94.14 v1(89.22,94.02) ; v2(68.46,33.51) 68.29,33.51 67.98,33.21 R88.1 ; v2(36.74,14.11) 36.7,14.15 36.7,14.88 PC6046.2 ; v1(185.76,33.13) 185.71,33.13 185.66,33.18 184.47,33.18 184,32.72 CN17.76 ; v1(20.81,31.58) 20.06,30.83 PQ19.1 ; R25385.1 79.33,25.33 v1(79.26,25.26) ; R353.1 89.52,96.13 89.5,96.1 v1(89.44,96.1) ; R355.1 v1(89.22,92.95) ; C584.2 202.42,26.83 203.01,26.25 v2(203.39,26.25) 203.31,26.33 203.31,26.77 C578.2 204.56,26.98 C587.1 ; v2(79.61,32.35) 79.67,32.29 79.67,32.04 80.06,31.65 C209.1 ; R25380.1 84.55,24.3 v2(85.13,24.88) ; R25501.2 R84.1 v1(65.59,43.42) ; v2(68.16,31.88) 68.11,31.88 68,31.99 67.15,31.99 R25386.1 R73.1 ; v1(144.3,53.17) 143.8,52.68 PC7024.2 ; C580.2 209.13,28.87 209,28.99 v2(209,29.2) ; v2(136.74,18.45) 137.78,19.49 137.78,20.76 138.09,21.08 C779.2 ; PC9022.2 103.12,120.71 C387.1 103.12,119.05 102.37,118.3 102.37,117.46 v1(102.12,117.21) ; v1(67.63,115.56) 67.36,115.56 PC290.1 ; v2(152.77,26.83) 152.77,26.91 152.77,26.91 152.79,26.91 152.94,27.05 PC6027.2 ; C218.1 64.44,46.35 v1(63.92,46.87) 63.55,47.24 C213.1 ; v1(108.55,26.74) 108.47,26.82 PR3021.2 108.31,27.46 107.61,26.76 PU3002.2 ; CN18.30 144.71,17.69 142.51,17.69 141.87,17.05 v2(141.87,16.83) ; PQ7.1 108.1,42.8 v1(107.83,42.53) ; v1(138.24,17.69) 138.24,18.46 138.74,18.96 C780.2 ; C6560.2 15.01,82.4 15.04,82.37 D50.1 15.99,82.37 v2(16.44,82.82) ; R25378.1 85.25,31.66 84.97,31.94 84.97,32.55 v2(84.92,32.6) ; CN14.9 61.53,17.56 v2(61.53,17.05) ; C446.1 120.52,103.33 v1(120.23,103.62) 119.94,103.33 C451.1 ; C6617.1 66.4,26.29 65.76,25.65 v1(65.76,25.5) ; CN14.10 57.92,18.15 58.74,17.34 v2(58.74,16.8) ; PU7002.9 117.59,69.12 117.54,69.07 v3(117.49,69.07) ; v2(74.2,98.77) 74.2,98.79 73.82,99.17 73.59,99.17 PR9082.1 72.34,99.42 PC9069.2 ; v1(212.36,27.47) 211.81,26.93 C581.2 ; R45.2 63.71,41.9 v1(63.33,42.28) ; Y2.4 99.53,26.47 v2(99.53,25.77) ; v1(17.21,58.15) 17.51,58.15 18.23,57.43 C514.1 ; R25387.1 65.64,32.86 v1(65.72,32.79) ; v2(91.5,50.02) 91.5,49.99 91.81,49.68 U1.BK10 ; R311.2 v1(104.48,117.82) ; PU9003.2 75.88,101.46 75.56,101.78 PC9072.2 76.13,102.92 v2(76.13,103.21) 76.19,103.21 76.22,103.18 PQ9010.1 ; VRAM2.N3 136.61,114.6 v2(137.01,115.01) ; v2(59.8,101.33) 59.83,101.36 59.83,101.59 60.39,102.14 C543.1 C544.1 ; v2(195.69,19.93) 195.3,20.31 EC12.2 ; v2(94.3,27.8) 94.3,27.88 94.37,27.95 94.37,28.39 R1.1 ; U8.E20 109.99,96.19 v2(110.39,95.79) ; v1(76.82,26.66) 76.9,26.73 R25431.2 ; v2(73.85,102.91) 73.85,103.4 PQ9009.1 ; C464.2 99.75,89.77 v1(100.11,90.13) ; v2(62.5,101.78) 62.5,101.28 62.35,101.14 SW3.5 ; v2(67.73,35.27) 67.68,35.32 R25391.1 ; v2(102.73,90.71) 103.01,90.44 103.01,90.33 103.3,90.04 R352.1 ; C524.2 203.84,20.81 204.2,21.17 205.97,21.17 206.26,20.88 207.29,20.88 207.68,21.27 U18.2 208.49,21.27 208.95,21.73 v1(209.18,21.73) ; C529.1 204.38,23.96 v2(202.86,23.96) ; PC9073.2 75.37,95.03 v1(75.2,94.86) 75.25,94.8 PC9071.2 ; v2(84.11,29.88) 84.14,29.91 84.14,30.11 84.16,30.14 R25379.1 ; CN29.42 64.15,110.3 62.55,108.7 v1(62.52,108.7) ; Q31.1 196.67,21.82 196.76,21.73 v2(197.24,21.73) ; C734.1 197.83,19.04 197.75,19.11 197.75,19.14 197.75,19.14 197.75,19.16 197.75,19.16 v2(197.75,19.18) ; v1(128.43,121.35) 128.22,121.13 C487.2 127.52,121.65 127.88,122.01 v1(128.43,122.01) ; v1(131.89,23.1) 131.9,23.09 131.9,22.55 131.63,22.29 C774.1 C773.1 ; C9.1 102.09,54.95 102.42,55.28 v1(102.42,55.31) ; C776.1 C775.1 130.62,22.08 131.25,22.72 v1(131.25,23.1) ; C844.1 197.51,29.62 197.81,29.31 R465.2 198.05,29.31 198.25,29.12 198.54,29.12 198.82,28.84 v2(198.82,28.71) ; EC2.1 63.19,50.54 62.93,50.28 v1(62.93,49.9) 63.6,49.9 C214.1 ; C228.1 82.7,32.24 v2(82.48,32.45) ; v1(63.94,51.52) 63.94,51.16 64.19,50.91 R56.1 64.32,50.76 64.32,50.17 C217.1 ; v1(89.33,92.09) 89.94,92.09 R357.1 ; C536.2 64.96,105.13 v1(64.96,104.95) ; C205.1 98.78,29 98.41,29.37 v2(98.41,29.4) ; v2(101.63,27.59) Y2.2 ; R446.1 80.58,96.16 v1(80.58,97.73) 80.58,97.78 80.2,98.16 U19.2 ; v1(26.35,26.63) 25.87,26.15 PU14.8 ; VRAM2.E12 130.23,107.4 v2(130.61,107.78) ; PC7106.1 116.72,68.5 116.52,68.69 v2(116.52,69.07) ; v1(83.55,97.04) 83.65,97.14 83.65,97.42 83.88,97.65 C559.1 ; v2(196.4,31.23) 196.53,31.36 C588.2 ; R479.2 v1(211.67,29.3) ; CN18.29 177.47,19.08 178.51,20.12 v2(178.51,20.38) ; C230.1 v1(98.06,31.51)
  BOTTOM w0.406: v1(12.48,18.66) 12.25,18.66 12,18.4 C691.1 ; RV1.3 11.77,10.42 11.49,10.15 v1(10.35,10.15)
  BOTTOM w0.457: v2(40.93,106.49) 40.93,106.19 C548.2
  BOTTOM w0.508: v1(43.95,105.79) C547.2 ; PR9030.1 69.74,115.87 69.23,116.38 v1(69.23,117.13) ; v1(14.31,43.19) 14.79,43.67 C515.1 ; CN29.41 42.15,111.54 42.66,112.05 v1(43.11,112.05) ; C70.1 C69.1 100.26,64.24 v2(100.14,64.12) ; PC7063.1 135.06,50.31 v1(135.06,50.79) ; JDIM1.261 44.67,96.63 45.56,97.52 v1(45.65,97.52) ; C6545.2 13.47,21.84 13.3,22.02 v1(13.3,22.47) ; PJ1.10 v1(92.35,14.44) ; v1(19.65,39.52) 19.68,39.54 20.39,39.54 PQ12.1 ; PC16.2 128.97,33.06 128.51,33.51 128.51,33.88 v2(128.22,34.17) ; v1(20.84,35.44) 20.44,35.84 PQ9050.1 ; 166.18,30.34 164.2,32.32 v2(164.2,34.1) ; 166.18,30.34 SW1.4 ; 166.18,30.34 166.15,30.34 165.72,29.91 165.72,27.77 166.1,27.39 SW1.3 ; C363.1 119.7,121.91 v1(119.7,122.16) ; PQ14.1 20.06,32.48 v1(19.62,32.04) ; C676.1 10.22,12.46 v1(10.35,12.33) ; v1(128.26,80.2) 129.26,80.2 C499.1 ; C6546.2 14.44,21.84 v1(13.95,22.33) ; 214.82,12.32 v2(215.71,12.32) ; PJ1.9 112.55,15.95 111.52,14.92 v2(111.52,14.85) ; CN13.6 200.1,10.95 v2(199.32,11.72) ; C383.1 119.7,118.99 v1(119.7,119.24) ; CN1.2 13.67,5.45 v1(14.29,4.84) ; 77.4,106.41 PR9077.2 ; C737.1 200.21,15.86 v2(200.87,16.52) ; v1(128,23.25) 127.09,23.25 126.6,23.74 C778.2 125.89,23.2 CN19.30 ; v1(64.81,125.59) 64.81,125.2 65.41,124.6 PC302.2 ; v1(137.58,78.29) 137.69,78.41 C473.2 ; CN19.29 155.87,23.06 v1(154.37,21.55) ; v2(130.39,26.32) 130.38,26.33 130.37,26.33 129.98,26.71 PC4.1 ; C516.1 14.69,44.94 13.83,44.08 v1(13.83,43.75) ; v1(12.63,13.83) D17.1 ; v1(23.25,42.02) 23.25,42 23.23,41.97 23.18,41.97 22.94,41.73 C512.2 ; v1(19.98,6.17) 19.98,6.6 20.25,6.87 CN16.77 ; 126.65,12.72 CN15.20 ; PC221.2 121.62,34.36 v1(122.02,34.36) ; C6503.2 29.98,13.2 30.49,12.69 v1(30.49,12.23) ; v1(131.51,103.75) 131.51,102.85 R406.1 ; v1(65.42,107.43) 65.48,107.43 C537.2 ; JDIM1.262 42.35,30.51 v1(43.57,31.74) ; v2(215.73,13.17) 215.1,13.17 214.82,13.45 ; 93.84,21.7 93.84,22.8 93.73,22.91 PC168.2 PC167.1 ; v1(47.52,9.14) 48.16,9.14 CN24.5 48.29,8.49 v1(47.57,8.49) ; v1(67.17,112.76) 67.17,110.9 C542.2 ; PC7052.2 130.87,43.29 v2(129.75,42.18) ; C504.2 135.06,79.74 v1(135.7,79.11) ; v1(116.01,118.61) R312.1 ; v2(40.32,15.86) 41.29,15.86 41.46,15.68 PC6055.1 42.17,16.62 PC6058.2 ; PQ9011.1 71.66,106.41 v1(71.28,106.41) ; v1(209.46,10.78) 208.59,10.78 CN13.5 ; C619.2 24.16,81.38 v1(24.42,81.65) ; C1691.2 22.13,83.23 22.13,85.36 v1(21.78,85.71) ; C349.1 120.28,120.43 v1(120.33,120.38) ; v1(35.24,104.38) 35.24,105.17 36.08,106.01 37.7,106.01 39.22,107.52 U25.25 ; v1(132.01,79.16) 132.15,79.29 C497.1 ; v1(136.74,45.15) 137.22,45.63 PR7033.2 ; CN38.1 33.9,116.63 v1(34.48,117.21) ; v2(207.58,25.84) 207.68,25.74 207.99,25.74 208.15,25.58 C665.2 209.1,26.39 C583.1 ; v1(12.03,22.32) 12.03,22.29 C6544.2 ; v2(216.7,28.21) 216.35,27.86 CN35.42 ; D13092.1 39.64,121.21 39.42,121.43 D13091.1 38,121.43 v1(37.15,122.29) 36.66,121.8 v2(36.66,121.78) ; v2(217.53,10.2) HD1.14 ; PC6014.2 160.53,36.24 160.34,36.44 160.34,36.49 v2(159.95,36.87) ; v1(27.01,13.27) 27.48,13.74 C6548.2 ; EC6500.2 11.2,22.23 10.35,21.37 v1(10.02,21.37) ; v1(10.6,19.17) D16.1 ; CN15.19 138.55,12.74 ; PR7104.1 132.74,53.17 132.7,53.17 v1(132.17,52.64) ; v1(117.54,118.61) C377.1 ; U15.2 v1(19.11,44.18) ; v1(34.2,13.7) 34.06,13.57 33.34,13.57 33.07,13.84 PC6050.2 ; v1(120.96,119.24) C381.1
  vias: v1(0.51,122.39) v1(0.51,105.17) v1(0.52,26.94) v1(0.72,25.51) v1(0.84,111.21) v1(1.74,23) v1(1.78,122.39) v1(1.79,27.13) v1(2,24.57) v1(2.11,111.09) v1(2.11,109.82) v1(2.11,108.55) v1(2.11,107.28) v1(2.11,106.01) v1(2.11,65.09) v1(2.11,63.82) v1(2.11,62.55) v1(2.58,21.16) v1(3.05,122.39) v1(2.96,61.75) v1(3.06,27.13) v1(3.25,46.93) v1(3.25,45.73) v1(3.25,44.46) v1(3.25,43.19) v1(3.85,21.63) v1(3.9,103.93) v1(3.9,88.49) v1(4.32,122.39) v1(4.3,120.71) v1(4.25,112.38) v1(4.33,27.13) v1(4.52,47.13) v1(4.68,87.49) v1(4.86,84.41) v1(4.86,67.99) v1(5.11,20.48) v1(5.11,19.21) v1(5.11,12.1) v1(5.07,10.83) v1(5.4,44.36) v1(5.52,120.71) v1(5.59,122.39) v1(5.6,112.41) v1(5.6,27.13) v1(5.79,47.13) v1(5.95,87.29) v1(6.03,84.41) v1(5.95,41.75) v1(6.13,67.99) v1(6.08,61.75) v1(6.06,45.55) v1(6.11,43.47) v1(6.18,105.27) v1(6.69,112.81) v1(6.86,122.39) v1(6.97,120.39) v1(7.02,84.7) v1(7.12,87.51) v1(7.2,67.5) v1(7.22,41.75) v1(7.43,88.49) v1(7.35,61.75) v1(7.38,44.36) v1(8.08,122.26) v1(8.14,85.33) v1(8.34,103.96) v1(8.34,67.09) v1(8.42,88.49) v1(8.42,62.19) v1(8.42,42.2) v1(8.98,121.37) v1(8.96,119.92) v1(8.98,46.53) v1(8.98,26.53) v1(9.36,84.72) v1(9.38,67.68) v1(9.54,44.33) v1(9.61,82.1) v1(9.61,70.65) v1(9.59,62.35) v1(9.61,42.35) v1(10.25,120.89) v1(10.25,46.53) v1(10.25,26.53) v1(10.86,62.35) v1(10.88,42.35) v1(10.96,44.23) v1(11.34,46.11) v1(11.52,120.89) v1(11.47,26.07) v1(11.78,88.78) v1(11.77,42.86) v1(12,103.26) v1(11.97,62.83) v1(12.21,0.51) v1(12.48,46.34) v1(12.69,26.66) v1(12.79,120.89) v1(12.76,61.96) v1(12.76,59.55) v1(12.76,49.26) v1(12.76,41.97) v1(12.76,39.56) v1(12.76,29.32) v1(13.55,18.02) v1(13.48,0.51) v1(14.06,120.89) v1(14.49,119.87) v1(14.72,118.76) v1(14.72,42) v1(14.75,0.51) v1(14.79,79.74) v1(14.79,77.71) v1(14.79,75.78) v1(15.56,113.02) v1(15.81,118.39) v1(15.94,112.51) v1(16.02,0.51) v1(16.32,113.14) v1(16.57,112.51) v1(17.08,118.39) v1(17.08,10.6) v1(17.29,0.51) v1(17.46,114.67) v1(17.74,10.6) v1(18.1,22.34) v1(18.35,118.39) v1(18.56,0.51) v1(18.73,34.71) v1(18.73,34.07) v1(18.98,41.9) v1(18.98,41.26) v1(19.24,97.9) v1(19.24,97.27) v1(19.24,96.63) v1(19.24,55.23) v1(19.24,54.6) v1(19.24,53.07) v1(19.37,40.75) v1(19.62,118.39) v1(19.62,49.14) v1(19.62,48.12) v1(19.7,114.87) v1(19.83,0.51) v1(20.13,55.21) v1(20.23,13.04) v1(20.48,12.46) v1(20.64,49.14) v1(20.64,48.12) v1(20.66,11.85) v1(20.89,118.39) v1(21.1,0.51) v1(21.5,93.59) v1(22.01,46.32) v1(22.08,26.91) v1(22.16,118.39) v1(22.37,0.51) v1(22.46,26.4) v1(22.54,12.84) v1(22.59,93.59) v1(22.85,72.35) v1(23.23,21.8) v1(23.28,6.67) v1(23.43,118.39) v1(23.35,93.59) v1(23.46,5.42) v1(23.63,45.17) v1(23.56,6.08) v1(23.64,0.51) v1(23.94,6.59) v1(24.29,85.81) v1(24.65,6.62) v1(24.7,118.39) v1(24.91,0.51) v1(25.16,35.7) v1(25.33,85.97) v1(25.33,85.33) v1(25.97,118.39) v1(26.2,86.09) v1(26.25,72.12) v1(26.18,0.51) v1(26.48,21.4) v1(26.6,36.31) v1(26.99,72.48) v1(26.99,71.84) v1(26.99,71.21) v1(26.96,21.83) v1(26.99,21.02) v1(27.24,118.39) v1(27.37,23.48) v1(27.45,0.51) v1(27.62,80.25) v1(27.62,78.35) v1(27.62,76.44) v1(27.62,74.54) v1(28,24.24) v1(28.51,118.39) v1(28.57,104.4) v1(28.72,0.51) v1(28.97,21.32) v1(29.5,104.38) v1(29.68,21.17) v1(29.78,118.39) v1(29.99,0.51) v1(30.62,21.32) v1(31.05,118.39) v1(31.26,0.51) v1(31.46,22.92) v1(31.56,104.38) v1(31.68,87.29) v1(32.19,89.04) v1(32.49,104.39) v1(32.6,0.52) v1(33.6,118.95) v1(33.71,122.69) v1(33.71,121.42) v1(33.71,120.15) v1(33.84,31.86) v1(33.8,0.51) v1(34.48,31.86) v1(35.11,31.86) v1(35.11,6.53) v1(35.07,0.51) v1(35.75,31.86) v1(35.75,15.86) v1(35.75,5.24) v1(36,119.62) v1(36,118.86) v1(36,118.1) v1(36.34,0.51) v1(36.38,5.24) v1(36.61,124.29) v1(37.43,13.19) v1(37.61,0.51) v1(38.37,124.32) v1(38.44,14.46) v1(38.87,26.96) v1(38.87,15.91) v1(38.88,0.51) v1(39.15,107) v1(39.64,124.32) v1(39.66,113.09) v1(40.15,0.51) v1(40.42,112.86) v1(40.91,124.32) v1(41.06,112.86) v1(41.29,54.27) v1(41.36,66.13) v1(41.42,0.75) v1(41.49,3.29) v1(41.49,2.02) v1(41.72,31.53) v1(41.87,65.75) v1(42.1,68.69) v1(42.18,124.32) v1(42.38,66.13) v1(42.43,21.7) v1(42.53,54.27) v1(42.73,68.69) v1(42.81,59.22) v1(42.89,65.75) v1(43.06,21.7) v1(43.45,124.32) v1(43.39,66.13) v1(43.45,59.22) v1(43.62,104.63) v1(43.62,100.7) v1(43.7,21.7) v1(43.9,65.75) v1(44.01,60.79) v1(44.08,59.22) v1(44.11,21.12) v1(44.26,68.69) v1(44.36,70.34) v1(44.41,66.13) v1(44.46,21.7) v1(44.64,105.4) v1(44.72,124.32) v1(44.72,59.22) v1(44.82,21.12) v1(44.89,68.69) v1(44.92,65.75) v1(44.89,54.34) v1(44.99,70.34) v1(45.22,100.82) v1(45.17,21.65) v1(45.43,66.13) v1(45.35,59.22) v1(45.5,104.68) v1(45.53,68.69) v1(45.55,21.12) v1(45.55,6.51) v1(45.78,60.8) v1(45.93,65.75) v1(45.99,124.32) v1(46.09,54.88) v1(46.16,68.69) v1(46.38,100.96) v1(46.44,97.52) v1(46.44,66.13) v1(46.82,6.51) v1(46.95,65.75) v1(47.08,97.52) v1(47.26,124.32) v1(47.31,122.46) v1(47.31,121.83) v1(47.31,100.82) v1(47.51,27.93) v1(48.07,97.52) v1(48.09,6.51) v1(48.17,60.01) v1(48.53,124.32) v1(48.83,81.53) v1(48.83,60.01) v1(48.83,27.93) v1(48.83,15.61) v1(48.96,97.52) v1(49.24,15.05) v1(49.37,126.76) v1(49.37,125.49) v1(49.36,6.51) v1(49.46,27.93) v1(49.46,15.68) v1(49.92,11.34) v1(49.89,10.07) v1(49.89,8.8) v1(49.89,7.53) v1(50.1,27.93) v1(50.25,127.49) v1(50.79,12.38) v1(51.52,127.49) v1(52.06,12.51) v1(52.31,59.96) v1(52.26,35.7) v1(52.44,72.94) v1(52.79,127.49) v1(52.92,81.16) v1(53.1,124.19) v1(53.1,66.2) v1(53.33,12.51) v1(53.5,76.95) v1(53.55,67.12) v1(53.55,62.29) v1(53.58,43.98) v1(53.78,88.94) v1(54.06,127.49) v1(54.27,57.77) v1(54.54,71.36) v1(54.6,12.51) v1(54.85,82.79) v1(55,61.25) v1(55.08,40.07) v1(55.18,54.85) v1(55.18,50.74) v1(55.33,127.49) v1(55.28,124.73) v1(55.28,124.09) v1(55.26,94.09) v1(55.64,63.51) v1(55.89,78.78) v1(55.87,12.51) v1(56.07,56.25) v1(56.17,59.96) v1(56.42,89.67) v1(56.6,127.49) v1(56.83,82.84) v1(57.14,12.51) v1(57.87,127.49) v1(58.2,119.06) v1(58.2,118.43) v1(58.41,12.51) v1(58.53,124.12) v1(58.84,119.06) v1(58.85,118.43) v1(58.88,117.74) v1(59.14,127.49) v1(59.45,121.07) v1(59.49,119.06) v1(59.49,118.43) v1(59.51,117.74) v1(59.7,108.34) v1(59.68,12.51) v1(59.93,123.71) v1(60.12,119.06) v1(60.12,118.43) v1(60.15,117.74) v1(60.41,127.49) v1(60.77,118.4) v1(60.78,117.74) v1(60.95,12.51) v1(61.43,117.64) v1(61.68,127.49) v1(62.22,12.51) v1(62.6,71.46) v1(62.95,127.49) v1(63,65.63) v1(63.23,71.46) v1(63.23,61.45) v1(63.31,55.26) v1(63.49,12.51) v1(63.69,65.65) v1(63.89,82.79) v1(63.87,71.46) v1(63.87,61.49) v1(63.94,55.26) v1(64.22,127.49) v1(64.32,65.65) v1(64.59,82.79) v1(64.58,61.45) v1(64.58,55.26) v1(64.76,12.51) v1(65.21,61.45) v1(65.29,82.79) v1(65.49,127.49) v1(65.99,82.79) v1(66.03,12.51) v1(66.76,127.49) v1(67.3,12.51) v1(67.63,99.55) v1(68.03,127.49) v1(68.11,125.56) v1(68.26,99.55) v1(68.54,123.91) v1(68.57,12.51) v1(68.74,125.56) v1(69.3,127.49) v1(69.84,12.51) v1(70.57,127.49) v1(71.11,12.51) v1(71.84,127.49) v1(72.38,12.51) v1(73.11,127.49) v1(73.09,111.62) v1(73.09,110.73) v1(73.11,109.84) v1(73.65,12.51) v1(73.98,111.62) v1(73.98,110.86) v1(73.98,109.84) v1(74.38,127.49) v1(74.92,12.51) v1(74.99,111.62) v1(74.99,110.73) v1(74.99,109.84) v1(75.09,122.03) v1(75.58,92.87) v1(75.65,127.49) v1(75.65,122.36) v1(75.73,110.98) v1(75.7,86.85) v1(75.93,92.34) v1(76.13,87.36) v1(76.21,125.21) v1(76.2,124.57) v1(76.2,123.94) v1(76.19,123.25) v1(76.19,12.51) v1(76.39,91.88) v1(76.39,88) v1(76.49,91.25) v1(76.54,86.85) v1(76.83,124.55) v1(76.83,123.91) v1(76.82,123.25) v1(76.92,127.49) v1(77.48,123.99) v1(77.46,123.25) v1(77.53,94.86) v1(77.46,12.51) v1(77.61,107.05) v1(78.14,123.25) v1(78.19,127.49) v1(78.17,108.04) v1(78.24,107.05) v1(78.65,29.91) v1(78.73,12.51) v1(79.01,122.92) v1(79.01,122.29) v1(79.23,125.39) v1(79.31,29.91) v1(79.74,120.99) v1(79.74,94.83) v1(79.76,122.9) v1(79.76,122.26) v1(79.76,121.63) v1(79.82,101.43) v1(79.92,108.09) v1(79.92,107.45) v1(79.92,106.81) v1(80,12.51) v1(80.39,122.9) v1(80.39,122.26) v1(80.39,121.63) v1(80.38,120.99) v1(80.43,95.19) v1(80.5,125.39) v1(80.55,108.09) v1(80.55,107.45) v1(80.55,106.81) v1(81.04,122.92) v1(81.04,122.24) v1(81.04,121.6) v1(81.19,108.09) v1(81.19,107.45) v1(81.19,106.81) v1(81.27,12.51) v1(81.37,101.43) v1(81.77,125.39) v1(81.82,108.09) v1(81.82,107.45) v1(81.82,106.81) v1(82,101.43) v1(82.61,91.63) v1(83.04,125.39) v1(83.12,57.67) v1(83.15,57.03) v1(83.15,56.4) v1(83.12,55.76) v1(83.12,53.17) v1(83.25,52.54) v1(83.93,89.85) v1(84.31,125.39) v1(84.39,105.75) v1(84.39,105.12) v1(85.38,89.88) v1(85.41,71.49) v1(85.41,70.86) v1(85.41,70.22) v1(85.41,69.59) v1(85.56,125.44) v1(86.07,105.35) v1(86.07,104.71) v1(86.09,104.08) v1(86.21,126.4) v1(86.29,105.95) v1(86.4,103.49) v1(86.7,127.49) v1(86.7,105.35) v1(86.7,104.71) v1(86.73,104.08) v1(86.75,102.96) v1(87.06,103.52) v1(87.34,104.71) v1(87.44,104.02) v1(87.54,103.06) v1(87.56,84.19) v1(87.56,83.55) v1(87.56,82.92) v1(87.56,82.28) v1(87.97,127.49) v1(88.38,118.81) v1(88.89,71.74) v1(88.89,71.11) v1(88.94,70.47) v1(88.91,69.84) v1(88.91,69.2) v1(89.42,118.55) v1(90.13,83.55) v1(90.18,84.19) v1(90.18,82.92) v1(90.18,82.28) v1(90.97,63.65) v1(91.09,64.28) v1(91.15,12.51) v1(91.58,114.54) v1(91.57,113.73) v1(91.58,113.09) v1(91.58,112.41) v1(91.76,85.58) v1(92.21,114.54) v1(92.21,113.73) v1(92.24,113.09) v1(92.21,112.41) v1(92.24,12.51) v1(92.64,110.73) v1(93.05,127.49) v1(93.33,85.58) v1(93.38,21.73) v1(93.51,12.51) v1(93.61,109.38) v1(94.32,127.49) v1(94.78,12.51) v1(95.59,127.49) v1(96.05,12.51) v1(96.86,127.49) v1(97.32,12.51) v1(97.78,118.6) v1(98.13,127.49) v1(98.59,12.51) v1(99.4,127.49) v1(99.86,12.51) v1(100.49,16.29) v1(100.67,127.49) v1(101.13,16.29) v1(101.13,12.51) v1(101.33,29.63) v1(101.69,15.99) v1(101.94,127.49) v1(101.89,76.69) v1(101.99,44.84) v1(102.17,75.37) v1(102.4,12.51) v1(102.63,44.84) v1(103.21,127.49) v1(103.67,12.51) v1(103.85,37.73) v1(104.48,127.49) v1(104.94,12.51) v1(104.99,122.67) v1(105.34,17.66) v1(105.34,17.03) v1(105.73,51.12) v1(105.75,127.49) v1(105.85,51.75) v1(105.98,17.66) v1(105.98,17.03) v1(106.21,12.51) v1(106.36,51.24) v1(106.61,17.66) v1(106.61,17.03) v1(107.02,127.49) v1(107.25,17.66) v1(107.25,17.03) v1(107.5,52.82) v1(107.48,12.51) v1(107.73,32.5) v1(107.83,17.41) v1(107.86,118.17) v1(107.88,117.54) v1(108.29,127.49) v1(108.37,32.5) v1(108.39,31.63) v1(108.49,54.24) v1(108.49,30.59) v1(108.65,69.73) v1(108.72,48.16) v1(108.75,12.51) v1(108.77,124.83) v1(108.77,123.05) v1(109.03,52.82) v1(109,32.5) v1(109.03,31.63) v1(109.13,54.22) v1(109.13,53.45) v1(109.28,69.73) v1(109.54,124.83) v1(109.54,123.05) v1(109.56,127.49) v1(109.74,54.88) v1(109.76,54.24) v1(109.79,48.22) v1(110.02,12.51) v1(110.4,55.49) v1(110.4,54.85) v1(110.4,54.22) v1(110.42,48.17) v1(110.6,53.58) v1(110.55,52.82) v1(110.68,62.29) v1(110.83,127.49) v1(110.93,56.2) v1(111.03,55.51) v1(111.03,54.88) v1(111.03,54.24) v1(111.29,12.51) v1(111.44,56.63) v1(111.54,55.92) v1(111.69,119.59) v1(112,48.14) v1(112.1,127.49) v1(112.13,48.78) v1(112.33,119.59) v1(112.61,48.35) v1(112.56,12.51) v1(112.81,72.25) v1(112.81,71.61) v1(112.81,70.98) v1(112.96,119.62) v1(113.32,70.6) v1(113.37,127.49) v1(113.37,71.94) v1(113.37,71.31) v1(113.83,12.51) v1(114.06,72.55) v1(114.13,70.27) v1(114.36,36.41) v1(114.44,35.72) v1(114.54,37.27) v1(114.64,127.49) v1(114.95,36.16) v1(115,71.28) v1(114.97,37.76) v1(114.97,36.79) v1(115.1,12.51) v1(115.35,35.65) v1(115.63,41.67) v1(115.61,36.26) v1(115.81,34.53) v1(115.91,127.49) v1(115.99,35.72) v1(115.99,34.83) v1(116.39,33.01) v1(116.39,23.71) v1(116.37,12.51) v1(116.55,75.42) v1(116.47,74.71) v1(116.7,48.8) v1(116.7,48.17) v1(116.83,74.15) v1(116.77,49.44) v1(117.03,23.71) v1(117.11,74.84) v1(117.11,22.97) v1(117.18,127.49) v1(117.18,75.47) v1(117.21,58.38) v1(117.18,57.75) v1(117.28,61.52) v1(117.28,60.88) v1(117.28,60.25) v1(117.28,59.61) v1(117.41,124.19) v1(117.41,49.26) v1(117.41,48.63) v1(117.54,124.83) v1(117.46,74.28) v1(117.64,12.51) v1(117.66,123.58) v1(117.74,74.92) v1(117.66,23.71) v1(118.12,124.19) v1(118.17,124.83) v1(118.45,127.49) v1(118.91,12.51) v1(119.29,75.95) v1(119.72,127.49) v1(119.79,75.45) v1(120.15,76.46) v1(120.18,12.51) v1(120.29,74.95) v1(120.65,75.96) v1(120.91,77.6) v1(120.92,68.52) v1(120.92,67.88) v1(120.89,67.22) v1(120.89,66.58) v1(120.99,127.49) v1(121.15,75.46) v1(121.41,77.1) v1(121.45,12.51) v1(121.52,67.22) v1(121.52,66.58) v1(121.6,116.06) v1(121.6,115.05) v1(121.55,68.52) v1(121.55,67.88) v1(121.68,51.45) v1(121.68,50.81) v1(121.68,50.18) v1(121.68,49.54) v1(121.76,118.77) v1(121.92,76.6) v1(121.96,48.93) v1(122.14,119.32) v1(122.19,68.52) v1(122.19,67.88) v1(122.16,67.22) v1(122.16,66.58) v1(122.26,127.49) v1(122.31,51.45) v1(122.31,50.81) v1(122.31,50.18) v1(122.31,49.54) v1(122.4,118.74) v1(122.36,80.1) v1(122.49,94.6) v1(122.72,66.92) v1(122.72,12.51) v1(122.78,119.32) v1(122.79,94.04) v1(122.77,67.58) v1(122.77,37.73) v1(122.95,51.45) v1(122.95,50.81) v1(122.95,50.18) v1(122.95,49.54) v1(123,80.07) v1(123.4,67.58) v1(123.53,127.49) v1(123.58,51.45) v1(123.58,50.81) v1(123.58,50.18) v1(123.58,49.54) v1(123.79,28.69) v1(123.89,94.6) v1(123.99,12.51) v1(124.14,21.2) v1(124.19,126.5) v1(124.22,51.45) v1(124.22,50.81) v1(124.22,50.18) v1(124.22,49.54) v1(124.22,48.91) v1(124.83,125.46) v1(125.03,19.86) v1(125.16,21.2) v1(125.26,12.51) v1(125.49,28.99) v1(126.05,19.87) v1(126.1,125.39) v1(126.17,42.33) v1(126.17,41.69) v1(126.53,12.51) v1(126.73,29.7) v1(126.81,42.33) v1(126.81,41.69) v1(126.91,77.48) v1(126.99,30.29) v1(127.37,125.39) v1(127.44,42.33) v1(127.44,41.69) v1(127.37,29.7) v1(127.62,30.29) v1(127.8,12.51) v1(128,29.7) v1(128,29.07) v1(128.26,30.29) v1(128.64,125.39) v1(129.07,77.48) v1(129.07,12.51) v1(129.53,75.5) v1(129.53,74.84) v1(129.7,77.48) v1(129.98,51.32) v1(129.98,50.68) v1(130.21,66.86) v1(130.21,66.23) v1(130.34,12.51) v1(130.62,51.32) v1(130.62,50.68) v1(130.57,50.05) v1(130.8,75.4) v1(130.85,66.86) v1(130.85,66.23) v1(131.48,66.86) v1(131.48,66.23) v1(131.61,12.51) v1(132.12,66.86) v1(132.12,66.23) v1(132.8,66.48) v1(132.88,12.51) v1(133.56,64.98) v1(134.15,12.51) v1(134.3,66.51) v1(134.3,65.87) v1(134.3,65.24) v1(134.3,64.6) v1(134.3,63.97) v1(134.94,98.67) v1(134.94,66.51) v1(134.94,65.87) v1(134.94,65.24) v1(134.94,64.6) v1(134.94,63.97) v1(135.42,12.51) v1(135.57,98.67) v1(135.7,96.63) v1(136.21,98.67) v1(136.46,96.63) v1(136.69,12.51) v1(136.89,56.25) v1(136.92,55.18) v1(136.87,54.47) v1(136.92,52.67) v1(137.65,53.66) v1(137.65,34.81) v1(137.98,56.25) v1(137.96,12.51) v1(138.16,72.91) v1(138.54,42.4) v1(138.54,41.77) v1(138.49,41.13) v1(138.72,56.27) v1(138.72,55.33) v1(138.75,54.47) v1(138.75,52.69) v1(138.87,72.91) v1(138.92,34.81) v1(139.13,41.11) v1(139.13,40.47) v1(139.08,32.9) v1(139.18,42.4) v1(139.18,41.74) v1(139.23,12.51) v1(139.58,72.91) v1(139.61,56.27) v1(139.61,55.33) v1(139.58,54.47) v1(139.61,52.69) v1(140.3,72.91) v1(140.35,53.5) v1(140.47,30.69) v1(140.5,12.51) v1(140.57,56.25) v1(140.57,55.33) v1(140.57,54.47) v1(140.57,52.69) v1(140.6,42.2) v1(141.01,72.91) v1(141.62,28.56) v1(141.67,72.71) v1(141.77,12.51) v1(143.04,12.51) v1(144.31,12.51) v1(144.49,116.72) v1(144.49,115.45) v1(144.49,114.18) v1(144.49,112.91) v1(144.49,111.64) v1(144.49,110.37) v1(144.49,109.1) v1(144.49,107.83) v1(144.49,106.56) v1(144.49,105.29) v1(144.49,104.02) v1(144.49,102.75) v1(144.49,101.48) v1(144.49,100.21) v1(144.49,98.94) v1(144.49,97.67) v1(144.49,96.4) v1(144.49,95.13) v1(144.49,93.86) v1(144.49,92.59) v1(144.49,91.32) v1(144.49,90.05) v1(144.49,88.78) v1(144.49,87.51) v1(144.49,86.24) v1(144.49,84.97) v1(144.49,83.7) v1(144.49,82.43) v1(144.49,81.16) v1(144.49,79.89) v1(144.49,78.62) v1(144.49,77.35) v1(144.49,76.08) v1(144.49,74.81) v1(144.49,73.54) v1(144.49,72.27) v1(144.49,71) v1(144.49,69.73) v1(144.49,68.46) v1(144.51,67.19) v1(144.57,65.92) v1(144.7,64.65) v1(144.85,63.38) v1(145.08,62.11) v1(145.35,60.84) v1(145.58,12.51) v1(145.66,59.57) v1(145.78,43.04) v1(145.93,44.54) v1(146.04,58.3) v1(146.04,41.46) v1(146.47,57.03) v1(146.54,45.99) v1(146.59,40.22) v1(146.85,12.51) v1(146.98,55.76) v1(147.54,54.49) v1(147.46,47.18) v1(147.59,38.98) v1(148.15,53.22) v1(148.12,12.51) v1(148.66,48.14) v1(148.83,38.09) v1(148.86,51.95) v1(149.39,12.51) v1(149.62,50.68) v1(150,49.41) v1(150.13,37.6) v1(150.19,21.53) v1(150.66,12.51) v1(150.83,21.53) v1(151.04,22.19) v1(151.46,21.53) v1(151.62,37.43) v1(151.93,12.51) v1(152.94,37.6) v1(153.07,21.53) v1(153.2,12.51) v1(153.73,21.55) v1(154.06,38.04) v1(154.47,12.51) v1(155.15,38.72) v1(155.74,12.51) v1(156.2,39.51) v1(157.01,12.51) v1(157.29,40.22) v1(157.31,26.96) v1(158.28,12.51) v1(158.58,39.58) v1(158.68,21.04) v1(159.55,12.51) v1(159.6,38.9) v1(160.67,38.24) v1(160.82,12.51) v1(161.66,37.65) v1(162.09,12.51) v1(162.7,37.1) v1(163.36,12.51) v1(163.89,36.51) v1(164.63,12.51) v1(165.16,35.95) v1(165.9,12.51) v1(166.41,35.44) v1(167.22,21.3) v1(167.17,12.51) v1(167.91,34.91) v1(168.44,12.51) v1(169.33,19.9) v1(169.35,34.68) v1(169.71,12.51) v1(169.76,19.32) v1(170.39,19.32) v1(170.75,19.93) v1(171.03,19.32) v1(170.98,12.51) v1(171.66,19.32) v1(172.25,12.51) v1(173.52,12.51) v1(174.59,34.63) v1(174.79,12.51) v1(175.86,34.63) v1(176.06,12.51) v1(177.13,34.61) v1(177.33,12.51) v1(178.4,34.61) v1(178.6,12.51) v1(179.67,34.59) v1(179.87,12.51) v1(180.94,34.59) v1(180.94,11.71) v1(182.21,34.64) v1(182.21,11.34) v1(182.71,9.66) v1(183.37,8.58) v1(183.48,34.75) v1(184.64,8.58) v1(184.75,34.87) v1(185.91,8.58) v1(186.02,35.05) v1(187.18,8.58) v1(187.29,35.28) v1(188.45,8.58) v1(188.56,35.56) v1(189.72,8.58) v1(189.83,35.86) v1(190.99,8.58) v1(191.1,36.22) v1(192.26,8.58) v1(192.37,36.63) v1(192.42,10.73) v1(193.53,8.58) v1(193.64,37.06) v1(194.8,8.58) v1(194.91,37.57) v1(196.07,8.58) v1(196.18,38.12) v1(197.34,8.58) v1(197.45,38.73) v1(198.61,8.58) v1(198.72,39.39) v1(199.88,8.58) v1(199.99,40.13) v1(201.15,8.58) v1(201.26,40.92) v1(202.42,8.58) v1(202.53,41.76) v1(202.75,32.63) v1(202.88,34.53) v1(203.69,8.58) v1(203.8,42.7) v1(204.38,30.72) v1(204.66,34.4) v1(204.66,32.63) v1(204.96,8.58) v1(205.07,43.71) v1(205.85,34.45) v1(206.23,8.58) v1(206.34,44.84) v1(206.56,32.55) v1(206.64,15.76) v1(207.5,8.58) v1(207.55,45.99) v1(208.6,47.08) v1(208.77,14.97) v1(208.77,8.58) v1(209.31,18.41) v1(209.71,48.35) v1(210.04,8.58) v1(210.3,21.73) v1(210.65,49.54) v1(210.93,10.76) v1(210.98,21.73) v1(211.31,8.58) v1(211.47,50.66) v1(211.57,10.76) v1(212.2,51.8) v1(212.23,21.73) v1(212.58,8.58) v1(213.85,8.58) v1(214.31,11.9) v1(215.07,11.67) v1(215.12,8.58) v1(215.71,11.67) v1(216.39,8.58) v1(218.29,49.54) v1(218.29,48.27) v1(218.29,47) v1(218.29,45.73) v1(218.29,44.46) v1(218.29,43.19) v1(218.29,41.92) v1(218.29,31.76) v1(218.29,30.49) v1(218.29,29.22) v1(218.29,27.95) v1(218.29,26.68) v1(218.71,8.58) v1(219.29,18.43) v1(219.29,17.16) v1(219.29,15.89) v1(219.29,14.62) v1(219.29,13.35) v1(219.29,12.08) v1(219.29,10.81) v1(219.29,9.54) v2(17.97,18.81) v2(21.65,53.45) v2(22.03,50.91) v2(23,60.9) v2(23.1,51.27) v2(24.24,9.87) v2(25.28,9.56) v2(32.42,13.04) v2(33.59,11.67) v2(39.23,105.37) v2(42.2,107.38) v2(63.18,95.62) v2(63.82,95.62) v2(63.95,100.97) v2(66.2,48.14) v2(66.56,64.78) v2(66.81,57.62) v2(66.79,50.35) v2(66.94,67.55) v2(67.03,52.03) v2(67.12,56.45) v2(67.07,55.23) v2(67.18,61.38) v2(67.22,53.58) v2(67.4,49.26) v2(67.55,69.96) v2(67.96,77.02) v2(68.01,71.97) v2(67.98,57.62) v2(67.96,50.35) v2(68.11,67.42) v2(68.06,63.13) v2(68.34,80.17) v2(68.46,74.64) v2(68.51,65.77) v2(68.54,47.71) v2(68.67,78.6) v2(68.85,55.15) v2(68.82,52.03) v2(68.9,56.5) v2(69.01,53.63) v2(69.33,69.96) v2(69.39,61.53) v2(69.45,81.65) v2(69.71,77.02) v2(69.76,72.02) v2(69.82,63.18) v2(69.86,67.55) v2(70.09,80.17) v2(70.22,74.66) v2(70.34,47.28) v2(70.42,78.62) v2(70.55,49.74) v2(70.63,65.74) v2(71.01,63.19) v2(71.08,69.99) v2(71.21,81.65) v2(71.16,47.97) v2(71.4,61.5) v2(71.65,51.24) v2(72.05,68.41) v2(72.32,72.31) v2(72.43,65.75) v2(72.63,48.88) v2(72.66,52.84) v2(72.88,51.14) v2(73.16,49.57) v2(73.42,34.91) v2(74.32,79.85) v2(74.36,83.85) v2(74.67,79.39) v2(74.91,81.01) v2(75.03,79.85) v2(75.79,83.33) v2(76.31,83.98) v2(76.39,80.4) v2(76.36,73.11) v2(76.4,70.88) v2(76.37,65.83) v2(76.39,61.02) v2(76.37,58.26) v2(76.5,76.79) v2(76.49,68.26) v2(77.21,77.61) v2(77.3,83.98) v2(77.43,73.85) v2(77.44,62.88) v2(77.5,72.07) v2(77.51,61.97) v2(77.46,59.3) v2(78.07,50.14) v2(78.65,67.48) v2(78.7,72.07) v2(78.71,71.1) v2(78.74,69.24) v2(78.7,68.41) v2(78.75,65.67) v2(78.72,63.78) v2(78.7,60.11) v2(78.72,56.54) v2(78.8,70.19) v2(79.11,83.09) v2(79.08,81.34) v2(79.18,33.9) v2(79.31,51.13) v2(79.37,71.1) v2(79.41,64.73) v2(79.37,63.78) v2(79.37,62.01) v2(79.37,60.19) v2(79.37,58.37) v2(79.37,56.54) v2(79.37,54.72) v2(79.75,77.57) v2(79.95,72.92) v2(79.92,51.09) v2(79.97,75.68) v2(80.02,71.1) v2(80.02,62.01) v2(80.02,61.1) v2(80.02,60.19) v2(80.02,58.37) v2(80.02,57.46) v2(80.02,56.54) v2(80.02,55.63) v2(80.02,54.72) v2(80.02,53.81) v2(80.02,52.9) v2(80.25,82.87) v2(80.22,81.09) v2(80.56,75.69) v2(80.63,74.74) v2(80.65,73.85) v2(80.67,72.95) v2(80.68,72.02) v2(80.7,71.16) v2(80.68,65.67) v2(80.7,64.71) v2(80.84,68.4) v2(80.85,67.48) v2(80.83,66.56) v2(81.09,82.76) v2(81.47,73.88) v2(82.21,82.08) v2(82.28,42.99) v2(82.28,42.34) v2(82.28,40.39) v2(82.5,77.04) v2(82.61,92.37) v2(83.17,91.88) v2(83.39,82.99) v2(83.5,76.56) v2(83.55,81.24) v2(84.21,56.58) v2(84.21,52.64) v2(84.39,82.97) v2(84.39,81.19) v2(85.31,77.04) v2(85.31,75.74) v2(85.31,74.44) v2(85.43,56.53) v2(85.43,52.59) v2(87.41,56.48) v2(87.51,52.72) v2(88.2,85.84) v2(89.39,48.12) v2(89.75,47.64) v2(90.99,68.92) v2(91.07,58.48) v2(91.12,55.92) v2(91.12,55.33) v2(91.12,54.75) v2(93.08,48.3) v2(93.69,48.3) v2(93.68,47.31) v2(94.02,14.39) v2(94.6,14.39) v2(95.26,55.76) v2(95.9,59.32) v2(95.92,54.7) v2(96.89,53.43) v2(96.96,79.54) v2(97.45,79.06) v2(98.08,55.87) v2(98.13,54.82) v2(98.16,66.59) v2(98.41,62.83) v2(98.46,65.01) v2(98.49,63.77) v2(98.69,61) v2(98.66,53.45) v2(98.79,48.53) v2(99.73,51.78) v2(99.66,50.79) v2(99.91,66.54) v2(99.88,54.82) v2(100.11,116.5) v2(100.16,65.26) v2(103.39,49.03) v2(105.01,44.08) v2(105.17,48.65) v2(105.22,46.44) v2(105.27,42.94) v2(105.57,91.45) v2(106.36,46.42) v2(106.51,91.22) v2(106.84,76.49) v2(106.79,44.03) v2(107.3,75.96) v2(107.43,76.67) v2(107.83,76.24) v2(107.83,75.65) v2(107.99,119.77) v2(108.14,119.19) v2(108.42,117.89) v2(108.47,118.71) v2(108.77,122.39) v2(109.49,122.39) v2(112,119.06) v2(112.38,118.6) v2(112.51,33.06) v2(112.89,85.81) v2(113.04,33.34) v2(113.3,32.8) v2(113.47,85.81) v2(113.65,33.34) v2(113.9,32.8) v2(114.08,85.79) v2(114.74,85.79) v2(115.71,41.01) v2(116.85,102.6) v2(117.16,110.22) v2(117.54,113.52) v2(117.66,111.62) v2(122.54,38.34) v2(123.12,38.34) v2(140.09,16.83) v2(140.42,29.63) v2(140.71,29.12) v2(141.3,29.12) v2(152.18,26.83) v2(156.27,37.71) v2(156.91,37.71) v2(156.86,27.57) v2(157.54,37.71) v2(157.9,27.57) v2(158.18,37.71) v2(184,9.87) v2(190.43,10.98) v2(191.02,10.98) v2(191.6,10.98) v2(205.65,15.24) v2(216.98,48.12) v3(50.79,19.74) v3(51.55,19.72)
