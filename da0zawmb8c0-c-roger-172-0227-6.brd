# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A12: length 38.1
  IN1 w0.102: v2(69.91,69.96) 69.51,69.56 65.39,69.56 65.28,69.46 61.72,69.46 61.41,69.15 60.99,69.15 60.68,69.46 58.74,69.46 57.75,68.47 57.48,68.47 57.01,68.93 56.87,68.93 56.72,68.79 56.72,68.64 57.01,68.36 57.01,68.21 56.81,68.02 56.49,68.02 56.33,68.18 56.11,68.18 55.76,67.83 55.76,67.63 56.17,67.22 v1(56.17,67.14)
  BOTTOM w0.076: U1.AA34 76.45,67.72 76.19,67.98 75.8,67.98 75.73,68.06 75.1,68.06 74.91,68.14 73.89,68.14 73.59,68.44 73.59,68.7 73.19,69.1 72.47,69.1 72.44,69.12 68.57,69.12 68.5,69.2 68.5,69.51 68.57,69.58 69.53,69.58 v2(69.91,69.96)
  BOTTOM w0.127: v1(56.17,67.14) 56.17,67.55 56.04,67.68 54.29,67.68 54.16,67.8 54.16,68.06 54.33,68.22 54.82,68.22 54.94,68.35 54.94,68.95 55.07,69.07 55.33,69.07 55.45,68.95 55.45,68.35 55.58,68.22 56.23,68.22 56.62,67.84 56.62,66.92 56.95,66.58 57.28,66.58 57.41,66.7 JDIM1.119
M_A_A13: length 38.1
  IN1 w0.102: v1(52.97,55.13) 52.97,55.28 52.51,55.74 51.67,55.74 51.35,56.05 51.35,56.83 51.45,56.93 54.63,56.93 54.96,57.26 57.09,57.26 60.32,60.49 72.78,60.49 75.93,63.64 75.93,64.51 77.02,65.6 77.02,66.01 77.65,66.63 v2(78.08,66.63)
  BOTTOM w0.076: v2(78.08,66.63) 78.08,66.46 U1.AC32
  BOTTOM w0.127: v1(52.97,55.13) 52.56,54.72 51.45,54.72 51.21,54.95 JDIM1.158
M_A_ACT#: length 35.9
  IN1 w0.102: v2(74.23,70.29) 73.8,70.73 73.26,70.73 69.96,74.03 65.96,74.03 65.22,74.76 50.58,74.76 50.48,74.66 50.48,69.94 51.74,68.68 v1(51.75,68.68)
  BOTTOM w0.076: v2(74.23,70.29) 74.56,69.96 75.34,69.96 U1.V35
  BOTTOM w0.127: JDIM1.114 51.37,67.95 51.75,68.34 v1(51.75,68.68)
M_A_ALERT#: length 33.9
  IN1 w0.102: v1(53.09,68.68) 52.56,69.2 51.79,69.2 51.52,69.47 51.52,70.39 51.71,70.57 52.12,70.57 52.22,70.47 52.22,70 52.32,69.9 52.52,69.9 52.62,70 52.62,70.47 52.73,70.57 52.93,70.57 53.03,70.47 53.03,70.13 53.13,70.03 53.34,70.03 53.44,70.13 53.44,70.47 53.54,70.57 54.98,70.57 56.31,71.89 57.41,71.89 58.24,72.72 64.4,72.72 65.12,72 v2(67.37,72)
  BOTTOM w0.076: v2(67.37,72) 68.35,71.02 70.86,71.02 72.26,69.62 72.71,69.62 72.73,69.59 73.56,69.59 73.93,69.23 74.45,69.23 U1.W37
  BOTTOM w0.127: v1(53.09,68.68) 52.35,67.94 52.04,67.94 51.55,67.46 JDIM1.116
M_A_BG#0: length 38.8
  IN1 w0.102: v2(69.18,72.02) 68.39,72.81 65.46,72.81 64.73,73.53 57.9,73.53 57.2,72.83 55.44,72.83 55.34,72.73 55.34,72.1 55.24,72 55.04,72 54.93,72.1 54.93,72.35 54.83,72.45 54.43,72.45 54.32,72.35 54.32,71.83 v1(53.91,71.41)
  BOTTOM w0.076: U1.V34 76.11,69.33 75.65,69.33 75.53,69.36 75.28,69.36 75.18,69.33 74.96,69.33 74.87,69.36 74.67,69.56 74.07,69.56 73.7,69.92 72.87,69.92 72.85,69.95 72.44,69.95 70.94,71.45 69.57,71.45 69.18,71.84 v2(69.18,72.02)
  BOTTOM w0.127: v1(53.91,71.41) 53.51,71.41 53.38,71.28 53.38,69.71 53.5,69.58 53.94,69.58 54.06,69.71 54.06,70.6 54.19,70.73 54.37,70.73 54.49,70.6 54.49,69.71 54.62,69.58 54.8,69.58 54.93,69.71 54.93,70.6 55.05,70.73 55.23,70.73 55.36,70.6 55.36,69.71 55.48,69.58 55.94,69.58 56.6,68.92 56.6,68.47 57.36,67.7 JDIM1.115
M_A_BG#1: length 38
  IN1 w0.102: v1(55.19,71.37) 56.25,72.43 57.37,72.43 58.07,73.13 64.56,73.13 65.29,72.4 68.18,72.4 v2(68.59,72)
  BOTTOM w0.076: U1.W35 75.82,69.16 75.63,69.16 75.51,69.19 75.31,69.19 75.2,69.16 74.93,69.16 74.82,69.2 74.82,69.2 74.78,69.21 74.69,69.3 74.6,69.39 74,69.39 73.63,69.76 72.8,69.76 72.78,69.79 72.32,69.79 70.89,71.22 69.16,71.22 68.59,71.79 v2(68.59,72)
  BOTTOM w0.127: v1(55.19,71.37) 55.19,71.74 55.07,71.87 53.27,71.87 53.15,72 53.15,72.38 53.27,72.5 53.71,72.5 53.83,72.63 53.83,73.26 53.96,73.39 54.14,73.39 54.27,73.26 54.27,72.63 54.39,72.5 54.57,72.5 54.7,72.63 54.7,73.26 54.82,73.39 55,73.39 55.13,73.26 55.13,72.63 55.26,72.5 55.87,72.5 55.99,72.38 55.99,70.14 57.05,69.08 57.05,68.66 57.5,68.2 JDIM1.113
M_A_BS#0: length 34.3
  IN1 w0.102: v2(77.36,69.24) 76.93,69.24 75.18,67.5 75.18,65.94 74.23,64.99 74.23,64.45 73.78,63.99 73.24,63.99 72.83,63.59 59.9,63.59 56.9,60.59 54.44,60.59 v1(51.62,57.77)
  BOTTOM w0.076: U1.W32 77.74,68.87 v2(77.36,69.24)
  BOTTOM w0.127: JDIM1.150 51.32,56.95 51.62,57.26 v1(51.62,57.77)
M_A_BS#1: length 36.2
  IN1 w0.102: v2(78.06,67.48) 78.04,67.48 77.51,66.94 77.28,66.94 76.77,66.43 76.77,65.67 75.7,64.6 75.7,63.94 73.28,61.52 72.83,61.52 72.73,61.42 72.73,61.02 72.6,60.9 72.43,60.9 72.32,61 72.32,61.39 72.2,61.52 72.05,61.52 71.92,61.39 71.92,61 71.82,60.9 71.61,60.9 71.41,61.1 71.21,61.1 71,60.9 70.85,60.9 70.68,61.06 70.41,61.06 70.24,60.9 68.69,60.9 68.4,61.19 68.25,61.19 67.96,60.9 66.28,60.9 66.18,61 66.18,61.42 66.08,61.52 65.87,61.52 65.77,61.42 65.77,61 65.67,60.9 62.77,60.9 62.67,61 62.67,61.42 62.57,61.52 62.37,61.52 62.27,61.42 62.27,61.05 62.11,60.9 60.13,60.9 57.49,58.25 55.21,58.25 55.1,58.15 55.1,57.77 55.21,57.67 56.2,57.67 56.25,57.72 v1(56.27,57.72)
  BOTTOM w0.076: v2(78.06,67.48) 78.39,67.15 U1.AB31
  BOTTOM w0.127: v1(56.27,57.72) 56.27,58.08 56.4,58.21 57.16,58.21 57.16,58.2 JDIM1.145
M_A_CAS#: length 36.3
  IN1 w0.102: v2(77.46,67.48) 75.98,66 75.98,65.34 75.47,64.83 75.47,64.48 73.72,62.72 73.34,62.72 72.54,61.92 60.57,61.92 57.32,58.67 54.96,58.67 54.7,58.41 54.7,57.58 54.46,57.34 51.07,57.34 50.86,57.14 50.86,55.97 v1(51.62,55.21)
  BOTTOM w0.076: v2(77.46,67.48) 77.74,67.19 U1.AB32
  BOTTOM w0.127: v1(51.62,55.21) 51.37,55.46 JDIM1.156
M_A_CB0: length 4.7
  TOP w0.102: v1(48.32,74.41) 48.32,74.15 48.96,73.52 R233.2
  BOTTOM w0.102: v1(48.32,74.41) 48.32,74.15 49.02,73.46 JDIM1.92
M_A_CB1: length 3.1
  BOTTOM w0.102: JDIM1.91 60.29,73.7 60.74,74.15 R234.2
M_A_CB2: length 3.1
  BOTTOM w0.102: R235.2 v1(60.69,71.11) 60.51,71.11 60.39,70.98 59.52,70.98 59.29,71.2 JDIM1.101
M_A_CB3: length 3
  BOTTOM w0.102: R236.2 60.87,70.09 60.76,70.2 JDIM1.105
M_A_CB4: length 2.4
  TOP w0.102: R237.2 49.08,74.54 v1(48.96,74.41)
  BOTTOM w0.102: JDIM1.88 49,74.46 v1(48.96,74.41)
M_A_CB5: length 3.1
  BOTTOM w0.102: R238.2 v1(60.67,75.17) 60.06,75.17 59.59,74.7 JDIM1.87
M_A_CB6: length 4.4
  TOP w0.102: R239.2 49.21,71.49 v1(48.3,72.4)
  BOTTOM w0.102: v1(48.3,72.4) 49.24,71.46 JDIM1.100
M_A_CB7: length 7.8
  TOP w0.102: R240.2 v4(48.91,70.47) 48.19,70.47 47.43,69.71 v1(47.43,68.74)
  BOTTOM w0.102: JDIM1.104 48.43,70.46 47.43,69.46 v1(47.43,68.74)
M_A_CKE0: length 36.3
  IN1 w0.102: v1(56.35,73.24) 54.59,73.24 54.48,73.14 54.48,72.96 54.38,72.86 54.18,72.86 54.08,72.96 54.08,73.14 53.98,73.24 53.77,73.24 53.67,73.14 53.67,72.32 53.57,72.22 53.37,72.22 53.27,72.32 53.27,73.14 53.16,73.24 52.76,73.24 52.66,73.34 52.66,73.84 52.76,73.94 64.9,73.94 65.62,73.21 69.2,73.21 v2(70.42,72)
  BOTTOM w0.076: v2(70.42,72) 70.8,71.61 71.18,71.61 71.98,70.81 74.45,70.81 74.77,70.49 75.14,70.49 U1.U36
  BOTTOM w0.127: v1(56.35,73.24) 56.42,73.16 56.42,70.32 57.54,69.2 JDIM1.109
M_A_CKE1: length 36.1
  IN1 w0.102: v1(52.94,71.39) 52.46,71.87 51.27,71.87 51.14,72 51.14,74.15 51.33,74.34 51.74,74.34 51.84,74.24 51.84,73.37 51.94,73.27 52.15,73.27 52.25,73.37 52.25,74.24 52.35,74.34 65.07,74.34 65.79,73.62 69.78,73.62 73.06,70.34 v2(73.06,70.29)
  BOTTOM w0.076: U1.U37 74.74,70.28 74.38,70.65 73.42,70.65 v2(73.06,70.29)
  BOTTOM w0.127: v1(52.94,71.39) 52.94,70.42 51.65,69.12 51.37,69.12 51.2,68.95 JDIM1.110
M_A_CLKN0: length 34.9
  IN1 w0.089: v1(56.3,61.25) 56.19,61.25 56.03,61.42 56.03,61.65 56.28,61.9 57.35,61.9 59.65,64.2 69.64,64.2 69.84,64.41 69.84,64.97 69.93,65.06 70.53,65.06 70.62,64.97 70.62,64.46 70.83,64.25 71.41,64.25 71.62,64.46 71.62,64.97 71.71,65.06 72.15,65.06 72.25,64.96 72.25,64.54 72.49,64.3 73.03,64.3 73.5,64.76 73.5,65.11 74.28,65.89 74.28,67.78 76.99,70.49 77.49,70.49 77.67,70.31 77.67,70.11 77.55,69.99 77.43,69.99 v2(77.31,70.11)
  BOTTOM w0.076: v2(77.31,70.11) 77.31,69.91 77.46,69.76 U1.V32
  BOTTOM w0.102: v1(56.3,61.25) 55.95,61.59 55.95,61.8 56.41,62.25 56.95,62.25 57.07,62.13 57.07,61.81 57.17,61.7 JDIM1.139
M_A_CLKN1: length 33.9
  IN1 w0.089: v1(52.92,62.29) 52.79,62.42 52.79,62.62 52.98,62.81 57.13,62.81 59.32,65 65.66,65 65.83,65.16 68.86,65.16 69.91,66.22 72.39,66.22 73.47,67.3 73.47,68.57 76.38,71.48 77.57,71.48 77.7,71.35 77.7,71.23 77.57,71.1 v2(77.45,71.1)
  BOTTOM w0.076: U1.T32 77.74,71.03 77.66,71.1 v2(77.45,71.1)
  BOTTOM w0.102: JDIM1.140 51.12,61.46 51.28,61.62 52.27,61.62 52.5,61.85 52.5,61.87 v1(52.92,62.29)
M_A_CLKP0: length 34.8
  IN1 w0.089: v2(78.06,70.13) 77.87,70.32 77.87,70.4 77.58,70.69 76.9,70.69 74.08,67.86 74.08,65.97 73.29,65.19 73.29,64.85 72.95,64.5 72.58,64.5 72.45,64.63 72.45,65.04 72.23,65.26 71.63,65.26 71.42,65.06 71.42,64.54 71.33,64.45 70.91,64.45 70.82,64.54 70.82,65.06 70.61,65.26 69.85,65.26 69.64,65.06 69.64,64.49 69.55,64.4 59.57,64.4 57.27,62.1 56.19,62.1 55.82,61.73 55.82,61.41 v1(55.66,61.25)
  BOTTOM w0.076: U1.V31 78.39,69.8 v2(78.06,70.13)
  BOTTOM w0.102: v1(55.66,61.25) 55.74,61.33 55.74,61.89 56.32,62.47 57.03,62.47 57.3,62.2 JDIM1.137
M_A_CLKP1: length 33.9
  IN1 w0.089: v2(78.09,71.1) 77.9,71.29 77.9,71.44 77.66,71.68 76.3,71.68 73.26,68.65 73.26,67.38 72.3,66.42 69.83,66.42 68.77,65.37 65.74,65.37 65.58,65.2 59.24,65.2 57.05,63.01 52.89,63.01 52.58,62.7 52.58,62.59 v1(52.28,62.29)
  BOTTOM w0.076: U1.T31 78.39,70.8 v2(78.09,71.1)
  BOTTOM w0.102: JDIM1.138 51.25,61.95 51.37,61.84 52.18,61.84 52.28,61.94 v1(52.28,62.29)
M_A_CS#0: length 38.3
  IN1 w0.102: v1(56.7,56.25) 57.26,56.25 60.69,59.68 73.34,59.68 73.72,60.06 74.38,60.06 74.66,60.34 74.66,61.17 76.39,62.9 76.39,64.32 76.79,64.73 v2(77.48,64.73)
  BOTTOM w0.076: U1.AE32 77.74,64.99 v2(77.48,64.73)
  BOTTOM w0.127: v1(56.7,56.25) 56.2,56.76 53.43,56.76 53.3,56.88 53.3,57.14 53.43,57.26 55.26,57.26 55.38,57.39 55.38,57.64 55.26,57.77 54.84,57.77 54.71,57.9 54.71,58.15 54.84,58.28 55.69,58.28 55.81,58.15 55.81,57.33 55.94,57.2 JDIM1.149
M_A_CS#1: length 37.4
  IN1 w0.102: v2(77.41,63.78) 77.41,63.49 77.05,63.13 77.05,61.66 76.9,61.5 76.9,60.82 76.75,60.67 76.75,60.52 77.3,59.97 77.3,59.82 77.16,59.68 77.01,59.68 76.46,60.24 76.31,60.24 76.17,60.09 76.17,59.95 76.72,59.39 76.72,59.25 76.58,59.11 76.44,59.11 75.88,59.66 75.74,59.66 75.59,59.52 75.59,59.37 76.15,58.82 76.15,58.67 76.01,58.53 75.86,58.53 75.31,59.09 75.16,59.09 75.02,58.94 75.02,58.8 75.57,58.24 75.57,58.1 75.43,57.96 75.29,57.96 74.73,58.51 74.59,58.51 73.86,57.78 70.44,57.78 70.32,57.66 70.32,57.3 70.22,57.2 70.01,57.2 69.91,57.3 69.91,57.73 69.81,57.83 69.61,57.83 69.51,57.73 69.51,57.3 69.4,57.2 69.2,57.2 69.1,57.3 69.1,58.29 68.93,58.46 61.23,58.46 57.65,54.88 v1(57.08,54.88)
  BOTTOM w0.076: U1.AF32 77.74,64.11 v2(77.41,63.78)
  BOTTOM w0.127: JDIM1.157 57.57,55.2 57.24,54.88 v1(57.08,54.88)
M_A_DIM0_ODT0: length 37.4
  IN1 w0.102: v1(55.81,54.85) 55.81,55.31 55.92,55.41 57.61,55.41 61.06,58.86 69.4,58.86 69.51,58.76 69.51,58.39 69.61,58.29 69.81,58.29 69.91,58.39 69.91,58.76 70.01,58.86 70.22,58.86 70.32,58.76 70.32,58.29 70.42,58.19 70.62,58.19 70.72,58.29 70.72,58.76 70.83,58.86 71.03,58.86 71.13,58.76 71.13,58.29 71.23,58.19 71.44,58.19 71.54,58.29 71.54,58.76 71.64,58.86 71.84,58.86 71.94,58.76 71.94,58.29 72.05,58.19 72.25,58.19 72.35,58.29 72.35,58.76 72.45,58.86 72.86,58.86 73.18,58.55 74.01,58.55 76.01,60.54 76.01,61.35 76.85,62.19 76.85,63.84 77.18,64.17 78.18,64.17 78.29,64.29 78.36,64.29 78.77,64.7 v2(78.78,64.7)
  BOTTOM w0.076: U1.AE31 78.39,65.1 v2(78.78,64.7)
  BOTTOM w0.127: v1(55.81,54.85) 55.64,55.03 55.64,55.21 55.79,55.36 57.11,55.36 57.46,55.7 JDIM1.155
M_A_DIM0_ODT1: length 37.5
  IN1 w0.102: v2(78.13,64.7) 78.13,64.47 78.03,64.36 77.09,64.36 76.62,63.89 76.62,62.55 75.6,61.53 75.6,60.71 73.85,58.95 73.47,58.95 73.15,59.27 60.88,59.27 57.42,55.82 54.72,55.82 54.01,56.53 53.63,56.53 53.53,56.42 53.53,54.98 53.66,54.85 v1(54.16,54.85)
  BOTTOM w0.076: v2(78.13,64.7) 78.39,64.45 U1.AF31
  BOTTOM w0.127: v1(54.16,54.85) 54.61,54.41 56.64,54.41 56.84,54.2 JDIM1.161
M_A_DQ0: length 47.8
  IN1 w0.089: v1(57.14,96.18) 57.22,96.09 57.75,96.09 58.62,95.22 62.12,95.22 62.21,95.31 62.21,95.55 62.3,95.64 62.48,95.64 62.57,95.55 62.57,95.31 62.65,95.22 64.13,95.22 64.22,95.31 64.22,95.87 64.31,95.96 64.49,95.96 64.58,95.87 64.58,95.31 64.67,95.22 64.84,95.22 64.93,95.31 64.93,95.87 65.02,95.96 65.2,95.96 65.29,95.87 65.29,95.31 65.38,95.22 65.56,95.22 65.65,95.31 65.65,95.87 65.73,95.96 65.91,95.96 66,95.87 66,95.31 66.09,95.22 66.27,95.22 66.36,95.31 66.36,95.87 66.45,95.96 66.62,95.96 66.71,95.87 66.71,95.31 66.8,95.22 67.14,95.22 67.23,95.31 67.23,95.87 67.32,95.96 68.89,95.96 68.97,95.87 68.97,95.68 69.06,95.59 69.22,95.59 69.33,95.71 69.33,95.87 69.42,95.96 75.2,95.96 78.3,92.86 78.3,90.77 79.6,89.47 80.55,89.47 81.66,88.36 81.66,82.19 81.6,82.13 v2(81.09,82.13)
  BOTTOM w0.076: U1.A26 81.82,79.48 81.82,80.71 81.5,81.04 81.5,81.72 v2(81.09,82.13)
  BOTTOM w0.102: v1(57.14,96.18) 57.14,95.95 57.38,95.7 JDIM1.3
M_A_DQ1: length 48.6
  IN1 w0.089: v2(81.01,80.43) 81.01,81.6 80.69,81.92 80.69,83.42 80.97,83.71 80.97,88.07 80.26,88.78 79.31,88.78 77.61,90.48 77.61,92.56 75.94,94.23 75.18,94.23 74.14,95.27 69.96,95.27 69.22,94.53 58.34,94.53 57.6,95.27 53.8,95.27 53.33,94.8 v1(53.33,94.42)
  BOTTOM w0.076: v2(81.01,80.43) 80.66,80.07 80.66,79.65 80.78,79.53 80.78,79.18 80.75,79.1 80.75,78.86 80.78,78.79 80.78,78.57 80.75,78.41 80.75,77.97 80.73,77.94 80.73,77.52 80.84,77.41 81.62,77.41 U1.D26
  BOTTOM w0.102: v1(53.33,94.42) 52.29,95.45 JDIM1.4
M_A_DQ2: length 49.5
  IN1 w0.089: v2(79.11,81.93) 79.11,81.95 78.17,82.89 78.17,85.15 77.28,86.04 77.28,88.15 75.27,90.17 75.27,91.16 73.29,93.13 70.47,93.13 69.4,92.06 68.9,92.06 68.81,91.97 68.81,91.72 68.72,91.63 68.54,91.63 68.45,91.72 68.45,91.97 68.36,92.06 68.19,92.06 68.1,91.97 68.1,91.57 68.01,91.48 67.83,91.48 67.74,91.57 67.74,91.97 67.65,92.06 67.47,92.06 67.39,91.97 67.39,91.57 67.3,91.48 67.12,91.48 67.03,91.57 67.03,91.97 66.94,92.06 66.76,92.06 66.67,91.97 66.67,91.57 66.59,91.48 66.41,91.48 66.32,91.57 66.32,91.97 66.23,92.06 66.05,92.06 65.96,91.97 65.96,91.57 65.87,91.48 65.7,91.48 65.61,91.57 65.61,91.97 65.52,92.06 65.34,92.06 65.25,91.97 65.25,91.57 65.16,91.48 64.99,91.48 64.9,91.57 64.9,91.97 64.81,92.06 64.63,92.06 64.54,91.97 64.54,91.57 64.45,91.48 64.27,91.48 64.19,91.57 64.19,91.97 64.1,92.06 53.46,92.06 v1(52.21,93.31)
  BOTTOM w0.076: U1.D28 80.36,77.52 80.09,77.78 80.09,78.52 80.03,78.59 80.03,78.93 79.78,79.55 79.78,79.95 79.46,80.27 79.46,81.57 v2(79.11,81.93)
  BOTTOM w0.102: JDIM1.16 51.64,92.45 52.21,93.03 v1(52.21,93.31)
M_A_DQ3: length 48
  IN1 w0.089: v1(56.37,91.6) 56.37,91.22 56.46,91.13 57.59,91.13 57.68,91.22 57.68,91.63 57.76,91.72 57.94,91.72 58.03,91.63 58.03,91.22 58.12,91.13 58.3,91.13 58.39,91.22 58.39,91.63 58.48,91.72 58.65,91.72 58.74,91.63 58.74,91.22 58.83,91.13 59.01,91.13 59.1,91.22 59.1,91.63 59.19,91.72 59.36,91.72 59.45,91.63 59.45,91.22 59.54,91.13 59.72,91.13 59.81,91.22 59.81,91.63 59.9,91.72 60.08,91.72 60.16,91.63 60.16,91.22 60.25,91.13 60.43,91.13 60.52,91.22 60.52,91.63 60.61,91.72 60.79,91.72 60.88,91.63 60.88,91.22 60.96,91.13 61.14,91.13 61.23,91.22 61.23,91.63 61.32,91.72 61.5,91.72 61.59,91.63 61.59,91.22 61.68,91.13 61.85,91.13 61.94,91.22 61.94,91.63 62.03,91.72 62.21,91.72 62.3,91.63 62.3,91.22 62.39,91.13 62.56,91.13 62.65,91.22 62.65,91.63 62.74,91.72 62.92,91.72 63.01,91.63 63.01,91.22 63.1,91.13 63.28,91.13 63.36,91.22 63.36,91.63 63.45,91.72 63.63,91.72 63.72,91.63 63.72,91.22 63.81,91.13 68.96,91.13 70.62,92.79 73.15,92.79 74.92,91.01 74.92,90.03 76.94,88.01 76.94,85.9 77.81,85.03 77.81,82.58 78.55,81.85 78.55,80.55 78.9,80.2 79.89,80.2 v2(80.2,80.5)
  BOTTOM w0.076: U1.C28 80.59,78.24 80.59,78.43 80.61,78.58 80.61,78.76 80.59,78.83 80.59,79.13 80.61,79.21 80.61,79.46 80.45,79.62 80.45,80.25 v2(80.2,80.5)
  BOTTOM w0.102: v1(56.37,91.6) 56.37,91.5 56.81,91.07 57.29,91.07 57.42,91.21 JDIM1.21
M_A_DQ4: length 46.4
  IN1 w0.089: v2(81.14,83.35) 81.32,83.52 81.32,88.22 80.4,89.13 79.45,89.13 77.96,90.62 77.96,92.71 75.05,95.62 69.82,95.62 69.07,94.87 68.73,94.87 68.64,94.96 68.64,95.53 68.55,95.62 68.38,95.62 68.29,95.53 68.29,94.96 68.2,94.87 68.02,94.87 67.93,94.96 67.93,95.53 67.84,95.62 67.66,95.62 67.58,95.53 67.58,94.96 67.49,94.87 58.48,94.87 57.61,95.74 56.3,95.74 v1(55.87,96.18)
  BOTTOM w0.076: U1.B26 81.84,78.85 81.84,79.05 81.99,79.37 81.99,80.78 81.66,81.11 81.66,82.83 v2(81.14,83.35)
  BOTTOM w0.102: v1(55.87,96.18) 57.34,94.7 JDIM1.7
M_A_DQ5: length 48.2
  IN1 w0.089: v1(51.64,94.45) 53.06,95.87 54.95,95.87 55.66,96.58 57.85,96.58 58.13,96.3 75.34,96.3 78.64,93 78.64,90.91 79.74,89.81 80.69,89.81 82,88.5 82,84.62 v2(82.19,84.44)
  BOTTOM w0.076: U1.C26 81.87,78.23 81.87,78.4 82.01,78.54 82.01,79.01 82.16,79.33 82.16,80.85 81.83,81.18 81.83,84.08 v2(82.19,84.44)
  BOTTOM w0.102: v1(51.64,94.45) JDIM1.8
M_A_DQ6: length 48.4
  IN1 w0.089: v2(79.11,82.51) 78.52,83.09 78.52,85.28 77.63,86.18 77.63,88.29 75.61,90.31 75.61,91.3 73.43,93.47 70.33,93.47 69.26,92.4 61.63,92.4 61.54,92.49 61.54,92.73 61.45,92.82 61.28,92.82 61.19,92.73 61.19,92.49 61.1,92.4 60.92,92.4 60.83,92.49 60.83,92.91 60.74,92.99 60.57,92.99 60.48,92.91 60.48,92.49 60.39,92.4 60.21,92.4 60.12,92.49 60.12,92.91 60.03,92.99 59.85,92.99 59.77,92.91 59.77,92.49 59.68,92.4 59.5,92.4 59.41,92.49 59.41,92.91 59.32,92.99 59.14,92.99 59.05,92.91 59.05,92.49 58.97,92.4 58.79,92.4 58.7,92.49 58.7,92.91 58.61,92.99 58.43,92.99 58.34,92.91 58.34,92.49 58.25,92.4 58.08,92.4 57.99,92.49 57.99,92.91 57.9,92.99 57.72,92.99 57.63,92.91 57.63,92.49 57.54,92.4 54.07,92.4 53.48,92.99 v1(53.48,93.31)
  BOTTOM w0.076: v2(79.11,82.51) 79.65,81.97 79.65,80.32 79.94,80.02 79.94,79.59 80.19,78.97 80.19,78.83 U1.B28
  BOTTOM w0.102: v1(53.48,93.31) 53.48,92.7 52.24,91.45 JDIM1.20
M_A_DQ7: length 47.3
  IN1 w0.089: v1(56.3,92.82) 56.81,93.34 61.97,93.34 62.06,93.25 62.06,92.83 62.14,92.74 62.32,92.74 62.41,92.83 62.41,93.25 62.5,93.34 62.68,93.34 62.77,93.25 62.77,92.83 62.86,92.74 63.03,92.74 63.12,92.83 63.12,93.25 63.21,93.34 63.39,93.34 63.48,93.25 63.48,92.83 63.57,92.74 63.74,92.74 63.83,92.83 63.83,93.25 63.92,93.34 64.1,93.34 64.19,93.25 64.19,92.83 64.28,92.74 64.46,92.74 64.54,92.83 64.54,93.25 64.63,93.34 64.81,93.34 64.9,93.25 64.9,92.83 64.99,92.74 65.17,92.74 65.26,92.83 65.26,93.25 65.35,93.34 65.52,93.34 65.61,93.25 65.61,92.83 65.7,92.74 65.88,92.74 65.97,92.83 65.97,93.25 66.06,93.34 66.23,93.34 66.32,93.25 66.32,92.83 66.41,92.74 66.59,92.74 66.68,92.83 66.68,93.25 66.77,93.34 66.95,93.34 67.03,93.25 67.03,92.83 67.12,92.74 67.3,92.74 67.39,92.83 67.39,93.25 67.48,93.34 67.66,93.34 67.75,93.25 67.75,92.83 67.83,92.74 68.01,92.74 68.1,92.83 68.1,93.25 68.19,93.34 68.37,93.34 68.46,93.25 68.46,92.83 68.55,92.74 68.72,92.74 68.81,92.83 68.81,93.25 68.9,93.34 69.71,93.34 70.19,93.82 73.57,93.82 75.95,91.44 75.95,90.46 77.97,88.44 77.97,86.32 78.87,85.43 78.87,83.92 v2(79.11,83.68)
  BOTTOM w0.076: U1.A28 80.36,79.46 80.22,79.59 80.22,79.98 79.82,80.38 79.82,82.97 v2(79.11,83.68)
  BOTTOM w0.102: JDIM1.17 56.81,92.21 56.3,92.72 v1(56.3,92.82)
M_A_DQ8: length 38.2
  IN1 w0.089: v1(55.74,89.67) 56.26,90.19 58.99,90.19 59.89,89.3 60.43,89.3 60.52,89.39 60.52,89.85 60.61,89.94 60.79,89.94 60.88,89.85 60.88,89.39 60.96,89.3 61.14,89.3 61.26,89.41 61.26,89.99 61.35,90.08 61.52,90.08 61.61,89.99 61.61,89.39 61.7,89.3 61.85,89.3 61.97,89.41 61.97,89.99 62.06,90.08 62.23,90.08 62.32,89.99 62.32,89.39 62.41,89.3 66.38,89.3 66.47,89.39 66.47,89.71 66.56,89.8 66.74,89.8 66.82,89.71 66.82,89.39 66.91,89.3 67.42,89.3 70.46,86.26 75.04,86.26 76.06,85.23 76.21,85.23 76.75,84.69 76.75,83.95 v2(77.3,83.4)
  BOTTOM w0.076: v2(77.3,83.4) 78.29,82.41 78.29,81.24 79.13,80.4 79.13,80.13 79.4,79.87 79.4,79.23 79.33,79.01 79.33,78.85 U1.B30
  BOTTOM w0.102: JDIM1.25 56.27,90.21 v1(55.74,89.67)
M_A_DQ9: length 38.8
  IN1 w0.089: v2(77.32,84.58) 77.06,84.84 77.06,84.87 76.35,85.57 76.21,85.57 75.18,86.6 70.6,86.6 66.78,90.42 60.95,90.42 60.82,90.28 59.39,90.28 59.13,90.54 55.69,90.54 55.03,91.2 52.89,91.2 v1(52.39,90.69)
  BOTTOM w0.076: U1.D30 79.14,77.51 79.42,77.78 79.42,78.7 79.5,78.78 79.5,78.98 79.57,79.21 79.57,79.93 79.3,80.2 79.3,80.47 78.55,81.22 78.55,83.35 v2(77.32,84.58)
  BOTTOM w0.102: JDIM1.24 51.2,90.45 51.52,90.13 51.83,90.13 v1(52.39,90.69)
M_A_DQ10: length 38.2
  IN1 w0.089: v1(56.22,86.7) 56.22,86.27 56.41,86.08 57.33,86.08 57.42,86.17 57.42,86.41 57.51,86.5 57.68,86.5 57.77,86.41 57.77,86.17 57.86,86.08 58.04,86.08 58.13,86.17 58.13,86.41 58.22,86.5 58.4,86.5 58.49,86.41 58.49,86.17 58.57,86.08 60.59,86.08 60.68,85.99 60.68,85.72 60.77,85.63 60.95,85.63 61.04,85.72 61.04,85.99 61.13,86.08 61.3,86.08 61.39,85.99 61.39,85.72 61.48,85.63 61.66,85.63 61.75,85.72 61.75,85.99 61.84,86.08 62.02,86.08 62.11,85.99 62.11,85.72 62.19,85.63 62.37,85.63 62.46,85.72 62.46,85.99 62.55,86.08 62.73,86.08 62.82,85.99 62.82,85.72 62.91,85.63 63.08,85.63 63.17,85.72 63.17,85.99 63.26,86.08 63.44,86.08 63.53,85.99 63.53,85.56 63.62,85.47 63.77,85.47 63.88,85.58 63.88,85.99 63.97,86.08 64.15,86.08 64.24,85.99 64.24,85.56 64.33,85.47 67.4,85.47 69.17,83.69 71.3,83.69 72.25,82.74 72.66,82.74 72.75,82.65 72.75,81.47 72.86,81.35 73.01,81.35 73.1,81.44 73.1,82.65 73.19,82.74 73.37,82.74 73.46,82.65 73.46,81.47 73.57,81.35 73.72,81.35 73.81,81.44 73.81,82.65 73.9,82.74 74.19,82.74 74.26,82.68 74.26,81.51 74.35,81.42 75.09,81.42 v2(75.5,81.01)
  BOTTOM w0.076: U1.B33 76.95,79.21 76.95,79.28 76.44,79.79 76.21,79.79 75.5,80.5 v2(75.5,81.01)
  BOTTOM w0.102: JDIM1.41 56.69,86.21 56.22,86.68 v1(56.22,86.7)
M_A_DQ11: length 37.6
  IN1 w0.089: v2(77.33,81.16) 77.5,81.34 77.5,82.05 76.98,82.57 75.11,82.57 74.94,82.74 74.94,83.25 74.74,83.45 74,83.45 73.85,83.6 73.85,84.29 73.76,84.38 73.42,84.38 73.33,84.29 73.33,84.02 73.24,83.93 73.06,83.93 72.97,84.02 72.97,84.29 72.88,84.38 69.46,84.38 67.68,86.16 67.24,86.16 67.15,86.24 67.15,86.68 67.02,86.82 66.68,86.82 66.59,86.73 66.59,86.24 66.5,86.16 66.32,86.16 66.23,86.24 66.23,86.73 66.14,86.82 65.97,86.82 65.88,86.73 65.88,86.24 65.79,86.16 65.61,86.16 65.52,86.24 65.52,86.73 65.43,86.82 65.26,86.82 65.17,86.73 65.17,86.39 65.08,86.3 64.9,86.3 64.81,86.39 64.81,86.73 64.72,86.82 59.71,86.82 59.02,87.5 58.68,87.5 58.59,87.41 58.59,87.27 58.5,87.18 58.33,87.18 58.24,87.27 58.24,87.41 58.15,87.5 56.72,87.5 56.35,87.87 v1(56.35,87.93)
  BOTTOM w0.076: v2(77.33,81.16) 77.67,81.16 78.64,80.2 78.64,79.93 78.72,79.84 78.72,79.14 78.75,79.08 78.75,78.88 78.72,78.81 78.72,78.5 78.75,78.46 78.75,78.01 78.8,77.97 78.8,77.56 78.6,77.37 U1.D32
  BOTTOM w0.102: JDIM1.37 57.01,87.21 56.35,87.87 v1(56.35,87.93)
M_A_DQ12: length 37.4
  IN1 w0.089: v1(57.06,89.67) 57.22,89.84 58.86,89.84 59.74,88.96 61.42,88.96 61.51,88.87 61.51,88.47 61.62,88.35 61.77,88.35 61.86,88.44 61.86,88.87 61.95,88.96 62.13,88.96 62.22,88.87 62.22,88.47 62.33,88.35 62.49,88.35 62.57,88.44 62.57,88.87 62.66,88.96 62.84,88.96 62.93,88.87 62.93,88.47 63.04,88.35 63.2,88.35 63.29,88.44 63.29,88.87 63.37,88.96 63.55,88.96 63.64,88.87 63.64,88.47 63.76,88.35 63.91,88.35 64,88.44 64,88.87 64.09,88.96 64.26,88.96 64.35,88.87 64.35,88.47 64.47,88.35 64.62,88.35 64.71,88.44 64.71,88.87 64.8,88.96 64.97,88.96 65.06,88.87 65.06,88.47 65.18,88.35 65.33,88.35 65.42,88.44 65.42,88.87 65.51,88.96 65.69,88.96 65.77,88.87 65.77,88.47 65.89,88.35 66.04,88.35 66.13,88.44 66.13,88.87 66.22,88.96 66.4,88.96 66.49,88.87 66.49,88.47 66.6,88.35 66.75,88.35 66.84,88.44 66.84,88.87 66.93,88.96 67.27,88.96 70.31,85.91 74.89,85.91 76.24,84.57 v2(76.34,84.57)
  BOTTOM w0.076: U1.A30 79.14,79.89 78.97,80.06 78.97,80.33 78.13,81.17 78.13,81.84 76.8,83.17 76.8,84.11 v2(76.34,84.57)
  BOTTOM w0.102: v1(57.06,89.67) 57.53,89.21 JDIM1.29
M_A_DQ13: length 38
  IN1 w0.089: v1(53.68,90.69) 53.96,90.41 53.96,89.64 54.08,89.52 54.35,89.52 54.44,89.61 54.44,89.91 54.53,90 54.71,90 54.8,89.91 54.8,89.33 54.89,89.24 58.97,89.24 59.6,88.61 60.71,88.61 61.31,88.01 67.65,88.01 70.09,85.57 74.75,85.57 75.94,84.38 75.94,83.83 v2(76.37,83.4)
  BOTTOM w0.076: 77.79,81.65 77.79,81.28 78.8,80.27 78.8,80 78.89,79.91 78.89,79.18 78.92,79.11 78.92,78.84 78.89,78.78 78.89,78.55 78.92,78.5 78.92,78.24 U1.C30
  BOTTOM w0.079: v2(76.37,83.4) 76.37,83.07 77.79,81.65
  BOTTOM w0.102: JDIM1.28 52.65,89.45 53.68,90.49 v1(53.68,90.69)
M_A_DQ14: length 36.1
  IN1 w0.089: v2(76.08,80.94) 76.08,81.29 76.17,81.38 77.01,81.38 77.1,81.47 77.1,81.64 77.01,81.73 76.67,81.73 76.58,81.82 76.58,82.14 76.49,82.23 76.31,82.23 76.22,82.14 76.22,81.86 76.13,81.77 74.69,81.77 74.6,81.86 74.6,83.02 74.51,83.11 72.37,83.11 72.05,83.43 72.05,83.88 71.89,84.03 69.32,84.03 67.54,85.81 64.9,85.81 64.24,86.47 59.19,86.47 58.82,86.84 57.58,86.84 57.31,87.11 53.3,87.11 v1(53.1,86.9)
  BOTTOM w0.076: U1.B32 77.5,79.01 77.5,79.07 77.26,79.31 77.23,79.31 76.55,80 76.26,80 76.01,80.25 76.01,80.81 76.08,80.89 v2(76.08,80.94)
  BOTTOM w0.102: v1(53.1,86.9) 52.15,85.95 JDIM1.42
M_A_DQ15: length 36.7
  IN1 w0.089: v1(51.67,86.9) 50.84,86.9 50.73,86.8 50.73,85.83 50.82,85.74 51.17,85.74 51.26,85.83 51.26,86.08 51.34,86.17 51.52,86.17 51.61,86.08 51.61,85.83 51.7,85.74 51.88,85.74 51.97,85.83 51.97,86.08 52.06,86.17 52.23,86.17 52.32,86.08 52.32,85.83 52.41,85.74 52.59,85.74 52.68,85.83 52.68,86.08 52.77,86.17 52.94,86.17 53.03,86.08 53.03,85.83 53.12,85.74 60.01,85.74 60.45,85.29 62.73,85.29 62.89,85.13 67.18,85.13 68.96,83.35 71.16,83.35 72.39,82.12 72.39,81.19 72.57,81.01 v2(74.31,81.01)
  BOTTOM w0.076: U1.C32 77.84,78.17 77.38,78.64 77.12,78.64 76.78,78.98 76.39,78.98 76.21,79.16 76.21,79.44 75.14,80.5 74.48,80.5 74.31,80.68 v2(74.31,81.01)
  BOTTOM w0.102: v1(51.67,86.9) 51.62,86.95 JDIM1.38
M_A_DQ16: length 29.6
  IN1 w0.089: v1(51.61,85.1) 51.61,85.09 53.19,83.51 62.2,83.51 62.51,83.21 66.8,83.21 68.36,81.65 v2(68.87,81.65)
  BOTTOM w0.076: U1.H37 74.66,75.36 74.3,75.36 73.77,75.88 73.26,75.88 71.97,77.17 71.97,78.88 69.84,81.01 69.51,81.01 v2(68.87,81.65)
  BOTTOM w0.102: JDIM1.46 51.48,84.95 51.61,85.09 v1(51.61,85.1)
M_A_DQ17: length 31
  IN1 w0.089: v1(57.11,85.1) 57.11,84.81 57.22,84.7 57.58,84.7 57.67,84.78 57.67,85 57.76,85.09 57.94,85.09 58.03,85 58.03,84.78 58.12,84.7 58.29,84.7 58.38,84.78 58.38,85 58.47,85.09 58.65,85.09 58.74,85 58.74,84.78 58.83,84.7 59.17,84.7 59.26,84.78 59.26,85 59.35,85.09 59.53,85.09 59.61,85 59.61,84.78 59.7,84.7 62.48,84.7 62.91,84.26 63.61,84.26 63.7,84.35 63.7,84.44 63.79,84.53 63.96,84.53 64.05,84.44 64.05,84.33 64.14,84.24 64.32,84.24 64.41,84.33 64.41,84.44 64.5,84.53 64.68,84.53 64.76,84.44 64.76,84.33 64.85,84.24 65.03,84.24 65.12,84.33 65.12,84.44 65.21,84.53 65.39,84.53 65.48,84.44 65.48,84.33 65.56,84.24 65.74,84.24 65.83,84.33 65.83,84.44 65.92,84.53 66.1,84.53 66.19,84.44 66.19,84.33 66.28,84.24 66.45,84.24 66.54,84.33 66.54,84.44 66.63,84.53 66.81,84.53 66.9,84.44 66.9,84.33 66.99,84.24 67.23,84.24 68.71,82.75 70.84,82.75 71.79,81.8 v2(71.79,81.65)
  BOTTOM w0.076: v2(71.79,81.65) 71.79,80.15 72.53,79.41 72.53,77.63 73.09,77.08 73.59,77.08 74.58,76.08 74.91,76.08 75.01,76.17 75.97,76.17 76.69,75.44 U1.H34
  BOTTOM w0.102: v1(57.11,85.1) 57.21,85.21 JDIM1.45
M_A_DQ18: length 32.5
  IN1 w0.089: v1(52.23,81.16) 52.23,81.52 52.36,81.65 66.33,81.65 68.24,79.74 70.1,79.74 70.19,79.65 70.19,79.39 70.28,79.3 70.46,79.3 70.55,79.39 70.55,79.65 70.64,79.74 70.88,79.74 71,79.62 v2(71,78.6)
  BOTTOM w0.076: U1.K34 76.58,73.97 76.2,74.34 75.03,74.34 74.84,74.42 74.34,74.42 74.23,74.53 73.55,74.53 71.16,76.93 71.16,78.45 v2(71,78.6)
  BOTTOM w0.102: v1(52.23,81.16) 51.78,80.71 51.41,80.71 51.17,80.95 JDIM1.62
M_A_DQ19: length 32.4
  IN1 w0.089: v2(68.08,78.6) 67.98,78.7 67.58,78.7 66.1,80.19 60.88,80.19 60.65,80.42 59.69,80.42 59.46,80.19 55.8,80.19 55.71,80.28 v1(55.71,80.8)
  BOTTOM w0.076: U1.K35 75.8,73.97 75.54,73.71 74.6,73.71 74.39,73.92 74.14,73.92 74.02,74.04 73.35,74.04 70.66,76.72 70.66,77.24 70.35,77.55 69.13,77.55 v2(68.08,78.6)
  BOTTOM w0.102: JDIM1.59 57.27,81.7 57.17,81.81 57.17,82.13 57.07,82.23 56.86,82.23 56.76,82.13 56.76,81.6 56.66,81.5 56.46,81.5 56.36,81.6 56.36,82.13 56.25,82.23 56.05,82.23 55.95,82.13 55.95,81.81 55.85,81.7 55.65,81.7 55.54,81.81 55.54,82.13 55.44,82.23 55.24,82.23 55.14,82.13 55.14,81.81 55.04,81.7 54.86,81.7 54.67,81.52 54.67,81.22 54.88,81.01 55.5,81.01 v1(55.71,80.8)
M_A_DQ20: length 31
  IN1 w0.089: v2(70.04,81.65) 69.62,82.07 68.43,82.07 66.94,83.55 62.65,83.55 62.3,83.91 54.29,83.91 v1(53.1,85.1)
  BOTTOM w0.076: v2(70.04,81.65) 70.04,81.16 72.15,79.06 72.15,77.23 73.33,76.05 73.84,76.05 74.36,75.53 74.83,75.53 75.05,75.45 75.21,75.45 U1.H36
  BOTTOM w0.102: v1(53.1,85.1) 51.95,83.95 JDIM1.50
M_A_DQ21: length 31.8
  IN1 w0.089: v1(55.74,85.1) 55.73,85.09 54.79,85.09 54.57,84.87 54.57,84.47 54.74,84.3 62.39,84.3 62.79,83.9 67.08,83.9 68.57,82.41 70.17,82.41 70.62,81.95 v2(70.62,81.65)
  BOTTOM w0.076: U1.H35 75.69,75.62 75.08,75.62 74.87,75.69 74.43,75.69 73.91,76.21 73.4,76.21 72.32,77.28 72.32,79.23 70.62,80.94 v2(70.62,81.65)
  BOTTOM w0.102: JDIM1.49 56.64,84.21 v1(55.74,85.1)
M_A_DQ22: length 31.3
  IN1 w0.089: v1(53.58,81.14) 53.74,81.3 54.09,81.3 54.18,81.22 54.18,80.8 54.27,80.71 54.44,80.71 54.53,80.8 54.53,81.22 54.62,81.3 54.8,81.3 54.89,81.22 54.89,80.8 54.98,80.71 55.15,80.71 55.24,80.8 55.24,81.22 55.33,81.3 66.14,81.3 68.06,79.39 69.71,79.39 69.84,79.26 v2(69.84,78.6)
  BOTTOM w0.076: v2(69.84,78.6) 70.99,77.44 70.99,76.86 73.48,74.37 74.16,74.37 74.27,74.25 74.8,74.25 75,74.17 75.19,74.17 U1.K36
  BOTTOM w0.102: JDIM1.58 52.87,81.95 53.58,81.24 v1(53.58,81.14)
M_A_DQ23: length 30.3
  IN1 w0.089: v1(57.06,80.8) 57.22,80.96 57.57,80.96 57.66,80.87 57.66,80.62 57.75,80.53 57.92,80.53 58.01,80.62 58.01,80.87 58.1,80.96 58.28,80.96 58.37,80.87 58.37,80.62 58.46,80.53 58.63,80.53 58.72,80.62 58.72,80.87 58.81,80.96 58.99,80.96 59.08,80.87 59.08,80.65 59.17,80.56 59.35,80.56 59.43,80.65 59.43,80.87 59.52,80.96 59.7,80.96 59.79,80.87 59.79,80.85 59.88,80.76 60.06,80.76 60.15,80.85 60.15,80.87 60.23,80.96 60.41,80.96 60.5,80.87 60.5,80.85 60.59,80.76 60.77,80.76 60.86,80.85 60.86,80.87 60.95,80.96 61.19,80.96 61.28,80.87 61.28,80.62 61.36,80.53 61.54,80.53 61.63,80.62 61.63,80.87 61.72,80.96 61.9,80.96 61.99,80.87 61.99,80.62 62.08,80.53 62.25,80.53 62.34,80.62 62.34,80.87 62.43,80.96 62.61,80.96 62.7,80.87 62.7,80.62 62.79,80.53 62.97,80.53 63.05,80.62 63.05,80.87 63.14,80.96 63.32,80.96 63.41,80.87 63.41,80.62 63.5,80.53 63.68,80.53 63.77,80.62 63.77,80.87 63.85,80.96 64.03,80.96 64.12,80.87 64.12,80.62 64.21,80.53 64.39,80.53 64.48,80.62 64.48,80.87 64.57,80.96 64.74,80.96 64.83,80.87 64.83,80.62 64.92,80.53 65.1,80.53 65.19,80.62 65.19,80.87 65.28,80.96 65.52,80.96 65.64,80.83 65.64,80.61 65.72,80.53 66.38,80.53 67.87,79.04 69.16,79.04 69.25,78.95 v2(69.25,78.6)
  BOTTOM w0.076: v2(69.25,78.6) 69,78.35 69,78.01 69.21,77.8 69.42,77.8 69.53,77.91 69.53,78.14 69.59,78.2 69.81,78.2 69.86,78.14 69.86,77.93 69.99,77.8 70.4,77.8 70.83,77.37 70.83,76.79 73.42,74.2 74.09,74.2 74.2,74.09 74.63,74.09 U1.K37
  BOTTOM w0.102: JDIM1.63 57.15,80.7 v1(57.06,80.8)
M_A_DQ24: length 32.8
  IN1 w0.089: v1(55.23,78.75) 55.71,79.23 65.72,79.23 67.2,77.76 68.39,77.76 v2(69.12,77.02)
  BOTTOM w0.076: U1.N36 75.21,72.94 75.05,72.94 74.64,73.07 73.51,73.07 70.04,76.54 69.61,76.54 v2(69.12,77.02)
  BOTTOM w0.102: JDIM1.67 57.4,79.7 57.33,79.78 57.1,79.78 57,79.68 57,79.39 56.9,79.28 56.7,79.28 56.59,79.39 56.59,79.68 56.49,79.78 56.29,79.78 56.19,79.68 56.19,79.39 56.09,79.28 55.88,79.28 55.78,79.39 55.78,80.11 55.59,80.3 54.47,80.3 54.37,80.2 54.37,80 54.47,79.89 55.13,79.89 55.23,79.79 55.23,79.44 55.08,79.28 54.47,79.28 54.37,79.18 54.37,78.98 54.47,78.88 55.1,78.88 v1(55.23,78.75)
M_A_DQ25: length 31.7
  IN1 w0.089: v2(67.37,77.02) 67.35,77 66.99,77 66.02,77.96 62.07,77.96 61.7,78.33 54.07,78.33 53.98,78.42 53.98,78.98 53.89,79.07 53.74,79.07 53.62,78.95 53.62,78.42 53.54,78.33 53.29,78.33 53.22,78.4 53.22,79.23 v1(53.2,79.26)
  BOTTOM w0.076: v2(67.37,77.02) 69.25,75.14 70.83,75.14 73.23,72.74 74.35,72.74 74.6,72.5 74.87,72.5 74.95,72.53 75.22,72.53 75.32,72.5 75.5,72.5 75.58,72.53 75.86,72.53 75.94,72.5 76.15,72.5 76.28,72.55 76.49,72.55 U1.N34
  BOTTOM w0.102: JDIM1.66 51.18,79.95 51.32,80.1 52.56,80.1 53.2,79.46 v1(53.2,79.26)
M_A_DQ26: length 31.3
  IN1 w0.089: v2(69.63,74.66) 69.63,75.2 69.45,75.37 66.44,75.37 65.4,76.41 55.05,76.41 54.01,75.37 51.27,75.37 51.01,75.63 51.01,76.03 51.42,76.44 51.85,76.44 v1(52.34,75.96)
  BOTTOM w0.076: v2(69.63,74.66) 69.63,74.31 72.52,71.42 74.72,71.42 U1.R37
  BOTTOM w0.102: JDIM1.84 51.91,75.46 52.34,75.88 v1(52.34,75.96)
M_A_DQ27: length 31.9
  IN1 w0.089: v2(70.8,74.66) 69.75,75.72 66.58,75.72 65.53,76.77 59.42,76.77 59.33,76.86 59.33,76.98 59.24,77.07 59.06,77.07 58.98,76.98 58.98,76.86 58.89,76.77 58.71,76.77 58.62,76.86 58.62,76.98 58.53,77.07 58.35,77.07 58.26,76.98 58.26,76.86 58.18,76.77 58,76.77 57.91,76.86 57.91,76.98 57.82,77.07 57.64,77.07 57.55,76.98 57.55,76.86 57.46,76.77 56.21,76.77 56.12,76.86 56.12,77.05 56.03,77.14 55.85,77.14 55.76,77.05 55.76,76.86 55.68,76.77 55.5,76.77 55.41,76.86 55.41,77.05 55.32,77.14 55.14,77.14 55.05,77.05 55.05,76.86 54.96,76.77 54.62,76.77 53.81,75.96 v1(53.71,75.96)
  BOTTOM w0.076: v2(70.8,74.66) 72.88,72.58 74.29,72.58 74.53,72.33 74.9,72.33 74.98,72.36 75.2,72.36 75.29,72.33 75.53,72.33 75.62,72.37 75.81,72.37 75.89,72.33 76.18,72.33 76.31,72.38 76.54,72.38 76.69,72.23 U1.R34
  BOTTOM w0.102: JDIM1.80 53.21,76.46 v1(53.71,75.96)
M_A_DQ28: length 31.4
  IN1 w0.089: v2(68.54,77.02) 68.15,77.42 67.05,77.42 65.72,78.75 65.38,78.75 65.29,78.66 65.29,78.4 65.2,78.31 65.02,78.31 64.93,78.4 64.93,78.66 64.84,78.75 64.67,78.75 64.58,78.66 64.58,78.4 64.49,78.31 64.31,78.31 64.22,78.4 64.22,78.66 64.13,78.75 63.95,78.75 63.87,78.66 63.87,78.4 63.78,78.31 63.6,78.31 63.51,78.4 63.51,78.66 63.42,78.75 63.24,78.75 63.15,78.66 63.15,78.4 63.07,78.31 62.89,78.31 62.8,78.4 62.8,78.66 62.71,78.75 v1(56.7,78.75)
  BOTTOM w0.076: v2(68.54,77.02) 70.05,75.51 70.79,75.51 73.39,72.91 74.59,72.91 U1.N37
  BOTTOM w0.102: v1(56.7,78.75) 56.22,78.27 54.37,78.27 54.19,78.09 54.19,77.84 54.37,77.66 57.01,77.66 57.31,77.96 57.31,78.57 57.44,78.7 JDIM1.71
M_A_DQ29: length 30.6
  IN1 w0.089: v1(51.75,79.28) 52.16,79.69 54.22,79.69 54.41,79.5 54.41,78.87 54.5,78.78 54.68,78.78 54.77,78.87 54.77,79.5 54.86,79.59 65.85,79.59 67.34,78.1 69.21,78.1 v2(70.29,77.02)
  BOTTOM w0.076: U1.N35 75.84,72.75 75.48,73.11 75.08,73.11 74.68,73.24 73.72,73.24 70.29,76.67 v2(70.29,77.02)
  BOTTOM w0.102: JDIM1.70 51.42,78.95 v1(51.75,79.28)
M_A_DQ30: length 32.7
  IN1 w0.089: v1(54.95,75.22) 54.95,75.83 55.2,76.07 55.54,76.07 55.63,75.98 55.63,75.71 55.72,75.62 55.89,75.62 55.98,75.71 55.98,75.98 56.07,76.07 57.84,76.07 57.92,75.98 57.92,75.8 58.01,75.71 58.19,75.71 58.28,75.8 58.28,75.98 58.37,76.07 58.55,76.07 58.64,75.98 58.64,75.8 58.72,75.71 58.9,75.71 58.99,75.8 58.99,75.98 59.08,76.07 65.26,76.07 66.3,75.03 68.88,75.03 69.05,74.87 v2(69.05,74.66)
  BOTTOM w0.076: v2(69.05,74.66) 69.05,74.59 72.38,71.26 74.52,71.26 74.58,71.2 74.83,71.2 75.04,71.27 75.21,71.27 U1.R36
  BOTTOM w0.102: v1(54.95,75.22) 54.95,75.75 54.85,75.86 54.47,75.86 54.37,75.96 54.37,76.16 54.47,76.26 54.85,76.26 54.95,76.36 54.95,76.57 54.85,76.67 54.47,76.67 54.37,76.77 54.37,76.97 54.47,77.08 54.85,77.08 54.95,77.18 56.37,77.18 56.85,76.7 JDIM1.79
M_A_DQ31: length 31.5
  IN1 w0.089: v2(67.88,74.64) 66.21,74.64 65.16,75.68 62.3,75.68 62.21,75.59 62.21,75.46 62.13,75.37 61.95,75.37 61.86,75.46 61.86,75.59 61.77,75.68 61.59,75.68 61.5,75.59 61.5,75.46 61.41,75.37 61.24,75.37 61.15,75.46 61.15,75.59 61.06,75.68 60.88,75.68 60.79,75.59 60.79,75.46 60.7,75.37 60.53,75.37 60.44,75.46 60.44,75.59 60.35,75.68 60.17,75.68 60.08,75.59 60.08,75.46 59.99,75.37 59.81,75.37 59.73,75.46 59.73,75.59 59.64,75.68 59.46,75.68 59.37,75.59 59.37,75.46 59.28,75.37 57.68,75.37 57.59,75.46 57.59,75.59 57.5,75.68 56.55,75.68 56.42,75.55 v1(56.42,75.22)
  BOTTOM w0.076: U1.R35 75.69,71.1 75.07,71.1 74.85,71.03 74.51,71.03 74.44,71.09 72.19,71.09 70.8,72.48 68.08,72.48 67.88,72.68 v2(67.88,74.64)
  BOTTOM w0.102: v1(56.42,75.22) 56.42,75.42 56.2,75.65 55.46,75.65 55.31,75.81 55.31,76.16 55.39,76.25 55.65,76.25 55.75,76.35 55.75,76.69 55.86,76.8 56.06,76.8 56.16,76.69 56.16,76.35 56.26,76.25 57.21,76.25 57.31,76.15 57.31,75.9 57.51,75.7 JDIM1.83
M_A_DQ32: length 33.7
  IN1 w0.089: v1(54.04,53.61) 54.7,54.27 57.9,54.27 59.45,55.82 60.05,55.82 60.25,56.03 60.25,56.53 61.34,57.62 64.35,57.62 64.44,57.71 64.44,57.76 64.52,57.85 64.7,57.85 64.79,57.76 64.79,57.71 64.88,57.62 65.06,57.62 65.15,57.71 65.15,57.76 65.24,57.85 65.41,57.85 65.5,57.76 65.5,57.71 65.59,57.62 v2(66.23,57.62)
  BOTTOM w0.076: U1.AN35 75.73,60.48 75.15,60.48 74.74,60.63 71.89,60.63 71.82,60.57 71.54,60.57 69.77,58.79 67.4,58.79 v2(66.23,57.62)
  BOTTOM w0.102: JDIM1.173 54.67,51.2 54.57,51.31 54.57,51.45 54.44,51.57 54.29,51.57 54.16,51.45 54.16,51.31 54.06,51.2 53.76,51.2 53.66,51.31 53.66,51.75 54.04,52.13 v1(54.04,53.61)
M_A_DQ33: length 31.3
  IN1 w0.089: v1(53.55,52.46) 53.64,52.54 58.37,52.54 62.27,56.45 v2(66.53,56.45)
  BOTTOM w0.076: v2(66.53,56.45) 66.96,56.02 68.92,56.02 69.53,56.63 69.53,56.88 71.83,59.18 74.42,59.18 74.53,59.29 74.9,59.29 74.99,59.26 75.2,59.26 75.27,59.29 75.54,59.29 75.59,59.26 75.85,59.26 75.91,59.29 76.18,59.29 76.3,59.24 76.51,59.24 76.69,59.42 U1.AN34
  BOTTOM w0.102: v1(53.55,52.46) 52.23,51.14 51.34,51.14 51.16,50.95 JDIM1.174
M_A_DQ34: length 32.4
  IN1 w0.089: v1(52.51,48.35) 52.51,48.02 52.69,47.84 53.92,47.84 54.17,48.1 57.07,48.1 60.9,51.93 61.34,51.93 62.99,53.58 65.02,53.58 65.61,54.17 68.11,54.17 68.72,54.78 69.69,54.78 69.91,55 69.91,55.13 69.81,55.23 v2(69.43,55.23)
  BOTTOM w0.076: v2(69.43,55.23) 69.43,55.59 70.19,56.35 70.19,56.61 72.1,58.52 74.39,58.52 74.46,58.45 74.95,58.45 75,58.49 75.07,58.51 75.69,58.51 U1.AR35
  BOTTOM w0.102: v1(52.51,48.35) 52.06,47.89 51.32,47.89 51.25,47.95 JDIM1.186
M_A_DQ35: length 33.4
  IN1 w0.089: v2(66.48,55.24) 65.23,55.24 64.81,54.83 62.79,54.83 62.39,54.44 62.27,54.44 62.22,54.48 62.1,54.48 61.97,54.35 61.97,54.23 62.02,54.19 62.02,54.06 61.89,53.93 61.77,53.93 61.72,53.98 61.6,53.98 61.47,53.85 61.47,53.73 61.51,53.68 61.51,53.56 60.91,52.96 60.47,52.96 58.82,51.3 58.25,51.3 57.25,50.3 54.03,50.3 53.86,50.13 53.86,49.39 54.47,48.78 55.99,48.78 v1(56.42,49.21)
  BOTTOM w0.076: U1.AR34 76.69,58.95 76.58,59.07 76.27,59.07 76.14,59.12 75.95,59.12 75.88,59.09 75.56,59.09 75.5,59.12 75.3,59.12 75.23,59.09 74.97,59.09 74.88,59.12 74.6,59.12 74.49,59.02 71.9,59.02 69.7,56.81 69.7,56.56 68.99,55.85 67.09,55.85 v2(66.48,55.24)
  BOTTOM w0.102: JDIM1.183 56.93,48.71 v1(56.42,49.21)
M_A_DQ36: length 31.6
  IN1 w0.089: v1(52.21,52.46) 51.7,52.97 51.42,52.97 51.22,53.17 51.22,53.68 51.56,54.02 52.55,54.02 52.79,53.78 52.79,53.08 52.98,52.89 58.23,52.89 62.22,56.88 67.37,56.88 67.65,57.16 68.11,57.16 v2(68.57,57.62)
  BOTTOM w0.076: v2(68.57,57.62) 69.1,57.62 71.72,60.23 72.15,60.23 72.22,60.3 74.61,60.3 U1.AN37
  BOTTOM w0.102: v1(52.21,52.46) 51.7,51.95 JDIM1.170
M_A_DQ37: length 32.7
  IN1 w0.089: v2(67.4,57.62) 67,57.22 62.01,57.22 61.77,56.99 61.64,56.99 61.48,57.15 61.36,57.15 61.23,57.02 61.23,56.9 61.39,56.74 61.39,56.61 61.27,56.48 61.14,56.48 60.98,56.65 60.85,56.65 60.73,56.52 60.73,56.4 60.89,56.23 60.89,56.11 60.26,55.48 59.6,55.48 59.1,54.98 59.1,54.86 59.34,54.61 59.34,54.49 59.22,54.36 59.09,54.36 58.85,54.61 58.72,54.61 58.6,54.48 58.6,54.35 58.84,54.11 58.84,53.99 58.71,53.86 58.59,53.86 58.34,54.1 58.22,54.1 58.09,53.98 58.09,53.85 58.34,53.61 58.34,53.48 58.21,53.36 58.08,53.36 57.84,53.6 57.72,53.6 57.35,53.23 55.91,53.23 55.56,53.58 v1(55.56,53.63)
  BOTTOM w0.076: v2(67.4,57.62) 68.18,58.41 69.62,58.41 71.61,60.4 71.89,60.4 71.96,60.47 74.7,60.47 75.12,60.32 75.25,60.32 U1.AN36
  BOTTOM w0.102: v1(55.56,53.63) 55.48,53.55 55.48,52.26 55.54,52.2 55.79,52.2 55.79,52.21 55.89,52.31 55.89,52.97 55.99,53.07 56.19,53.07 56.3,52.97 56.3,52.26 56.35,52.2 JDIM1.169
M_A_DQ38: length 33.3
  IN1 w0.089: v1(53.83,48.32) 52.82,49.34 52.82,49.49 52.97,49.64 53.12,49.64 54.33,48.44 56.92,48.44 60.76,52.27 61.2,52.27 62.85,53.92 64.88,53.92 65.47,54.51 67.95,54.51 68.26,54.82 v2(68.26,55.23)
  BOTTOM w0.076: v2(68.26,55.23) 68.54,55.51 69.11,55.51 70.03,56.42 70.03,56.68 72.04,58.69 74.46,58.69 74.53,58.61 74.88,58.61 74.91,58.64 75.04,58.68 75.21,58.68 U1.AR36
  BOTTOM w0.102: JDIM1.182 53.2,48.95 v1(53.83,48.32)
M_A_DQ39: length 33.2
  IN1 w0.089: v2(67.65,55.23) 67.78,55.11 67.78,54.95 67.68,54.86 65.95,54.86 65.91,54.9 65.37,54.9 64.73,54.27 64.3,54.27 64.21,54.35 64.21,54.4 64.12,54.49 63.94,54.49 63.85,54.4 63.85,54.35 63.76,54.27 63.58,54.27 63.5,54.35 63.5,54.4 63.41,54.49 63.23,54.49 63.14,54.4 63.14,54.35 63.05,54.27 62.71,54.27 61.06,52.61 60.62,52.61 58.57,50.57 58.45,50.57 58.29,50.73 58.17,50.73 58.04,50.6 58.04,50.48 58.2,50.32 58.2,50.2 57.95,49.95 57.6,49.95 57.51,49.87 57.51,49.7 57.42,49.61 57.24,49.61 57.16,49.7 57.16,49.87 57.07,49.95 56.89,49.95 56.8,49.87 56.8,49.7 56.71,49.61 56.53,49.61 56.44,49.7 56.44,49.87 56.36,49.95 56.18,49.95 56.09,49.87 56.09,49.7 56,49.61 55.82,49.61 55.73,49.7 55.73,49.87 55.64,49.95 55.47,49.95 55.38,49.87 55.38,49.7 55.29,49.61 55.11,49.61 55.02,49.7 55.02,49.87 54.93,49.95 54.3,49.95 54.2,49.86 54.2,49.53 54.58,49.15 55.05,49.15 v1(55.1,49.21)
  BOTTOM w0.076: v2(67.65,55.23) 68.11,55.69 69.06,55.69 69.86,56.49 69.86,56.74 71.97,58.85 74.73,58.85 U1.AR37
  BOTTOM w0.102: v1(55.1,49.21) 55.1,49.08 56.48,47.71 JDIM1.187
M_A_DQ40: length 33
  IN1 w0.089: v2(71.79,56.5) 70.51,55.22 70.51,54.1 68.87,52.46 66.36,52.46 65.84,51.94 63.8,51.94 63.54,51.69 63.54,51.43 62.41,50.3 62.01,50.3 57.63,45.92 52.78,45.92 52.64,46.06 52.64,46.21 v1(52.89,46.47)
  BOTTOM w0.076: U1.AU35 75.83,57.43 75.58,57.43 75.5,57.39 75.32,57.39 75.22,57.42 74.95,57.42 74.87,57.4 74.59,57.4 74.4,57.58 74.09,57.58 74.02,57.64 72.49,57.64 71.82,56.97 71.82,56.55 71.79,56.53 v2(71.79,56.5)
  BOTTOM w0.102: JDIM1.190 52.41,46.95 v1(52.89,46.47)
M_A_DQ41: length 33.4
  IN1 w0.089: v1(51.57,46.44) 51.32,46.7 51.32,47.59 51.42,47.69 51.93,47.69 52.37,47.24 54.16,47.24 54.42,47.5 57.31,47.5 60.27,50.45 60.71,50.45 63.23,52.97 65.26,52.97 65.85,53.55 v2(66.64,53.55)
  BOTTOM w0.076: U1.AU34 76.44,57.65 76.13,57.97 75.15,57.97 74.87,58.07 74.3,58.07 74.23,58.14 72.29,58.14 70.7,56.55 70.7,55.94 69.48,54.72 67.8,54.72 v2(66.64,53.55)
  BOTTOM w0.102: v1(51.57,46.44) 51.09,45.95 JDIM1.194
M_A_DQ42: length 35
  IN1 w0.089: v1(51.6,42.45) 51.6,42.73 51.52,42.81 51.12,42.81 51.01,42.71 51.01,42.2 51.17,42.05 53.3,42.05 54.13,42.87 57.73,42.87 60.69,45.83 62.15,45.83 62.41,46.09 62.41,46.65 63.47,47.71 63.88,47.71 65.8,49.63 67.13,49.63 67.4,49.9 68.26,49.9 68.55,50.19 v2(68.55,50.37)
  BOTTOM w0.076: v2(68.55,50.37) 69.61,51.42 69.61,52.55 72.88,55.83 73.37,55.83 73.62,56.07 74.39,56.07 74.53,55.93 74.85,55.93 75.07,56 75.5,56 75.86,56.35 U1.AW35
  BOTTOM w0.102: JDIM1.208 v1(51.6,42.45)
M_A_DQ43: length 33
  IN1 w0.089: v2(72.71,57.26) 72.71,56.68 71.74,55.71 71.74,55.24 71.65,55.15 70.94,55.15 70.85,55.07 70.85,54.89 70.94,54.8 71.65,54.8 71.74,54.71 71.74,54.53 71.65,54.44 70.94,54.44 70.85,54.35 70.85,53.53 70.7,53.38 70.27,53.38 69.34,52.44 69.34,52.02 68.07,50.75 65.46,50.75 63.45,48.74 63.04,48.74 61.66,47.36 60.76,47.36 58.13,44.72 56.48,44.72 56.37,44.61 v1(56.37,43.96)
  BOTTOM w0.076: U1.AW34 76.69,57.07 76.49,57.28 76.29,57.28 76.18,57.23 75.9,57.23 75.76,57.26 75.62,57.26 75.53,57.23 75.29,57.23 75.2,57.26 74.98,57.26 74.9,57.23 74.52,57.23 74.34,57.41 74.02,57.41 73.96,57.48 72.92,57.48 v2(72.71,57.26)
  BOTTOM w0.102: JDIM1.203 57.55,43.71 57.31,43.47 56.86,43.47 56.37,43.95 v1(56.37,43.96)
M_A_DQ44: length 33.3
  IN1 w0.089: v2(68.39,53.58) 68.99,54.18 69.16,54.18 69.31,54.03 69.45,54.03 69.6,54.18 69.71,54.18 69.81,54.09 69.81,53.88 69.1,53.17 68.77,53.17 68.69,53.09 68.69,52.9 68.6,52.81 68.4,52.81 68.34,52.87 68.34,53.07 68.24,53.17 68.08,53.17 67.98,53.07 67.98,52.92 67.87,52.81 66.19,52.81 65.67,52.28 63.51,52.28 62.95,51.72 62.95,51.6 63.03,51.52 63.03,51.39 62.9,51.27 62.78,51.27 62.7,51.35 62.57,51.35 62.45,51.22 62.45,51.09 62.52,51.02 62.52,50.89 62.4,50.77 62.27,50.77 62.2,50.84 62.07,50.84 60.69,49.46 60.56,49.46 60.46,49.55 60.34,49.55 60.21,49.43 60.21,49.3 60.31,49.21 60.31,49.08 60.18,48.95 60.06,48.95 59.96,49.05 59.84,49.05 59.71,48.92 59.71,48.8 59.81,48.7 59.81,48.58 59.68,48.45 59.55,48.45 59.46,48.55 59.33,48.55 59.21,48.42 59.21,48.3 59.3,48.2 59.3,48.08 59.18,47.95 59.05,47.95 58.96,48.04 58.83,48.04 58.7,47.92 58.7,47.79 58.8,47.7 58.8,47.57 58.67,47.45 58.55,47.45 58.45,47.54 58.33,47.54 58.2,47.42 58.2,47.29 58.3,47.19 58.3,47.07 58.17,46.94 58.05,46.94 57.95,47.04 57.82,47.04 57.7,46.91 57.7,46.79 57.79,46.69 57.79,46.57 57.49,46.26 56.51,46.26 56.43,46.33 56.43,46.49 v1(56.7,46.76)
  BOTTOM w0.076: U1.AU37 74.65,57.74 74.16,57.74 74.09,57.81 72.42,57.81 71.03,56.41 71.03,55.81 69.42,54.2 69.01,54.2 v2(68.39,53.58)
  BOTTOM w0.102: JDIM1.191 56.75,46.71 v1(56.7,46.76)
M_A_DQ45: length 33.6
  IN1 w0.089: v1(55.43,46.75) 55.84,47.16 57.46,47.16 60.41,50.11 60.85,50.11 63.37,52.63 65.43,52.63 65.97,53.17 67.4,53.17 v2(67.8,53.58)
  BOTTOM w0.076: U1.AU36 75.25,57.8 75.12,57.8 74.83,57.91 74.23,57.91 74.16,57.97 72.36,57.97 70.86,56.48 70.86,55.87 69.46,54.47 68.69,54.47 v2(67.8,53.58)
  BOTTOM w0.102: JDIM1.195 56.04,45.71 55.62,46.13 54.7,46.13 54.57,46.26 54.57,48.3 54.67,48.4 54.87,48.4 54.98,48.29 54.98,46.87 55.1,46.75 v1(55.43,46.75)
M_A_DQ46: length 34.1
  IN1 w0.089: v2(67.37,50.35) 66.99,49.97 65.65,49.97 63.73,48.06 63.33,48.06 61.94,46.67 61.04,46.67 57.59,43.22 53.86,43.22 53.66,43.42 52.34,43.42 52.24,43.32 52.24,43.01 52.34,42.91 52.67,42.91 v1(53.1,42.48)
  BOTTOM w0.076: v2(67.37,50.35) 67.8,50.79 68.64,50.79 69.44,51.59 69.44,52.62 72.81,55.99 73.3,55.99 73.55,56.24 74.46,56.24 74.6,56.09 74.83,56.09 75.04,56.16 75.21,56.16 U1.AW36
  BOTTOM w0.102: JDIM1.204 52.12,43.45 v1(53.1,42.48)
M_A_DQ47: length 33.8
  IN1 w0.089: v1(54.93,43.96) 54.93,44.28 54.86,44.35 54.08,44.35 54.01,44.28 54.01,43.68 54.13,43.56 57.45,43.56 60.9,47.01 61.8,47.01 63.18,48.4 63.59,48.4 65.55,50.35 v2(66.2,50.35)
  BOTTOM w0.076: v2(66.2,50.35) 66.89,51.04 68.51,51.04 69.28,51.8 69.28,52.69 72.74,56.16 73.24,56.16 73.48,56.4 74.69,56.4 U1.AW37
  BOTTOM w0.102: JDIM1.207 56,42.71 55.79,42.91 54.57,42.91 54.47,43.01 54.47,43.5 v1(54.93,43.96)
M_A_DQ48: length 36.3
  IN1 w0.089: v1(54.67,42.28) 54.92,42.28 55.32,41.88 55.65,41.88 56.05,42.28 57.98,42.28 60.63,44.92 62.08,44.92 63.61,46.45 64.11,46.45 64.45,46.79 64.45,47.44 66.05,49.03 66.58,49.03 v2(66.8,49.25)
  BOTTOM w0.076: U1.BA35 75.85,55.13 75.53,55.45 75.15,55.45 74.86,55.56 74.52,55.56 74.31,55.35 72.95,55.35 70.04,52.44 70.04,51.29 68.59,49.85 67.4,49.85 v2(66.8,49.25)
  BOTTOM w0.102: JDIM1.215 57.31,40.71 57.31,40.71 56.04,40.71 55.94,40.81 55.94,41.23 55.84,41.34 55.63,41.34 55.53,41.23 55.53,40.81 55.43,40.71 55.23,40.71 55.13,40.81 55.13,41.23 55.02,41.34 54.82,41.34 54.72,41.23 54.72,40.81 54.62,40.71 54.39,40.71 54.31,40.78 54.31,41.92 v1(54.67,42.28)
M_A_DQ49: length 35.1
  IN1 w0.089: v2(73.54,54.04) 72.2,54.04 69.15,50.99 69.15,49.94 66.62,47.41 66.62,46.99 65.47,45.83 65.19,45.83 63.19,43.83 61.96,43.83 58.74,40.6 55.59,40.6 55.5,40.69 55.5,41.02 55.41,41.11 55.23,41.11 55.14,41.02 55.14,40.69 55.06,40.6 53.91,40.6 v1(53.55,40.96)
  BOTTOM w0.076: U1.BA34 76.69,54.32 76.58,54.2 76.3,54.2 76.17,54.26 75.93,54.26 75.85,54.23 75.59,54.23 75.53,54.26 75.28,54.26 75.2,54.23 74.99,54.23 74.9,54.26 74.5,54.26 74.2,53.96 73.65,53.96 73.57,54.04
  BOTTOM w0.102: JDIM1.212 53.06,41.45 v1(53.55,40.96) ; 73.57,54.04 v2(73.54,54.04)
M_A_DQ50: length 35.6
  IN1 w0.089: v2(68.13,47.2) 68.13,46.78 65.78,44.43 65.55,44.43 63.94,42.82 63.94,42.32 63.35,41.72 62.2,41.72 58.81,38.33 54.42,38.33 54.06,38.69 54.06,39.46 54.27,39.66 55.18,39.66 55.38,39.46 55.38,39.23 v1(55.81,38.8)
  BOTTOM w0.076: v2(68.13,47.2) 68.78,47.2 72.2,50.63 72.2,51.57 73.74,53.11 73.97,53.11 74.1,53.25 74.36,53.25 75.15,53.51 75.72,53.51 U1.BC35
  BOTTOM w0.102: JDIM1.225 56.41,38.2 v1(55.81,38.8)
M_A_DQ51: length 35.8
  IN1 w0.089: v2(72.15,52.34) 72.15,50.81 70.59,49.26 70.59,48.74 68.95,47.1 68.95,46.63 65.99,43.67 65.99,43.22 63.81,41.04 62.49,41.04 59.1,37.65 53.81,37.65 v1(53.53,37.93)
  BOTTOM w0.076: v2(72.15,52.34) 72.15,52.86 72.97,53.68 73.7,53.68 73.81,53.8 74.27,53.8 74.57,54.09 74.88,54.09 74.97,54.06 75.23,54.06 75.31,54.09 75.49,54.09 75.56,54.06 75.88,54.06 75.96,54.09 76.13,54.09 76.27,54.03 76.58,54.03 76.69,53.92 U1.BC34
  BOTTOM w0.102: JDIM1.224 53.01,38.45 v1(53.53,37.93)
M_A_DQ52: length 34.1
  IN1 w0.089: v1(56.45,41.44) 56.88,41.01 57.68,41.01 58.28,41.61 58.4,41.61 58.77,41.24 58.89,41.24 59.02,41.37 59.02,41.49 58.66,41.86 58.66,41.98 58.78,42.11 58.91,42.11 59.27,41.75 59.4,41.75 59.52,41.87 59.52,42 59.16,42.36 59.16,42.49 59.28,42.61 59.41,42.61 59.78,42.25 59.9,42.25 60.03,42.37 60.03,42.5 59.66,42.86 59.66,42.99 59.79,43.12 59.91,43.12 60.28,42.75 60.4,42.75 60.53,42.88 60.53,43 60.16,43.37 60.16,43.49 60.29,43.62 60.42,43.62 60.78,43.25 60.91,43.25 61.03,43.38 61.03,43.51 60.67,43.87 60.67,44 60.91,44.24 62.37,44.24 63.89,45.76 64.39,45.76 64.84,46.21 65.34,46.21 66.18,47.05 66.18,47.56 v2(66.8,48.18)
  BOTTOM w0.076: U1.BA37 74.63,55.02 73.09,55.02 70.42,52.35 70.42,50.91 68.26,48.75 67.37,48.75 v2(66.8,48.18)
  BOTTOM w0.102: v1(56.45,41.44) 56.25,41.64 56.25,41.79 56.32,41.87 57.36,41.87 57.53,41.71 JDIM1.211
M_A_DQ53: length 34.4
  IN1 w0.089: v2(67.98,49.34) 67.98,49.3 67.37,48.69 67.18,48.69 67.07,48.8 66.88,48.8 66.67,48.6 66.1,48.6 65.61,48.11 65.61,47.99 65.8,47.8 65.8,47.67 65.68,47.54 65.55,47.54 65.36,47.73 65.23,47.73 64.83,47.33 64.83,46.69 64.25,46.11 63.75,46.11 62.22,44.58 60.77,44.58 58.12,41.93 56.19,41.93 55.71,41.45 54.3,41.45 54.24,41.52 54.24,41.79 54.15,41.87 53.97,41.87 53.88,41.79 53.88,41.51 53.82,41.45 52.09,41.45 52.03,41.39 52.03,41.16 v1(52.21,40.98)
  BOTTOM w0.076: U1.BA36 75.25,55.28 75.12,55.28 74.83,55.39 74.59,55.39 74.38,55.18 73.02,55.18 70.25,52.42 70.25,51.28 68.32,49.34 v2(67.98,49.34)
  BOTTOM w0.102: v1(52.21,40.98) 51.68,40.45 JDIM1.216
