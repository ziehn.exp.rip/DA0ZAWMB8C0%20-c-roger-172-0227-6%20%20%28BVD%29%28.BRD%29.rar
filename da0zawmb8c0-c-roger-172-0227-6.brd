# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ54: length 33.6
  IN1 w0.089: v1(52.21,37.96) 52.67,38.42 53.78,38.42 54.21,37.99 58.96,37.99 62.35,41.38 63.49,41.38 64.29,42.18 64.29,42.68 65.7,44.09 65.92,44.09 68.55,46.72 68.55,47.19 70.22,48.86 v2(70.22,49.26)
  BOTTOM w0.076: U1.BC36 75.24,53.67 75.12,53.67 74.36,53.43 74.05,53.43 73.9,53.28 73.6,53.28 72.01,51.7 72.01,50.68 70.6,49.26 v2(70.22,49.26)
  BOTTOM w0.102: JDIM1.228 51.7,37.45 v1(52.21,37.96)
M_A_DQ55: length 32.5
  IN1 w0.089: v2(73.09,53.28) 73.49,53.28 73.59,53.17 73.59,52.77 73.49,52.67 73.06,52.67 72.49,52.09 72.49,50.69 72.86,50.32 72.86,50.15 72.77,50.06 72.62,50.06 72.31,50.37 72.18,50.37 72.06,50.24 72.06,50.11 72.31,49.85 72.31,49.73 72.18,49.6 72.06,49.6 71.8,49.86 71.68,49.86 71.55,49.74 71.55,49.61 71.76,49.41 71.76,49.28 71.63,49.16 71.5,49.16 71.3,49.36 71.18,49.36 70.93,49.12 70.93,48.6 69.34,47.01 69.34,46.53 66.34,43.53 66.34,43.08 63.96,40.7 62.63,40.7 59.18,37.24 v1(56.58,37.24)
  BOTTOM w0.076: v2(73.09,53.28) 73.32,53.5 73.75,53.5 73.88,53.63 74.34,53.63 74.54,53.83 U1.BC37
  BOTTOM w0.102: JDIM1.229 56.63,37.2 56.59,37.24 v1(56.58,37.24)
M_A_DQ56: length 41.5
  IN1 w0.089: v2(70.04,46.62) 70.04,46.39 66.93,43.28 66.93,42.83 64.2,40.1 62.88,40.1 59.42,36.64 51.9,36.64 51.73,36.82 51.73,37.22 51.9,37.4 53.22,37.4 53.57,37.05 54.22,37.05 v1(54.42,37.25)
  BOTTOM w0.076: U1.BE35 75.73,52.93 75.15,52.93 74.77,53.07 74.48,53.07 74.36,52.95 73.81,52.95 72.36,51.5 72.36,50.56 71.05,49.25 71.05,48.63 69.84,47.41 69.84,46.82 v2(70.04,46.62)
  BOTTOM w0.102: JDIM1.233 55.16,36.2 54.42,36.94 v1(54.42,37.25)
M_A_DQ57: length 41
  IN1 w0.089: v1(53.36,32) 53.52,31.85 61.55,31.85 67.54,37.83 67.58,37.83 73.34,43.59 73.34,45.25 73.81,45.72 73.81,46.57 74.03,46.8 74.03,48.86 74.26,49.08 74.26,49.51 74.37,49.63 74.37,50.04 74.61,50.28 74.61,50.94 73.82,51.73 73.82,51.87 v2(73.78,51.91)
  BOTTOM w0.076: v2(73.78,51.91) 73.75,51.94 73.75,52.06 74.13,52.44 74.51,52.44 74.59,52.36 74.87,52.36 74.97,52.39 75.21,52.39 75.32,52.36 75.49,52.36 75.59,52.4 75.86,52.4 75.95,52.36 76.15,52.36 76.26,52.41 76.49,52.41 U1.BE34
  BOTTOM w0.102: v1(53.36,32) 53.34,32 52.39,32.95 JDIM1.246
M_A_DQ58: length 41.4
  IN1 w0.089: v2(71.7,47.67) 71.56,47.54 71.56,47.2 71.44,47.08 71.44,46.87 71.56,46.75 71.56,46.62 71.11,46.16 71.11,45.54 68.23,42.67 68.23,41.81 68.02,41.6 67.2,41.6 60.82,35.22 60.19,35.22 60.1,35.13 60.1,34.58 60.03,34.5 59.84,34.5 59.75,34.59 59.75,35.13 59.66,35.22 59.48,35.22 59.39,35.13 59.39,34.59 59.3,34.5 59.12,34.5 59.04,34.59 59.04,35.13 58.95,35.22 58.77,35.22 58.68,35.13 58.68,34.59 58.59,34.5 58.41,34.5 58.32,34.59 58.32,35.13 58.24,35.22 58.06,35.22 57.97,35.13 57.97,34.59 57.88,34.5 57.7,34.5 57.61,34.59 57.61,35.13 57.52,35.22 57.35,35.22 57.26,35.13 57.26,34.59 57.17,34.5 54.43,34.5 53.96,34.98 52.34,34.98 v1(51.62,35.7)
  BOTTOM w0.076: v2(71.7,47.67) 71.84,47.81 72.18,47.81 72.99,48.62 72.99,48.86 73.98,49.85 73.98,50.15 73.87,50.25 73.87,50.67 74.07,50.86 74.75,50.86 75.19,51 75.48,51 75.79,51.32 U1.BG35
  BOTTOM w0.102: v1(51.62,35.7) 51.62,36.35 51.52,36.45 JDIM1.232
M_A_DQ59: length 41.9
  IN1 w0.089: v2(71.18,47.36) 70.83,47.36 70.75,47.28 70.75,47.18 71.03,46.9 71.03,46.57 70.76,46.3 70.76,45.69 64.43,39.35 64.13,39.35 64.02,39.25 64.02,38.94 63.92,38.85 63.8,38.85 63.53,39.12 63.37,39.12 63.26,39.01 63.26,38.88 63.57,38.58 63.57,38.45 63.44,38.33 63.32,38.33 63.01,38.63 62.89,38.63 62.76,38.51 62.76,38.38 63.06,38.08 63.06,37.95 62.94,37.83 62.81,37.83 62.51,38.13 62.38,38.13 62.26,38 62.26,37.88 62.56,37.57 62.56,37.45 62.44,37.32 62.31,37.32 62.01,37.63 61.88,37.63 61.76,37.5 61.76,37.37 62.06,37.07 62.06,36.95 61.93,36.82 61.81,36.82 61.5,37.12 61.38,37.12 61.25,37 61.25,36.87 61.56,36.57 61.56,36.44 61.43,36.32 61.3,36.32 61,36.62 60.88,36.62 60.75,36.49 60.75,36.37 61.05,36.06 61.05,35.94 60.93,35.81 60.8,35.81 60.5,36.12 60.37,36.12 60.22,35.96 57.14,35.96 56.08,34.9 54.52,34.9 54.1,35.32 53.29,35.32 v1(52.89,35.72)
  BOTTOM w0.076: U1.BG34 76.59,51.32 76.26,50.99 75.7,50.99 75.53,50.81 75.53,50.56 75.35,50.38 74.61,50.38 74.33,50.1 74.33,49.97 73.15,48.79 73.15,48.47 72.32,47.65 72.2,47.65 71.86,47.31 71.23,47.31 v2(71.18,47.36)
  BOTTOM w0.102: v1(52.89,35.72) 52.44,35.27 51.4,35.27 51.21,35.45 JDIM1.236
M_A_DQ60: length 38.8
  IN1 w0.089: v2(73.3,51.56) 73.59,51.27 73.59,50.53 74.03,50.1 74.03,49.77 73.91,49.66 73.91,49.22 73.69,49 73.69,46.94 73.47,46.72 73.47,45.86 73,45.39 73,43.92 68.25,39.17 67.79,39.17 67.48,38.86 67.48,38.26 61.46,32.24 53.69,32.24 53.41,32.52 52.46,32.52 v1(51.89,31.95)
  BOTTOM w0.076: U1.BE37 73.94,52.62 73.24,51.91 73.24,51.64 73.3,51.57 v2(73.3,51.56)
  BOTTOM w0.102: JDIM1.250 v1(51.89,31.95)
M_A_DQ61: length 40.2
  IN1 w0.089: v1(55.69,35.7) 55.69,35.39 55.54,35.24 54.67,35.24 54.19,35.72 54.19,36.13 54.36,36.3 59.57,36.3 59.87,36.6 59.99,36.6 60.12,36.48 60.25,36.48 60.37,36.6 60.37,36.73 60.25,36.85 60.25,36.98 60.37,37.11 60.5,37.11 60.62,36.98 60.75,36.98 60.88,37.11 60.88,37.23 60.75,37.36 60.75,37.48 60.87,37.61 61,37.61 61.13,37.48 61.25,37.48 61.38,37.61 61.38,37.73 61.25,37.86 61.25,37.99 61.38,38.11 61.5,38.11 61.63,37.99 61.76,37.99 61.88,38.11 61.88,38.24 61.75,38.36 61.75,38.49 61.88,38.62 62.01,38.62 62.13,38.49 62.26,38.49 62.38,38.61 62.38,38.74 62.26,38.87 62.26,38.99 62.38,39.12 62.51,39.12 62.64,38.99 62.76,38.99 62.89,39.12 62.89,39.24 62.76,39.37 62.76,39.49 63.02,39.76 64.35,39.76 67.45,42.86 67.45,42.99 67.4,43.04 67.4,43.16 67.53,43.29 67.65,43.29 67.7,43.24 67.83,43.24 67.96,43.37 67.96,43.49 67.91,43.54 67.91,43.67 68.03,43.79 68.16,43.79 68.21,43.74 68.33,43.74 68.46,43.87 68.46,43.99 68.41,44.04 68.41,44.17 68.53,44.3 68.66,44.3 68.71,44.25 68.84,44.25 68.96,44.37 68.96,44.5 68.91,44.55 68.91,44.67 69.04,44.8 69.16,44.8 69.21,44.75 69.34,44.75 69.46,44.87 69.46,45 69.41,45.05 69.41,45.18 69.54,45.3 69.67,45.3 69.72,45.25 69.84,45.25 70.42,45.83 70.42,46.52 v2(70.65,46.75)
  BOTTOM w0.076: v2(70.65,46.75) 70.75,46.85 70.75,48.07 71.23,48.55 71.23,49.19 72.53,50.49 72.53,51.43 73.88,52.78 74.45,52.78 74.56,52.89 74.77,52.89 75.12,52.77 75.25,52.77 U1.BE36
  BOTTOM w0.102: JDIM1.237 56.16,35.2 55.69,35.67 v1(55.69,35.7)
M_A_DQ62: length 40
  IN1 w0.089: v2(73.59,50) 73.57,49.97 73.57,49.36 73.35,49.14 73.35,47.08 73.13,46.86 73.13,46.01 72.66,45.54 72.66,44.06 68.11,39.51 67.64,39.51 67.14,39 67.14,38.4 62.47,33.74 62.35,33.74 62.01,34.07 61.89,34.07 61.76,33.95 61.76,33.82 62.1,33.49 62.1,33.36 61.97,33.23 61.84,33.23 61.51,33.57 61.38,33.57 61.26,33.44 61.26,33.32 61.59,32.98 61.59,32.86 61.32,32.59 60.86,32.59 60.77,32.68 60.77,32.87 60.68,32.96 60.5,32.96 60.41,32.87 60.41,32.68 60.32,32.59 60.14,32.59 60.06,32.68 60.06,32.87 59.97,32.96 59.79,32.96 59.7,32.87 59.7,32.68 59.61,32.59 59.43,32.59 59.34,32.68 59.34,32.87 59.26,32.96 59.08,32.96 58.99,32.87 58.99,32.68 58.9,32.59 58.72,32.59 58.63,32.68 58.63,32.87 58.54,32.96 58.37,32.96 58.28,32.87 58.28,32.68 58.19,32.59 58.01,32.59 57.92,32.68 57.92,32.87 57.83,32.96 57.66,32.96 57.57,32.87 57.57,32.68 57.48,32.59 55.45,32.59 55.33,32.7 55.33,32.8 v1(55.66,33.13)
  BOTTOM w0.076: v2(73.59,50) 73.59,50.13 73.71,50.24 73.71,50.74 74,51.03 74.73,51.03 74.86,51.07 U1.BG36
  BOTTOM w0.102: v1(55.66,33.13) 56.59,32.2 JDIM1.249
M_A_DQ63: length 39.3
  IN1 w0.089: v2(72.58,49.47) 73,49.04 73,47.22 72.78,47 72.78,46.15 72.31,45.68 72.31,44.2 68.48,40.37 67.66,40.37 66.28,39 66.28,38.87 66.64,38.52 66.64,38.39 66.51,38.26 66.39,38.26 66.03,38.62 65.91,38.62 65.78,38.49 65.78,38.37 66.14,38.01 66.14,37.89 66.01,37.76 65.88,37.76 65.53,38.12 65.4,38.12 65.28,37.99 65.28,37.87 65.63,37.51 65.63,37.38 65.51,37.26 65.38,37.26 65.03,37.61 64.9,37.61 64.78,37.49 64.78,37.36 65.13,37.01 65.13,36.88 65,36.76 64.88,36.76 64.52,37.11 64.4,37.11 63.81,36.53 63.81,36.4 64.15,36.06 64.15,35.93 64.03,35.81 63.9,35.81 63.56,36.15 63.44,36.15 63.31,36.02 63.31,35.9 63.65,35.56 63.65,35.43 63.53,35.31 63.4,35.31 63.06,35.65 62.93,35.65 62.81,35.52 62.81,35.39 63.15,35.05 63.15,34.93 63.02,34.8 62.9,34.8 62.56,35.14 62.43,35.14 62.28,35 62.28,34.92 62.64,34.56 62.64,34.42 62.51,34.29 62.41,34.29 62.06,34.63 61.92,34.63 60.59,33.3 57.22,33.3 v1(57.03,33.11)
  BOTTOM w0.076: U1.BG37 74.61,51.32 74.48,51.19 73.93,51.19 73.54,50.8 73.54,50.61 72.58,49.64 v2(72.58,49.47)
  BOTTOM w0.102: JDIM1.245 57.13,33.2 v1(57.03,33.11)
M_A_DQSN0: length 48.7
  IN1 w0.089: v1(56.53,94.07) 56.25,94.34 56.25,94.5 56.33,94.58 57.31,94.58 58.05,93.83 69.51,93.83 70.25,94.58 73.79,94.58 74.83,93.53 75.65,93.53 76.92,92.27 76.92,90.19 79.26,87.84 80.19,87.84 80.28,87.76 80.28,87.44 80.19,87.35 79.11,87.35 78.9,87.14 78.9,86.68 79.14,86.45 80.19,86.45 80.28,86.36 80.28,86.04 80.19,85.95 79.57,85.95 79.36,85.74 79.36,85.26 79.57,85.05 80.19,85.05 80.28,84.96 80.28,84.64 80.19,84.56 79.85,84.56 79.59,84.29 79.59,83.92 79.82,83.69 79.82,83.41 79.59,83.18 79.59,82.63 79.77,82.45 79.77,81.6 79.89,81.48 80.06,81.48 v2(80.25,81.67)
  BOTTOM w0.076: U1.C27 81.01,78.18 81.07,78.12 81.16,78.12 81.25,78.18 81.28,78.29 81.28,78.42 81.24,78.52 81.24,78.77 81.26,78.88 81.26,79.11 81.24,79.17 81.24,79.53 81.4,79.69 81.4,80.57 80.92,81.05 80.92,81.56 80.58,81.9 80.35,81.9 80.25,81.8 v2(80.25,81.67)
  BOTTOM w0.102: v1(56.53,94.07) 56.48,94.07 56.21,93.8 56.21,93.64 56.35,93.5 57.42,93.5 57.63,93.7 JDIM1.11
M_A_DQSN1: length 38.5
  IN1 w0.089: v2(74.95,83.86) 75.17,84.08 75.17,84.16 74.46,84.87 69.8,84.87 67.36,87.31 59.91,87.31 58.82,88.4 55.9,88.4 55.69,88.2 55.69,87.91 55.39,87.62 54.73,87.62 54.52,87.82 54.52,88.14 54.43,88.23 54.12,88.23 54.03,88.14 54.03,87.82 53.82,87.62 52.87,87.62 52.67,87.82 52.67,88.67 52.38,88.96 v1(52.36,88.96)
  BOTTOM w0.076: 75.99,82.26 76.03,82.26 76.76,81.53 76.76,80.24 76.96,80.05 77.6,80.05 78.12,79.52 78.12,79.28 78.07,79.13 78.07,78.83 78.1,78.75 78.1,78.58 78.07,78.42 78.07,78.18 78.1,78.12 78.13,78.06 78.29,77.9 78.36,77.9 78.49,77.77 U1.D31
  BOTTOM w0.102: JDIM1.32 51.14,88.45 51.32,88.28 52.4,88.28 52.55,88.43 52.55,88.77 v1(52.36,88.96) ; 75.99,82.26 75.13,83.12 75.13,83.68 v2(74.95,83.86)
M_A_DQSN2: length 31.7
  IN1 w0.089: v2(68.92,80.17) 68.92,80.8 68.77,80.95 67.73,80.95 67.05,81.63 67.05,81.96 66.83,82.18 62.21,82.18 62,82.39 62,82.73 61.91,82.82 61.6,82.82 61.51,82.73 61.51,82.39 61.3,82.18 59.53,82.18 59.33,82.39 59.33,82.73 59.24,82.82 58.92,82.82 58.83,82.73 58.83,82.39 58.62,82.18 58.09,82.18 57.64,82.64 57.52,82.64 57.06,82.18 56.04,82.18 55.81,82.41 55.81,82.51 v1(55.51,82.82)
  BOTTOM w0.076: v2(68.92,80.17) 69.16,79.93 69.16,79.76 69.41,79.51 70.67,79.51 71.5,78.68 71.5,77.09 73.09,75.49 73.61,75.49 74.13,74.96 74.41,74.96 74.52,74.85 74.9,74.85 74.97,74.87 74.98,74.87 75.2,74.87 75.29,74.85 75.53,74.85 75.62,74.88 75.82,74.88 75.94,74.81 76.01,74.75 76.01,74.67 75.95,74.62 U1.J35
  BOTTOM w0.102: JDIM1.53 57.42,83.21 57.11,83.51 55.85,83.51 55.64,83.3 55.64,82.95 v1(55.51,82.82)
M_A_DQSN3: length 31
  IN1 w0.089: v2(72.92,72.17) 73.01,72.27 73.01,73.15 69.95,76.21 66.79,76.21 65.73,77.27 61.78,77.27 61.41,77.63 52.85,77.63 52.74,77.52 52.74,77.08 v1(52.87,76.95)
  BOTTOM w0.076: U1.P34 76.21,72.1 76.13,72.03 76.13,71.87 76.06,71.79 75.9,71.68 75.55,71.68 75.51,71.71 75.27,71.71 75.2,71.67 74.92,71.67 74.84,71.72 74.57,71.72 74.5,71.65 73.49,71.65 72.97,72.17 v2(72.92,72.17)
  BOTTOM w0.102: JDIM1.74 51.13,77.95 51.23,77.85 52.27,77.85 52.63,77.49 52.63,77.16 52.84,76.95 v1(52.87,76.95)
M_A_DQSN4: length 32.5
  IN1 w0.089: v2(68.31,56.4) 68.04,56.13 68.04,55.95 67.83,55.74 62.55,55.74 58.66,51.85 54.6,51.85 54.43,51.67 54.43,51.44 54.51,51.35 55.83,51.35 v1(56.45,50.74)
  BOTTOM w0.076: U1.AP35 75.96,59.52 76.01,59.56 76.01,59.65 75.94,59.71 75.82,59.78 75.62,59.78 75.53,59.75 75.27,59.75 75.17,59.77 74.97,59.77 74.89,59.75 74.43,59.75 74.29,59.89 72.55,59.89 72.33,59.67 71.62,59.67 68.88,56.93 68.03,56.93 67.92,56.82 67.92,56.71 68.24,56.4 v2(68.31,56.4)
  BOTTOM w0.102: JDIM1.177 57.39,50.2 57.34,50.15 57.34,50.02 57.24,49.92 56.21,49.92 56.11,50.02 56.11,50.45 56.39,50.74 v1(56.45,50.74)
M_A_DQSN5: length 33.7
  IN1 w0.089: v2(68.22,52.04) 68.05,51.86 68.05,51.5 67.79,51.24 65.15,51.24 63.15,49.24 61.94,49.24 57.92,45.22 55.9,45.22 55.53,44.85 53.26,44.85 52.74,44.33 52.74,44.18 v1(52.94,43.98)
  BOTTOM w0.076: U1.AV34 76.2,57 76.15,56.95 76.15,56.77 76.01,56.63 75.88,56.58 75.55,56.58 75.47,56.62 75.33,56.62 75.23,56.58 74.97,56.58 74.8,56.63 74.16,56.63 74.07,56.72 73.43,56.72 73.1,56.39 72.59,56.39 68.9,52.69 68.24,52.69 68.01,52.46 68.01,52.26 v2(68.22,52.04)
  BOTTOM w0.102: v1(52.94,43.98) 52.84,44.08 52.84,44.54 52.43,44.95 JDIM1.198
M_A_DQSN6: length 34.6
  IN1 w0.089: v1(56.37,40.04) 56.25,40.04 56.09,39.88 56.09,39.62 56.25,39.46 58.55,39.46 58.81,39.72 58.81,39.97 59.5,40.66 60.15,40.66 60.37,40.88 60.37,41.01 60.26,41.12 60.26,41.42 60.6,41.76 60.9,41.76 61.01,41.65 61.14,41.65 61.36,41.87 61.36,42 61.25,42.11 61.25,42.41 61.59,42.75 61.88,42.75 62,42.63 62.13,42.63 62.82,43.33 63.39,43.33 65.19,45.13 65.49,45.13 67.12,46.76 67.12,47.21 68.2,48.29 68.66,48.29 69.52,49.15 69.52,49.61 70.33,50.42 70.56,50.42 70.99,50.85 71.17,50.85 v2(71.31,50.71)
  BOTTOM w0.076: U1.BB35 75.96,54.48 76.01,54.53 76.01,54.6 75.94,54.67 75.81,54.75 75.6,54.75 75.51,54.71 75.22,54.71 75.16,54.75 74.99,54.75 74.72,54.68 73.33,54.68 71.69,53.05 71.69,52.08 71.13,51.52 71.13,51.14 70.81,50.82 70.81,50.65 70.87,50.58 71.03,50.58 71.08,50.53 71.23,50.53 71.31,50.61 v2(71.31,50.71)
  BOTTOM w0.102: JDIM1.219 57.54,39.71 57.42,39.58 57.42,39.51 57.33,39.42 56.26,39.42 56.08,39.6 56.08,39.8 56.32,40.04 v1(56.37,40.04)
M_A_DQSN7: length 40.7
  IN1 w0.089: v2(72.07,48.7) 72.07,48.6 72.51,48.16 72.51,47.44 72.27,47.2 72.27,46.34 71.82,45.88 71.82,44.41 70.95,43.54 70.66,43.54 70.48,43.72 70.35,43.72 70.13,43.49 70.13,43.37 70.31,43.19 70.31,42.89 69.96,42.55 69.67,42.55 69.49,42.73 69.36,42.73 69.14,42.5 69.14,42.38 69.32,42.2 69.32,41.91 68.31,40.9 67.49,40.9 60.38,33.79 54.16,33.79 53.67,34.28 52.83,34.28 52.67,34.12 52.67,33.74 v1(52.87,33.54)
  BOTTOM w0.076: v2(72.07,48.7) 71.81,48.7 71.65,48.86 71.65,49.15 73.88,51.37 74.38,51.37 74.58,51.57 74.88,51.57 75.01,51.53 75.2,51.53 75.35,51.59 75.46,51.59 75.55,51.54 75.88,51.54 76,51.6 76.14,51.74 76.14,51.93 76.18,51.97 U1.BF34
  BOTTOM w0.102: v1(52.87,33.54) 52.65,33.76 52.65,33.96 52.16,34.45 JDIM1.240
M_A_DQSN8: length 3.1
  BOTTOM w0.102: JDIM1.95 60.51,72.7 v1(60.69,72.88) 60.95,73.14 R232.1
M_A_DQSP0: length 48.8
  IN1 w0.089: v1(55.89,94.07) 55.89,94.09 56.05,94.25 56.05,94.58 56.25,94.78 57.39,94.78 58.13,94.04 69.42,94.04 70.16,94.78 73.87,94.78 74.92,93.74 75.74,93.74 77.12,92.35 77.12,90.28 79.35,88.05 80.27,88.05 80.48,87.84 80.48,87.35 80.27,87.15 79.2,87.15 79.11,87.06 79.11,86.77 79.22,86.65 80.27,86.65 80.48,86.44 80.48,85.96 80.27,85.75 79.65,85.75 79.56,85.66 79.56,85.34 79.65,85.25 80.27,85.25 80.48,85.05 80.48,84.56 80.27,84.35 79.93,84.35 79.79,84.21 79.79,84 80.02,83.77 80.02,83.33 79.79,83.09 79.79,82.72 v2(80.25,82.26)
  BOTTOM w0.076: v2(80.25,82.26) 80.44,82.07 80.65,82.07 81.09,81.63 81.09,81.12 81.56,80.64 81.56,79.62 81.4,79.46 81.4,79.2 81.43,79.14 81.43,78.86 81.4,78.75 81.4,78.55 81.45,78.45 81.45,78.26 81.39,78.08 81.21,77.95 81.09,77.95 81.01,77.88 U1.D27
  BOTTOM w0.102: v1(55.89,94.07) 55.99,93.97 55.99,93.55 56.26,93.28 57.47,93.28 57.54,93.21 JDIM1.13
M_A_DQSP1: length 38.5
  IN1 w0.089: v2(75.53,83.86) 75.37,84.02 75.37,84.25 74.55,85.08 69.89,85.08 67.45,87.51 60,87.51 58.91,88.61 55.81,88.61 55.48,88.28 55.48,87.99 55.31,87.82 54.81,87.82 54.73,87.91 54.73,88.22 54.52,88.43 54.03,88.43 53.82,88.22 53.82,87.91 53.73,87.82 52.96,87.82 52.87,87.91 52.87,88.76 v1(53.05,88.94)
  BOTTOM w0.076: 76.14,82.42 76.14,82.38 76.93,81.59 76.93,80.31 77.03,80.21 77.66,80.21 78.29,79.59 78.29,79.25 78.24,79.1 78.24,78.86 78.26,78.79 78.26,78.57 78.24,78.4 78.24,78.22 78.27,78.16 78.36,78.07 78.42,78.07 78.49,78.14 U1.C31
  BOTTOM w0.102: JDIM1.34 51.39,87.95 51.5,88.06 52.49,88.06 52.77,88.34 52.77,88.66 v1(53.05,88.94) ; v2(75.53,83.86) 75.35,83.68 75.35,83.21 76.14,82.42
M_A_DQSP2: length 31.6
  IN1 w0.089: v2(69.51,80.17) 69.12,80.55 69.12,80.89 68.86,81.15 67.82,81.15 67.26,81.71 67.26,82.04 66.91,82.38 62.3,82.38 62.21,82.47 62.21,82.81 62,83.02 61.51,83.02 61.3,82.81 61.3,82.47 61.22,82.38 59.62,82.38 59.53,82.47 59.53,82.81 59.32,83.02 58.84,83.02 58.63,82.81 58.63,82.47 58.54,82.38 58.18,82.38 57.72,82.84 57.43,82.84 56.98,82.38 56.13,82.38 56.02,82.49 56.02,82.64 v1(56.19,82.82)
  BOTTOM w0.076: U1.J34 76.22,74.62 76.17,74.67 76.17,74.82 76.04,74.95 75.86,75.05 75.58,75.05 75.5,75.01 75.32,75.01 75.22,75.04 74.95,75.04 74.88,75.01 74.59,75.01 74.48,75.13 74.2,75.13 73.68,75.65 73.16,75.65 71.66,77.15 71.66,78.75 70.73,79.68 69.47,79.68 69.33,79.82 69.33,80 v2(69.51,80.17)
  BOTTOM w0.102: JDIM1.55 57.45,82.7 57.33,82.83 57.33,82.99 57.02,83.3 55.94,83.3 55.86,83.21 55.86,83.16 v1(56.19,82.82)
M_A_DQSP3: length 30.9
  IN1 w0.089: v1(52.23,76.95) 52.31,76.95 52.54,77.17 52.54,77.61 52.77,77.84 61.49,77.84 61.86,77.47 65.82,77.47 66.87,76.41 70.04,76.41 73.21,73.24 73.21,72.4 73.44,72.17 v2(73.51,72.17)
  BOTTOM w0.076: U1.P35 75.89,72.1 75.97,72.03 75.97,71.94 75.91,71.89 75.85,71.85 75.6,71.85 75.56,71.87 75.22,71.87 75.16,71.84 74.97,71.84 74.89,71.89 74.51,71.89 74.44,71.82 73.56,71.82 73.42,71.95 73.42,72.08 v2(73.51,72.17)
  BOTTOM w0.102: JDIM1.76 51.22,77.46 51.4,77.63 52.18,77.63 52.41,77.41 52.41,77.13 v1(52.23,76.95)
M_A_DQSP4: length 32.5
  IN1 w0.089: v2(67.72,56.4) 67.84,56.29 67.84,56.03 67.75,55.94 62.47,55.94 58.58,52.05 54.51,52.05 54.22,51.76 54.22,51.35 54.43,51.15 55.75,51.15 55.81,51.08 v1(55.81,50.74)
  BOTTOM w0.076: U1.AP34 76.22,59.52 76.17,59.56 76.17,59.71 76.04,59.84 75.86,59.95 75.58,59.95 75.5,59.91 75.29,59.91 75.2,59.94 74.94,59.94 74.86,59.91 74.5,59.91 74.36,60.06 72.48,60.06 72.26,59.84 71.56,59.84 68.81,57.09 67.96,57.09 67.76,56.89 67.76,56.44 v2(67.72,56.4)
  BOTTOM w0.102: JDIM1.179 56.12,49.71 55.89,49.93 55.89,50.66 v1(55.81,50.74)
M_A_DQSP5: length 33.6
  IN1 w0.089: v2(67.63,52.03) 67.84,51.81 67.84,51.59 67.7,51.45 65.07,51.45 63.06,49.44 61.85,49.44 57.84,45.42 55.82,45.42 55.45,45.05 53.17,45.05 52.54,44.42 52.54,44.23 v1(52.28,43.98)
  BOTTOM w0.076: v2(67.63,52.03) 67.84,52.25 67.84,52.53 68.17,52.86 68.83,52.86 72.52,56.55 73.03,56.55 73.36,56.88 74.14,56.88 74.23,56.8 74.88,56.8 74.92,56.77 74.99,56.74 75.2,56.74 75.3,56.79 75.51,56.79 75.59,56.74 75.85,56.74 75.91,56.77 75.98,56.84 75.98,56.95 75.93,57 U1.AV35
  BOTTOM w0.102: v1(52.28,43.98) 52.63,44.32 52.63,44.45 52.34,44.74 51.52,44.74 51.24,44.45 JDIM1.200
M_A_DQSP6: length 34.6
  IN1 w0.089: v1(55.74,40.07) 55.89,39.91 55.89,39.53 56.17,39.25 58.63,39.25 59.02,39.64 59.02,39.89 59.58,40.45 60.23,40.45 60.58,40.8 60.58,41.09 60.46,41.21 60.46,41.33 60.69,41.56 60.81,41.56 60.93,41.44 61.22,41.44 61.57,41.79 61.57,42.08 61.45,42.2 61.45,42.32 61.67,42.55 61.8,42.55 61.92,42.43 62.21,42.43 62.91,43.13 63.48,43.13 65.27,44.93 65.58,44.93 67.32,46.67 67.32,47.12 68.28,48.09 68.75,48.09 69.72,49.06 69.72,49.53 70.42,50.22 v2(70.91,50.22)
  BOTTOM w0.076: v2(70.91,50.22) 70.91,50.32 70.65,50.58 70.65,50.89 70.97,51.21 70.97,51.59 71.52,52.14 71.52,53.12 73.26,54.85 74.7,54.85 74.97,54.91 75.21,54.91 75.27,54.88 75.48,54.88 75.57,54.91 75.86,54.91 76.07,54.79 76.21,54.65 76.21,54.57 76.29,54.48 U1.BB34
  BOTTOM w0.102: v1(55.74,40.07) 55.86,39.94 55.86,39.51 56.17,39.2 JDIM1.221
M_A_DQSP7: length 40.7
  IN1 w0.089: v1(52.21,33.54) 52.46,33.79 52.46,34.2 52.75,34.49 53.75,34.49 54.24,34 60.3,34 67.4,41.1 68.23,41.1 69.11,41.99 69.11,42.12 68.93,42.29 68.93,42.59 69.28,42.93 69.57,42.93 69.75,42.75 69.88,42.75 70.1,42.98 70.1,43.1 69.92,43.28 69.92,43.58 70.27,43.92 70.56,43.92 70.74,43.74 70.87,43.74 71.61,44.49 71.61,45.97 72.07,46.43 72.07,47.29 72.31,47.52 72.31,48.07 72.05,48.33 71.72,48.33 v2(71.66,48.27)
  BOTTOM w0.076: v2(71.66,48.27) 71.77,48.37 71.77,48.51 71.49,48.79 71.49,49.21 73.81,51.54 74.31,51.54 74.52,51.74 74.9,51.74 75.03,51.7 75.16,51.7 75.32,51.76 75.49,51.76 75.59,51.71 75.84,51.71 75.9,51.74 75.97,51.81 75.97,51.93 75.94,51.97 U1.BF35
  BOTTOM w0.102: JDIM1.242 51.13,33.95 51.41,34.24 52.07,34.24 52.44,33.87 52.44,33.77 v1(52.21,33.54)
M_A_DQSP8: length 3
  BOTTOM w0.102: R231.1 60.39,72.12 60.3,72.2 JDIM1.97
M_A_PARITY: length 32.5
  IN1 w0.102: v1(56.81,59.96) 56.84,59.96 60.05,63.17 67.45,63.17 67.88,62.74 72.29,62.74 73.14,63.59 73.66,63.59 74.64,64.56 74.64,64.82 75.37,65.55 75.37,66.53 77.02,68.18 77.02,68.48 77.36,68.82 77.71,68.82 78.11,69.22 v2(78.11,69.24)
  BOTTOM w0.076: U1.W31 78.11,69.13 v2(78.11,69.24)
  BOTTOM w0.127: v1(56.81,59.96) 56.81,59.65 56.58,59.42 55.69,59.42 55.43,59.68 55.43,60.06 55.84,60.46 57.31,60.46 57.56,60.7 JDIM1.143
M_A_RAS#: length 34.1
  IN1 w0.102: v2(77.49,68.41) 77.44,68.36 77.44,68.33 75.56,66.45 75.56,65.47 75,64.9 75,64.65 73.71,63.36 73.21,63.36 72.33,62.48 67.63,62.48 67.36,62.75 60.21,62.75 56.97,59.51 54.63,59.51 52.94,57.82 v1(52.94,57.77)
  BOTTOM w0.076: v2(77.49,68.41) 77.74,68.16 U1.Y32
  BOTTOM w0.127: v1(52.94,57.77) 52.74,57.57 52.74,57.03 52.16,56.46 JDIM1.152
M_A_WE#: length 37.6
  IN1 w0.102: v2(78.11,65.67) 78.11,65.45 77.98,65.32 77.05,65.32 76.16,64.43 76.16,63.26 74.26,61.35 74.26,60.72 74.1,60.57 73.59,60.57 73.11,60.08 60.51,60.08 57.08,56.65 56.91,56.65 56.7,56.86 56.32,56.86 56.15,56.68 55.74,56.68 55.56,56.86 55.13,56.86 54.76,56.49 54.76,56.35 54.86,56.25 v1(55.43,56.25)
  BOTTOM w0.076: U1.AC31 78.11,65.83 v2(78.11,65.67)
  BOTTOM w0.127: v1(55.43,56.25) 55.36,56.32 53.78,56.32 53.66,56.2 53.66,55.93 53.78,55.8 56.89,55.8 57.29,56.2 57.29,56.42 57.57,56.7 JDIM1.151
M_B1_ZQ0: length 4.4
  TOP w0.102: R253.1 40.08,35.3 v1(40.54,35.77) 42.45,37.68 42.45,38.1 U4.F9
M_B2_ZQ0: length 3.8
  TOP w0.102: R254.1 41.22,49.35 42.35,50.49 42.35,51.35 U5.F9
M_B3_ZQ0: length 3.6
  TOP w0.102: U7.F9 42.45,72.67 42.45,69.67 R255.1
M_B4_ZQ0: length 3.8
  TOP w0.102: R256.1 v1(43.38,83.68) 43.38,85.05 U6.F9
M_B_A0: length 166.6
  TOP w0.076: U5.P3 35.6,56.23 34.99,55.62 33.72,55.62 33.13,55.03 v1(33.13,54.52) ; U7.P3 35.6,77.66 34.99,77.04 34.23,77.04 v1(33.13,75.95) ; U6.P3 35.6,90.96 34.8,90.16 v1(34.22,90.16) 33.76,90.16 32.28,91.63 32.28,94.13 31.18,95.24 R274.2 ; v1(33.77,41.62) 33.53,41.62 33.42,41.72 33.42,42.14 33.56,42.28 34.96,42.28 35.6,42.91 35.7,42.91 U4.P3
  IN1 w0.089: v1(34.22,90.16) 34.19,90.12 34.19,89.69 34.11,89.62 33.87,89.62 33.79,89.54 33.79,89.43 33.87,89.35 34.11,89.35 34.19,89.27 34.19,89.16 34.11,89.08 33.87,89.08 33.79,89 33.79,88.89 33.87,88.82 34.11,88.82 34.19,88.74 34.19,87.97 34.05,87.83 34.05,81.91 34.21,81.75 34.21,79.8 33.44,79.03 33.44,78.5 33.62,78.32 33.62,77.46 33.32,77.16 33.32,76.13 v1(33.13,75.95) 33.32,75.76 33.32,75.05 33.82,74.55 33.82,70.21 33.74,70.13 33.41,70.13 33.34,70.06 33.34,69.95 33.41,69.87 33.74,69.87 33.82,69.79 33.82,69.68 33.74,69.6 33.41,69.6 33.34,69.52 33.34,69.41 33.41,69.33 33.74,69.33 33.82,69.26 33.82,69.15 33.74,69.07 33.41,69.07 33.34,68.99 33.34,68.88 33.41,68.8 33.74,68.8 33.82,68.72 33.82,64.2 33.67,64.05 33.67,63.06 33.84,62.88 33.84,62.71 33.67,62.53 33.67,61.23 34.21,60.69 34.21,58.73 33.44,57.97 33.44,55.86 33.32,55.74 33.32,54.75 33.13,54.56 v1(33.13,54.52) 33.32,54.34 33.32,53.64 33.84,53.12 33.84,52.03 33.55,51.74 33.55,49.76 33.08,49.29 33.08,48.93 33.72,48.29 33.72,46.44 33.91,46.25 33.91,44.96 33.41,44.46 33.41,41.97 33.18,41.74 33.18,41.39 33.36,41.21 33.36,41.03 33.21,40.88 32.95,40.88 32.83,40.75 32.83,40.55 32.95,40.42 33.53,40.42 33.65,40.55 33.65,40.89 34.06,41.3 34.06,41.5 33.95,41.62 v1(33.77,41.62)
  IN3 w0.14: v2(65.97,64.78) 65.92,64.83 60.34,64.83 59.44,63.94 59.04,63.94 58.92,63.81 58.92,63.43 58.79,63.31 58.62,63.31 58.5,63.43 58.5,63.81 58.37,63.94 58.2,63.94 58.08,63.81 58.08,63.43 57.96,63.31 57.78,63.31 57.66,63.43 57.66,63.81 57.54,63.94 57.36,63.94 57.24,63.81 57.24,63.43 57.12,63.31 56.94,63.31 56.82,63.43 56.82,63.81 56.7,63.94 54.73,63.94 54.58,63.78 54.58,63.44 54.44,63.3 51.68,63.3 51.47,63.51 51.47,64.05 51.14,64.38 41.07,64.38 40.95,64.26 40.95,64.01 40.83,63.89 40.65,63.89 40.53,64.01 40.53,64.26 40.41,64.38 39.91,64.38 39.63,64.66 37.31,64.66 36.74,64.1 35.94,64.1 35.21,63.37 35.21,61.81 35.04,61.65 34.87,61.65 34.6,61.92 34.42,61.92 34.3,61.8 34.3,61.62 34.57,61.35 34.57,61.18 34.45,61.05 34.28,61.05 34,61.33 33.83,61.33 33.71,61.21 33.71,61.03 33.98,60.76 33.98,60.58 33.86,60.46 33.68,60.46 33.41,60.74 33.24,60.74 33.11,60.61 33.11,60.44 33.39,60.17 33.39,59.99 33.26,59.87 33.09,59.87 32.82,60.14 32.64,60.14 30.1,57.6 30.1,53.13 30.24,52.99 30.69,52.99 30.82,52.86 30.82,52.69 30.69,52.57 30.52,52.57 30.4,52.45 30.4,52.27 30.52,52.15 30.69,52.15 30.82,52.03 30.82,51.85 30.69,51.73 30.52,51.73 30.4,51.61 30.4,51.43 30.52,51.31 30.69,51.31 30.82,51.19 30.82,51.01 30.69,50.89 30.52,50.89 30.4,50.77 30.4,50.6 30.52,50.47 30.69,50.47 30.82,50.35 30.82,50.18 30.69,50.05 30.52,50.05 30.4,49.93 30.4,49.76 30.52,49.63 30.69,49.63 30.82,49.51 30.82,49.34 30.69,49.22 30.52,49.22 30.4,49.09 30.4,48.92 30.52,48.8 30.69,48.8 30.82,48.67 30.82,48.5 30.69,48.38 30.52,48.38 30.4,48.25 30.4,47.82 30.51,47.7 30.79,47.7 30.94,47.85 31.29,47.85 31.54,47.6 31.54,46.68 32.02,46.19 32.02,45.39 32.34,45.08 32.34,44.86 32.46,44.74 32.57,44.74 32.7,44.62 32.7,44.44 32.58,44.32 32.46,44.32 32.34,44.2 32.34,44.02 32.46,43.9 32.58,43.9 32.7,43.78 32.7,43.6 32.58,43.48 32.46,43.48 32.34,43.36 32.34,42.78 32.34,41.72 32.45,41.62 32.66,41.62 32.79,41.74 32.79,42.46 32.89,42.56 33.17,42.56 33.31,42.42 33.31,42.37 33.45,42.23 34.68,42.23 34.78,42.13 34.78,41.94 34.64,41.79 33.95,41.79 v1(33.77,41.62)
  BOTTOM w0.076: v2(65.97,64.78) 65.97,63.93 66.08,63.82 66.24,63.82 66.32,63.9 66.32,64.35 66.39,64.43 66.52,64.43 66.6,64.35 66.6,63.9 66.67,63.82 66.8,63.82 66.88,63.9 66.88,64.39 66.95,64.46 67.08,64.46 67.15,64.39 67.15,63.93 67.23,63.86 67.44,63.86 67.58,63.99 73.26,63.99 73.5,63.76 74.49,63.76 74.6,63.65 74.86,63.65 75.05,63.75 75.2,63.9 U1.AG36
M_B_A1: length 163
  TOP w0.076: U4.P7 35.84,39.91 35.53,39.91 35.14,40.3 34.86,40.3 v1(34.48,40.68) ; U6.P7 35.87,87.48 35.75,87.36 35.54,87.36 35.44,87.46 35.44,88.4 v1(35.34,88.51) 34.73,88.51 33.98,89.25 33.64,89.25 31.56,91.33 31.56,91.93 31.15,92.34 R275.2 ; U7.P7 35.09,75.23 v1(34.48,75.23) ; v1(34.48,53.81) 35.09,53.81 U5.P7
  IN1 w0.089: v1(34.48,40.68) 34.48,40.17 34.89,39.76 34.89,39.48 34.8,39.39 34.63,39.39 33.79,40.22 33.79,40.33 34.02,40.55 34.02,40.87 34.28,41.13 34.4,41.13 34.53,41.26 34.53,41.41 34.44,41.5 34.39,41.5 34.31,41.58 34.31,41.75 34.73,42.17 34.73,42.38 34.91,42.56 34.91,42.61 34.73,42.79 34.73,42.96 34.81,43.04 34.95,43.04 35.1,43.19 35.1,44.6 34.96,44.74 34.78,44.74 34.67,44.86 34.67,44.97 34.75,45.04 35.01,45.04 35.08,45.12 35.08,45.23 35.01,45.31 34.76,45.31 34.67,45.4 34.67,45.5 34.74,45.58 34.74,45.79 34.67,45.86 34.67,46.57 34.48,46.76 34.48,48.61 34.07,49.02 34.07,49.2 34.31,49.44 34.31,51.42 34.61,51.72 34.61,52.96 34.73,53.08 34.73,53.56 v1(34.48,53.81) 34.23,53.81 34.08,53.96 34.08,55.42 34.22,55.57 34.22,55.95 34.48,56.21 34.86,56.21 35.12,56.46 35.12,56.78 34.55,57.36 34.55,58 34.97,58.42 34.97,60.43 35.32,60.78 35.32,64.84 35.24,64.92 34.94,64.92 34.86,64.99 34.86,65.1 34.94,65.18 35.24,65.18 35.32,65.26 35.32,65.37 35.24,65.45 34.94,65.45 34.86,65.53 34.86,65.64 34.94,65.72 35.24,65.72 35.32,65.79 35.32,65.9 35.24,65.98 34.94,65.98 34.86,66.06 34.86,66.17 34.94,66.25 35.24,66.25 35.32,66.33 35.32,67.25 34.58,67.99 34.58,74.38 34.73,74.53 34.73,74.99 v1(34.48,75.23) 34.22,75.23 34.08,75.37 34.08,76.85 35.12,77.89 35.12,79.69 34.97,79.84 34.97,82.07 34.82,82.22 34.82,87.51 35.14,87.84 35.14,88.01 34.96,88.2 34.96,88.4 35.06,88.51 v1(35.34,88.51)
  IN3 w0.14: v2(67.52,67.42) 67.52,67.16 67.37,67 66.24,67 65.84,67.41 65.84,67.84 65.74,67.94 59.81,67.94 59.5,68.25 51.93,68.25 51.81,68.13 51.81,67.72 51.68,67.6 51.43,67.6 51.31,67.72 51.31,68.94 51.19,69.06 51.01,69.06 50.89,68.94 50.89,67.72 50.77,67.6 50.59,67.6 50.47,67.72 50.47,68.94 50.35,69.06 50.18,69.06 50.05,68.94 50.05,67.72 49.93,67.6 49.76,67.6 49.63,67.72 49.63,68.13 49.51,68.25 49.3,68.25 49.13,68.09 49.13,67.67 49.04,67.58 35.62,67.58 32.44,64.4 32.27,64.4 32.12,64.55 31.95,64.55 31.83,64.42 31.83,64.25 31.97,64.11 31.97,63.93 31.85,63.81 31.68,63.81 31.53,63.95 31.36,63.95 31.24,63.83 31.24,63.66 31.38,63.51 31.38,63.34 31.26,63.22 31.08,63.22 30.94,63.36 30.77,63.36 30.64,63.24 30.64,63.06 30.79,62.92 30.79,62.75 30.66,62.62 30.49,62.62 30.35,62.77 30.17,62.77 30.05,62.65 30.05,62.47 30.19,62.33 30.19,62.15 30.07,62.03 29.9,62.03 29.75,62.18 29.58,62.18 27.64,60.24 27.64,59.61 27.18,59.15 27.18,45.13 31.42,40.89 33.21,40.89 33.47,40.63 34.43,40.63 v1(34.48,40.68)
  BOTTOM w0.076: v2(67.52,67.42) 66.95,66.85 66.95,65.33 67.92,64.36 73.36,64.36 73.63,64.09 74.29,64.09 74.36,64.16 74.84,64.16 74.93,64.13 75.2,64.13 75.31,64.16 75.51,64.16 75.63,64.13 75.65,64.13 75.88,63.9 U1.AG35
M_B_A2: length 169.3
  TOP w0.076: U7.R3 35.03,77.66 34.69,77.31 32.42,77.31 32.17,77.06 v1(32.07,77.06) ; U5.R3 35.03,56.23 34.69,55.89 33.1,55.89 32.83,55.61 32.83,55.41 32.7,55.28 32.24,55.28 32.07,55.46 v1(32.07,55.64) ; U4.R3 35.07,43.07 34.73,42.73 32.75,42.73 v1(31.91,41.9) ; U6.R3 35.03,90.96 34.69,90.61 34.13,90.61 34.12,90.6 33.9,90.6 v1(33.72,90.79) 32.52,91.98 32.52,94.23 31.01,95.74 30.03,95.74 29.6,96.18 R276.2
  IN1 w0.089: v1(31.91,41.9) 31.91,42.12 32.4,42.61 32.4,44.62 32.2,44.82 31.67,44.82 31.48,45.01 31.48,46.11 31.56,46.19 32.07,46.19 32.17,46.09 32.17,45.96 31.94,45.73 31.94,45.45 32.19,45.2 32.63,45.2 32.89,45.46 32.89,45.83 32.7,46.02 32.7,47.87 31.58,48.99 31.58,50.35 32.47,51.24 32.47,52.01 32.3,52.18 32.3,53.64 31.91,54.03 31.91,55.49 v1(32.07,55.64) 32.07,55.93 32.39,56.25 32.39,58.36 33.19,59.16 33.19,59.75 32.65,60.29 32.65,64.47 32.8,64.62 32.8,65.79 32.72,65.87 32.35,65.87 32.27,65.95 32.27,66.06 32.35,66.14 32.72,66.14 32.8,66.21 32.8,66.32 32.72,66.4 32.35,66.4 32.27,66.48 32.27,71.4 32.35,71.48 32.68,71.48 32.77,71.57 32.77,71.69 32.68,71.78 32.35,71.78 32.27,71.86 32.27,72.46 32.47,72.67 32.47,73.44 32.21,73.7 32.21,75.03 31.91,75.33 31.91,76.19 31.79,76.31 31.79,76.69 32.07,76.96 v1(32.07,77.06) 32.07,77.35 32.39,77.68 32.39,79.42 33.19,80.22 33.19,81.33 33.03,81.49 33.03,83.64 32.66,84.02 32.66,86.3 32.9,86.55 32.9,87.94 33.54,88.58 33.54,89.3 33.46,89.38 33.25,89.38 33.17,89.46 33.17,89.57 33.25,89.65 33.46,89.65 33.54,89.73 33.54,89.84 33.46,89.92 33.16,89.92 33.08,89.99 33.08,90.1 33.16,90.18 33.68,90.18 33.84,90.35 33.84,90.66 v1(33.72,90.79)
  IN3 w0.14: v1(31.91,41.9) 31.91,42.06 31.84,42.14 31.47,42.14 31.29,42.31 31.29,42.46 31.39,42.56 31.77,42.56 31.99,42.77 31.99,44.89 31.61,45.27 31.61,46.3 30.93,46.98 30.24,46.98 30.1,47.12 30.1,52.28 29.81,52.58 29.81,57.72 32.43,60.34 32.43,60.54 32.14,60.82 32.14,61.02 32.34,61.22 32.52,61.22 32.82,60.91 33,60.91 33.12,61.04 33.12,61.21 32.81,61.52 32.81,61.69 32.94,61.81 33.11,61.81 33.42,61.51 33.59,61.51 33.71,61.63 33.71,61.8 33.41,62.11 33.41,62.28 33.89,62.77 34.78,62.77 34.92,62.91 34.92,63.49 36.38,64.95 40.21,64.95 40.49,64.67 51.34,64.67 51.76,64.25 51.76,63.73 51.9,63.59 52.1,63.59 52.2,63.69 52.2,64.36 52.32,64.48 52.49,64.48 52.62,64.36 52.62,63.72 52.74,63.59 52.91,63.59 53.04,63.72 53.04,64.36 53.16,64.48 53.33,64.48 53.45,64.36 53.45,63.72 53.58,63.59 53.75,63.59 53.87,63.72 53.87,64.52 54,64.65 54.17,64.65 54.29,64.52 54.29,64.32 54.42,64.19 54.59,64.19 54.71,64.32 54.71,64.63 54.83,64.75 55.01,64.75 55.13,64.63 55.13,64.35 55.25,64.23 55.43,64.23 55.55,64.35 55.55,64.63 55.67,64.75 55.85,64.75 55.97,64.63 55.97,64.35 56.09,64.23 56.27,64.23 56.39,64.35 56.39,64.63 56.51,64.75 56.68,64.75 56.81,64.63 56.81,64.35 56.93,64.23 57.1,64.23 57.23,64.35 57.23,64.63 57.35,64.75 57.52,64.75 57.65,64.63 57.65,64.35 57.77,64.23 57.94,64.23 58.06,64.35 58.06,64.63 58.19,64.75 58.36,64.75 58.48,64.63 58.48,64.35 58.61,64.23 59.32,64.23 59.53,64.44 59.53,64.86 59.8,65.12 60.98,65.12 61.1,65.25 61.1,65.64 61.23,65.77 61.4,65.77 61.52,65.64 61.52,65.25 61.65,65.12 61.82,65.12 61.94,65.25 61.94,65.64 62.06,65.77 62.24,65.77 62.36,65.64 62.36,65.25 62.48,65.12 65.33,65.12 65.59,65.39 67.4,65.39 67.58,65.22 68.97,65.22 69.1,65.34 69.1,65.62 69.22,65.75 69.39,65.75 69.52,65.62 69.52,65.34 69.64,65.22 69.9,65.22 70.04,65.36 v2(70.04,65.73)
  BOTTOM w0.076: U1.AF34 75.97,64.95 75.3,64.95 75.21,64.98 75,64.98 74.88,64.95 74.6,64.95 74.42,65.13 73.63,65.13 73.36,64.86 72.4,64.86 72.24,65.02 72.15,65.02 71.98,64.86 68.96,64.86 68.85,64.97 68.55,64.97 68.44,64.86 68.31,64.86 68.21,64.96 68.21,65.18 68.28,65.25 68.75,65.25 69.04,65.54 69.04,65.87 69.15,65.99 69.92,65.99 70.04,65.87 v2(70.04,65.73)
M_B_A3: length 165.2
  TOP w0.076: v1(34.5,54.56) 34.55,54.52 35.18,54.52 36.25,53.45 36.25,52.67 36.36,52.57 36.54,52.57 36.67,52.7 U5.N7 ; U7.N7 35.28,75.84 34.68,75.84 34.65,75.87 v1(34.5,75.87) ; v1(35.39,40.75) 35.39,40.7 35.4,40.7 35.4,40.57 35.72,40.25 36.08,40.25 36.44,39.88 U4.N7 ; U6.N7 36.51,87.91 36.51,88.63 v1(35.62,89.52) 35.37,89.52 35.34,89.5 33.74,89.5 31.8,91.43 31.8,92.18 R277.2
  IN1 w0.089: v1(35.39,40.75) 35.52,40.63 35.52,40.04 35.39,39.91 35.09,39.91 34.92,40.08 34.92,41.05 34.79,41.18 34.79,41.75 34.99,41.95 34.99,42.28 35.35,42.64 35.35,45.54 34.92,45.97 34.92,46.68 34.73,46.87 34.73,48.72 34.44,49.01 34.44,49.21 34.57,49.33 34.57,51.32 34.86,51.61 34.86,52.85 34.98,52.97 34.98,53.91 34.5,54.39 v1(34.5,54.56) 34.5,54.59 34.33,54.77 34.33,55.32 34.48,55.46 34.48,55.84 34.59,55.95 34.97,55.95 35.38,56.36 35.38,56.89 34.8,57.46 34.8,57.89 35.22,58.31 35.22,60.32 35.57,60.67 35.57,65.33 35.65,65.41 36.1,65.41 36.17,65.48 36.17,65.59 36.1,65.67 35.65,65.67 35.57,65.75 35.57,65.86 35.65,65.94 36.1,65.94 36.17,66.02 36.17,66.75 34.83,68.09 34.83,74.25 34.98,74.4 34.98,75.33 34.5,75.81 v1(34.5,75.87) 34.5,76.02 34.35,76.18 34.35,76.76 35.38,77.79 35.38,79.79 35.22,79.95 35.22,82.18 35.07,82.33 35.07,87.4 35.77,88.1 35.77,88.87 35.62,89.01 35.32,89.01 35.22,89.11 35.22,89.42 35.32,89.52 v1(35.62,89.52)
  IN3 w0.14: v1(35.39,40.75) 35.39,40.32 35.11,40.04 34.3,40.04 33.97,40.37 33.39,40.37 33.11,40.65 31.25,40.65 26.89,45.01 26.89,59.27 27.35,59.73 27.35,60.36 32.15,65.16 32.32,65.16 32.46,65.01 32.64,65.01 32.76,65.13 32.76,65.31 32.62,65.45 32.62,65.63 32.74,65.75 32.91,65.75 33.06,65.6 33.23,65.6 33.35,65.73 33.35,65.9 33.21,66.05 33.21,66.22 33.33,66.34 33.51,66.34 33.65,66.2 33.82,66.2 33.95,66.32 33.95,66.49 33.8,66.64 33.8,66.81 33.93,66.93 34.1,66.93 34.24,66.79 34.42,66.79 35.55,67.92 48.46,67.92 49.89,69.36 53.36,69.36 53.51,69.2 53.51,68.71 53.68,68.54 53.97,68.54 54.09,68.67 54.09,69.23 54.22,69.36 54.39,69.36 54.51,69.23 54.51,68.67 54.63,68.54 54.81,68.54 54.93,68.67 54.93,69.23 55.05,69.36 55.23,69.36 55.35,69.23 55.35,68.67 55.47,68.54 55.65,68.54 55.77,68.67 55.77,69.23 55.89,69.36 56.07,69.36 56.19,69.23 56.19,68.67 56.31,68.54 56.48,68.54 56.61,68.67 56.61,69.23 56.73,69.36 56.9,69.36 57.03,69.23 57.03,68.67 57.15,68.54 57.32,68.54 57.45,68.67 57.45,69.23 57.57,69.36 57.74,69.36 57.86,69.23 57.86,68.67 57.99,68.54 59.62,68.54 59.94,68.23 65.99,68.23 66.13,68.09 66.13,67.78 v2(66.36,67.55)
  BOTTOM w0.076: v2(66.36,67.55) 66.36,65.49 67.65,64.2 73.29,64.2 73.56,63.92 74.73,63.92 U1.AG37
M_B_A4: length 164
  TOP w0.076: R279.2 32.04,92.91 32.04,91.53 33.84,89.74 35.08,89.74 v1(35.49,90.16) 35.62,90.16 36.42,90.96 U6.N3 ; U5.N3 36.67,56.09 36.86,55.9 36.86,55.77 36.72,55.63 36.62,55.63 36.38,55.87 35.62,55.87 35.37,55.61 35.37,54.85 35.28,54.76 35.14,54.76 v1(34.76,55.14) ; U4.N3 36.42,43.08 35.47,42.12 35.47,42.1 v1(35.42,42.05) ; U7.N3 36.31,77.29 35.59,77.29 34.77,76.47 v1(34.77,76.45)
  IN1 w0.089: v1(35.49,90.16) 35.49,90.54 35.62,90.66 35.88,90.66 36.05,90.49 36.05,88.02 35.32,87.3 35.32,82.43 35.48,82.28 35.48,80.05 35.63,79.9 35.63,77.68 34.77,76.82 v1(34.77,76.45) 34.94,76.28 34.94,75.73 35.24,75.44 35.24,74.29 35.09,74.15 35.09,68.2 36.43,66.86 36.43,65.13 36.35,65.05 35.9,65.05 35.83,64.97 35.83,64.86 35.9,64.78 36.35,64.78 36.43,64.7 36.43,64.59 36.35,64.51 35.9,64.51 35.83,64.44 35.83,60.57 35.48,60.22 35.48,58.21 35.06,57.79 35.06,57.57 35.63,56.99 35.63,56.25 34.76,55.38 v1(34.76,55.14) 34.93,54.97 34.93,54.32 35.24,54.01 35.24,52.87 35.11,52.74 35.11,51.51 34.82,51.21 34.82,48.99 34.99,48.82 34.99,48.25 35.09,48.14 35.56,48.14 35.65,48.05 35.65,47.93 35.56,47.84 35.06,47.84 34.99,47.76 34.99,47.66 35.08,47.57 35.57,47.57 35.64,47.5 35.64,47.38 35.57,47.31 35.09,47.31 35.01,47.23 35.01,47.1 35.08,47.04 35.53,47.04 35.61,46.96 35.61,46.85 35.53,46.77 35.26,46.77 35.18,46.69 35.18,46.59 35.27,46.5 35.59,46.5 35.66,46.43 35.66,46.32 35.58,46.24 35.28,46.24 35.19,46.15 35.19,46.06 35.28,45.97 35.69,45.97 35.77,45.88 35.77,45.79 35.61,45.63 35.61,42.19 35.47,42.05 v1(35.42,42.05)
  IN3 w0.14: v2(73.01,65.77) 73.17,65.93 73.17,66.51 73.03,66.65 72.04,66.65 71.91,66.53 71.91,66.29 71.79,66.17 71.62,66.17 71.49,66.29 71.49,66.53 71.37,66.65 71.2,66.65 71.08,66.53 71.08,66.29 70.95,66.17 65.83,66.17 64.94,67.06 59.41,67.06 58.78,66.43 56.37,66.43 56.11,66.69 55.15,66.69 55.08,66.76 55.08,67.08 54.94,67.22 54.8,67.22 54.66,67.08 54.66,66.86 54.48,66.69 52.32,66.69 52.19,66.55 52.15,66.55 52.02,66.43 52.02,66.1 51.9,65.98 51.73,65.98 51.6,66.1 51.6,66.43 51.48,66.55 51.31,66.55 51.19,66.43 51.19,66.1 51.06,65.98 50.89,65.98 50.77,66.1 50.77,66.43 50.64,66.55 50.47,66.55 50.35,66.43 50.35,66.09 50.22,65.97 50.05,65.97 49.93,66.09 49.93,66.43 49.81,66.55 49.63,66.55 49.51,66.43 49.51,66.23 49.39,66.11 49.21,66.11 49.09,66.23 49.09,66.43 48.97,66.55 48.68,66.55 48.55,66.43 48.55,66.18 48.43,66.06 48.26,66.06 48.13,66.18 48.13,66.43 48.01,66.55 47.28,66.55 47.07,66.35 46.83,66.35 46.62,66.55 46.27,66.55 46.01,66.3 45.86,66.3 45.6,66.55 45.25,66.55 45,66.31 44.83,66.31 44.59,66.55 44.23,66.55 43.96,66.28 43.85,66.28 43.57,66.55 43.22,66.55 43.01,66.35 42.76,66.35 42.55,66.55 42.19,66.55 41.95,66.31 41.78,66.31 41.54,66.55 41.19,66.55 40.88,66.25 35.54,66.25 30.84,61.55 30.84,60.66 28.06,57.88 28.06,52.39 28.18,52.27 28.39,52.27 28.52,52.14 28.52,51.97 28.39,51.85 28.18,51.85 28.06,51.72 28.06,51.43 28.18,51.31 28.39,51.31 28.52,51.19 28.52,51.01 28.39,50.89 28.18,50.89 28.06,50.77 28.06,50.59 28.18,50.47 28.39,50.47 28.52,50.35 28.52,50.17 28.39,50.05 28.18,50.05 28.06,49.93 28.06,49.75 28.18,49.63 28.39,49.63 28.52,49.51 28.52,49.34 28.39,49.21 28.18,49.21 28.06,49.09 28.06,48.92 28.18,48.79 28.39,48.79 28.52,48.67 28.52,48.5 28.39,48.37 28.18,48.37 28.06,48.25 28.06,48.08 28.18,47.96 28.39,47.96 28.52,47.83 28.52,47.66 28.39,47.54 28.18,47.54 28.06,47.41 28.06,45.71 29.14,44.63 31.08,44.63 31.39,44.31 31.39,43.61 30.95,43.17 30.95,42.22 31.8,41.38 33.41,41.38 33.6,41.18 33.95,41.18 34.24,41.48 34.68,41.48 35.25,42.05 v1(35.42,42.05)
  BOTTOM w0.076: v2(73.01,65.77) 73.01,65.71 73.09,65.63 74.91,65.63 75.04,65.55 75.69,65.55 U1.AE35
M_B_A5: length 158.7
  TOP w0.076: U6.P8 35.55,86.96 35.15,87.36 34.1,87.36 33.84,87.62 33.84,88.07 v1(33.77,88.15) ; R278.2 31.43,90.41 v1(31.68,90.16) ; U5.P8 35.47,52.63 33.56,52.63 v1(33.25,52.94) ; v1(33.34,74.38) 33.34,74.32 33.6,74.06 35.47,74.06 U7.P8 ; U4.P8 35.84,39.08 v1(35.44,39.48)
  IN1 w0.089: v1(35.44,39.48) 35.1,39.13 34.52,39.13 33.48,40.17 32.78,40.17 32.57,40.37 32.57,40.91 32.93,41.26 32.93,41.9 33.16,42.12 33.16,44.59 33.65,45.08 33.65,46.15 33.46,46.34 33.46,48.19 32.83,48.82 32.83,49.39 33.29,49.85 33.29,51.84 33.59,52.14 33.59,52.82 33.47,52.94 v1(33.25,52.94) 33.06,53.13 33.06,53.96 32.68,54.35 32.68,54.69 33.06,55.08 33.06,55.84 33.15,55.93 33.15,58.04 33.95,58.84 33.95,60.41 33.41,60.95 33.41,64.15 33.56,64.31 33.56,68.29 33.03,68.82 33.03,70.27 33.23,70.47 33.46,70.47 33.56,70.57 33.56,74.15 v1(33.34,74.38) 32.97,74.74 32.97,75.35 32.68,75.65 32.68,76.12 33.06,76.5 33.06,77.27 33.15,77.36 33.15,77.61 33.23,77.69 33.28,77.69 33.36,77.77 33.36,77.88 33.28,77.96 33.23,77.96 33.15,78.04 33.15,79.1 33.95,79.9 33.95,81.65 33.79,81.81 33.79,86.45 33.59,86.65 33.59,87.16 33.79,87.36 33.79,88.12 v1(33.77,88.15)
  IN3 w0.089: v1(31.68,90.16) 32.83,90.16 33.72,89.27 33.72,88.2 v1(33.77,88.15)
  IN3 w0.14: v2(68.69,67.42) 68.69,68.76 68.47,68.98 66.26,68.98 66.12,69.11 66.12,69.41 65.89,69.65 49.7,69.65 48.32,68.27 38.9,68.27 38.77,68.39 38.77,68.9 38.65,69.02 38.48,69.02 38.35,68.9 38.35,68.39 38.23,68.27 38.06,68.27 37.94,68.39 37.94,68.9 37.81,69.02 37.64,69.02 37.52,68.9 37.52,68.39 37.39,68.27 36.54,68.27 36.42,68.39 36.42,68.92 36.3,69.04 36.12,69.04 36,68.92 36,68.39 35.88,68.27 34.84,68.27 27.06,60.48 27.06,59.85 26.6,59.39 26.6,44.89 31.07,40.41 33.01,40.41 33.4,40.02 33.82,40.02 34.35,39.48 v1(35.44,39.48)
  BOTTOM w0.076: U1.AF35 75.49,64.78 75.27,64.78 75.17,64.82 75.03,64.82 74.89,64.78 74.54,64.78 74.35,64.96 73.7,64.96 73.43,64.69 68.24,64.69 68.05,64.89 68.05,65.25 68.21,65.42 68.68,65.42 68.87,65.61 68.87,65.92 68.69,66.1 v2(68.69,67.42)
M_B_A6: length 161.4
  TOP w0.076: R280.2 34.43,95.36 34.86,94.93 34.86,94.37 34.35,93.86 34.35,93.33 34.68,93 v1(34.68,92.99) 35.12,92.99 35.49,92.62 35.49,92.24 35.87,91.87 U6.P2 ; U5.P2 35.87,57.35 35.65,57.57 35.37,57.57 35.19,57.39 34.73,57.39 34.69,57.43 v1(33.87,57.43) ; v1(33.87,78.86) 35.58,78.86 35.87,78.57 U7.P2 ; U4.P2 35.94,43.95 35.94,44.27 36.02,44.35 36.22,44.35 36.31,44.26 36.31,43.62 36.16,43.48 v1(34.66,43.48)
  IN1 w0.089: v1(34.66,43.48) 34.48,43.3 34.48,42.28 34.22,42.02 33.95,42.02 33.67,42.3 33.67,44.33 34.16,44.83 34.16,46.36 33.97,46.55 33.97,48.4 33.46,48.91 33.46,49.31 33.81,49.65 33.81,51.64 34.1,51.93 34.1,53.22 33.57,53.75 33.57,55.63 33.72,55.78 33.72,57.28 v1(33.87,57.43) 33.87,58.04 34.46,58.63 34.46,60.65 34.71,60.9 34.71,61.01 34.62,61.1 34.18,61.1 34.1,61.18 34.1,61.29 34.18,61.36 34.72,61.36 34.8,61.44 34.8,61.57 34.73,61.63 34,61.63 33.92,61.71 33.92,61.82 34,61.9 34.47,61.9 34.55,61.98 34.55,63.8 34.48,63.87 34.3,63.87 34.22,63.79 34.22,63.73 34.15,63.65 34.01,63.65 33.92,63.74 33.92,63.94 34.07,64.1 34.07,74.66 33.57,75.16 33.57,77.06 33.87,77.36 v1(33.87,78.86) 34.46,79.45 34.46,81.86 34.31,82.01 34.31,87.72 34.45,87.86 34.45,89.69 34.66,89.9 34.66,90.73 34.24,91.16 34.24,92.55 v1(34.68,92.99)
  IN3 w0.14: v1(34.66,43.48) 34.19,43.48 34.09,43.58 34.09,43.97 33.96,44.09 33.67,44.09 33.57,43.99 33.57,43.3 33.47,43.2 33.25,43.2 33.06,43.39 33.06,45.67 32.17,46.55 32.17,46.71 32.05,46.83 31.95,46.83 31.83,46.95 31.83,47.12 31.95,47.25 32.05,47.25 32.17,47.37 32.17,47.66 31.64,48.19 31.18,48.19 31.11,48.26 31.11,48.55 31.23,48.67 31.47,48.67 31.59,48.8 31.59,48.97 31.47,49.09 31.23,49.09 31.11,49.22 31.11,49.39 31.23,49.51 31.47,49.51 31.59,49.63 31.59,49.81 31.47,49.93 31.23,49.93 31.11,50.05 31.11,50.51 31.23,50.63 31.67,50.63 31.8,50.75 31.8,50.93 31.67,51.05 31.23,51.05 31.11,51.17 31.11,53.26 30.97,53.4 30.54,53.4 30.4,53.55 30.4,53.73 30.52,53.86 31.02,53.86 31.14,53.98 31.14,54.15 31.02,54.28 30.52,54.28 30.4,54.4 30.4,54.57 30.52,54.7 31.02,54.7 31.14,54.82 31.14,54.99 31.02,55.11 30.52,55.11 30.4,55.24 30.4,55.41 30.52,55.53 31.02,55.53 31.14,55.66 31.14,55.83 31.02,55.95 30.52,55.95 30.4,56.08 30.4,56.79 30.54,56.93 30.92,56.93 31.14,57.14 31.14,58.15 32.13,59.15 32.32,59.15 32.69,58.78 32.81,58.78 33.23,59.19 33.23,59.42 35.66,61.85 35.66,62.15 35.5,62.31 35.5,63.25 36.06,63.8 36.87,63.8 37.43,64.37 39.51,64.37 40.29,63.59 41.32,63.59 41.44,63.72 41.44,63.97 41.56,64.09 41.73,64.09 41.86,63.97 41.86,63.72 41.98,63.59 42.15,63.59 42.28,63.72 42.28,63.97 42.4,64.09 42.57,64.09 42.7,63.97 42.7,63.72 42.82,63.59 42.99,63.59 43.11,63.72 43.11,63.97 43.24,64.09 43.41,64.09 43.53,63.97 43.53,63.72 43.66,63.59 43.83,63.59 43.95,63.72 43.95,63.97 44.08,64.09 44.25,64.09 44.37,63.97 44.37,63.72 44.49,63.59 44.67,63.59 44.79,63.72 44.79,63.97 44.91,64.09 45.09,64.09 45.21,63.97 45.21,63.72 45.33,63.59 45.51,63.59 45.63,63.72 45.63,63.97 45.75,64.09 45.93,64.09 46.05,63.97 46.05,63.72 46.17,63.59 46.34,63.59 46.47,63.72 46.47,63.97 46.59,64.09 46.76,64.09 46.89,63.97 46.89,63.72 47.01,63.59 47.18,63.59 47.31,63.72 47.31,63.97 47.43,64.09 51.02,64.09 51.18,63.93 51.18,63.39 51.56,63.01 58.93,63.01 60.46,64.54 65.65,64.54 65.81,64.38 66.73,64.38 66.97,64.61 66.97,64.89 67.11,65.03 67.35,65.03 67.51,64.88 70.36,64.88 70.75,65.26 71.43,65.26 71.5,65.33 71.5,65.49 v2(71.24,65.75)
  BOTTOM w0.076: U1.AE37 74.65,65.29 73.56,65.29 73.3,65.02 73.03,65.02 72.96,65.1 72.82,65.1 72.75,65.02 72.47,65.02 72.26,65.23 72.12,65.23 71.91,65.02 69.19,65.02 69.05,65.16 69.05,65.32 69.2,65.47 69.2,65.68 69.35,65.82 69.53,65.82 69.61,65.75 69.61,65.47 69.75,65.33 71.28,65.33 71.42,65.47 71.42,65.56 v2(71.24,65.75)
M_B_A7: length 161.8
  TOP w0.076: U7.R8 35.01,73.66 34.63,73.28 31.76,73.28 v1(31.53,73.05) ; U4.R8 35.01,39.08 34.66,39.43 33.97,39.43 33.77,39.64 32.8,39.64 v1(32.42,39.25) ; U5.R8 35.01,52.23 34.63,51.85 31.76,51.85 v1(31.53,51.62) ; R281.2 v1(30.57,86.5) 31.53,86.5 v1(31.68,86.65) 31.76,86.58 34.63,86.58 35.01,86.96 U6.R8
  IN1 w0.089: v1(32.42,39.25) 32.42,38.49 32.22,38.29 31.46,38.29 31.2,38.54 31.2,38.8 31.28,38.88 31.76,38.88 31.84,38.95 31.84,39.06 31.76,39.14 31.28,39.14 31.2,39.22 31.2,42.18 31.86,42.83 31.86,43.78 30.97,44.66 30.97,46.49 31.18,46.7 31.63,46.7 31.94,47 31.94,47.56 30.82,48.67 30.82,51.45 30.91,51.54 31.45,51.54 v1(31.53,51.62) 31.37,51.78 31.37,52.07 31.03,52.41 31.03,55.97 31.63,56.57 31.63,59.73 31.89,60 31.89,62.71 31.51,63.09 31.51,71.09 31.43,71.16 31.11,71.16 31.03,71.24 31.03,71.35 31.11,71.43 31.43,71.43 31.51,71.51 31.51,71.62 31.43,71.7 31.11,71.7 31.03,71.78 31.03,71.89 31.11,71.96 31.43,71.96 31.51,72.04 31.51,72.15 31.43,72.23 31.11,72.23 31.03,72.31 31.03,72.42 31.11,72.5 31.43,72.5 31.51,72.58 31.51,73.02 v1(31.53,73.05) 31.03,73.55 31.03,77.39 31.63,77.99 31.63,79.74 32.07,80.18 32.07,82.37 31.23,83.21 31.23,86.23 31.66,86.65 v1(31.68,86.65)
  IN3 w0.089: v2(79.4,66.62) 79.71,66.92 80.08,66.92 80.25,67.09 80.25,67.72 80.11,67.86 79.37,67.86 79.2,68.03 77.31,68.03 77.08,68.26
  IN3 w0.14: 77.08,68.26 77.08,68.53 76.11,69.5 75.33,69.5 75.32,69.51 72.2,69.51 71.19,70.52 47.49,70.52 46.88,69.92 35.26,69.92 26.18,60.84 26.18,60.22 25.72,59.76 25.72,44.52 29.54,40.71 29.54,39.92 30.06,39.4 30.84,39.4 30.99,39.25 v1(32.42,39.25)
  BOTTOM w0.079: v2(79.4,66.62) 79.69,66.33 U1.AC29
M_B_A8: length 158
  TOP w0.076: U5.R2 35.37,57.03 35.67,56.73 35.67,56.6 35.55,56.48 35.39,56.48 35.24,56.63 v1(34.67,56.63) ; v1(34.67,78.06) 35.07,78.46 U7.R2 ; R282.2 33.46,95.34 v1(34.33,94.47) ; v1(34.67,44.28) 35.47,44.28 35.53,44.22 35.53,43.95 35.46,43.88 U4.R2 ; v1(34.67,91.36) 35.07,91.76 U6.R2
  IN1 w0.089: v1(34.67,91.36) 35.05,91.36 35.36,91.05 35.36,90.91 34.92,90.47 34.92,89.65 34.7,89.43 34.7,87.76 34.56,87.62 34.56,82.12 34.71,81.97 34.71,78.1 v1(34.67,78.06) 34.67,77.8 33.82,76.95 33.82,75.27 34.33,74.76 34.33,67.74 34.4,67.66 34.53,67.66 34.61,67.59 34.61,67.48 34.53,67.4 34.4,67.4 34.33,67.32 34.33,67.21 34.4,67.13 34.53,67.13 34.61,67.05 34.61,66.94 34.53,66.86 34.4,66.86 34.33,66.79 34.33,66.68 34.4,66.6 34.53,66.6 34.61,66.52 34.61,66.41 34.53,66.33 34.4,66.33 34.33,66.25 34.33,66.14 34.4,66.06 34.53,66.06 34.61,65.99 34.61,65.88 34.53,65.8 34.4,65.8 34.33,65.72 34.33,65.61 34.4,65.53 34.53,65.53 34.61,65.45 34.61,65.34 34.53,65.26 34.4,65.26 34.33,65.19 34.33,65.08 34.4,65 34.53,65 34.61,64.92 34.61,64.81 34.53,64.73 34.4,64.73 34.33,64.65 34.33,64.57 34.42,64.48 34.97,64.48 35.06,64.39 35.06,64.13 34.98,64.05 34.88,64.05 34.8,63.98 34.8,63.87 34.88,63.79 34.98,63.79 35.06,63.71 35.06,63.6 34.98,63.52 34.88,63.52 34.8,63.44 34.8,63.33 34.88,63.25 34.98,63.25 35.06,63.18 35.06,63.07 34.98,62.99 34.88,62.99 34.8,62.91 34.8,62.8 34.88,62.72 34.98,62.72 35.06,62.64 35.06,62.53 34.98,62.45 34.88,62.45 34.8,62.38 34.8,62.27 34.88,62.19 34.98,62.19 35.06,62.11 35.06,60.89 34.71,60.54 34.71,58.52 34.29,58.1 34.29,57.24 34.67,56.87 v1(34.67,56.63) 34.47,56.63 34.23,56.88 34.06,56.88 33.97,56.79 33.97,56.63 34.16,56.44 34.16,56.31 33.97,56.12 33.97,55.67 33.82,55.53 33.82,53.85 34.35,53.33 34.35,51.82 34.06,51.53 34.06,49.55 33.72,49.2 33.72,49.01 34.22,48.51 34.22,46.66 34.42,46.47 34.42,44.7 33.92,44.21 33.92,42.43 34.01,42.34 34.14,42.34 34.22,42.43 34.22,44.06 34.45,44.28 v1(34.67,44.28)
  IN3 w0.089: v1(34.33,94.47) 34.22,94.37 34.22,91.93 34.67,91.49 v1(34.67,91.36)
  IN3 w0.14: v1(34.67,44.28) 34.58,44.37 33.55,44.37 33.41,44.51 33.41,44.73 33.51,44.83 34.02,44.83 34.12,44.93 34.12,45.16 34.02,45.26 33.52,45.26 33.42,45.36 33.42,45.78 32.46,46.75 32.46,47.78 31.88,48.36 31.88,50.42 32.12,50.66 32.12,51.24 31.97,51.4 31.97,51.81 32.12,51.96 32.12,52.24 32,52.36 31.52,52.36 31.4,52.48 31.4,52.66 31.52,52.78 32,52.78 32.12,52.9 32.12,54.06 32,54.19 31.51,54.19 31.39,54.31 31.39,54.48 31.51,54.61 32,54.61 32.12,54.73 32.12,55.02 31.9,55.25 31.59,55.25 31.43,55.41 31.43,55.98 31.55,56.1 32.11,56.1 32.24,56.23 32.24,56.4 32.11,56.52 31.55,56.52 31.43,56.64 31.43,56.82 31.55,56.94 32.09,56.94 32.21,57.06 32.21,57.24 32.09,57.36 31.55,57.36 31.43,57.48 31.43,57.73 31.57,57.87 31.96,57.87 32.12,58.03 32.12,58.55 32.19,58.63 32.43,58.63 32.57,58.48 33,58.48 33.52,59 33.52,59.3 36.13,61.91 36.13,62.09 35.79,62.43 35.79,63.12 36.18,63.51 36.99,63.51 37.55,64.08 39.39,64.08 40.17,63.3 47.67,63.3 47.8,63.42 47.8,63.67 47.92,63.8 48.09,63.8 48.22,63.67 48.22,63.42 48.34,63.3 48.51,63.3 48.63,63.42 48.63,63.67 48.76,63.8 48.93,63.8 49.05,63.67 49.05,63.42 49.18,63.3 49.35,63.3 49.47,63.42 49.47,63.67 49.6,63.8 49.77,63.8 49.89,63.67 49.89,63.42 50.01,63.3 50.19,63.3 50.31,63.42 50.31,63.67 50.43,63.8 50.61,63.8 50.73,63.67 50.73,63.42 51.44,62.72 58.16,62.72 58.24,62.65 58.24,62.41 58.39,62.26 58.59,62.26 60.58,64.25 65.53,64.25 65.69,64.09 66.85,64.09 67.35,64.58 70.77,64.58 70.89,64.71 70.89,64.84 71.01,64.96 71.19,64.96 71.31,64.84 71.31,64.71 71.43,64.58 71.6,64.58 71.73,64.71 71.73,64.84 71.85,64.96 72.02,64.96 72.15,64.84 72.15,64.71 72.27,64.58 73.1,64.58 73.24,64.72 73.24,64.91 73.38,65.05 74.5,65.05 74.62,65.17 74.62,66.98 74.51,67.09 73.71,67.09 73.55,66.93 73.55,66.59 73.69,66.45 73.94,66.45 74.13,66.25 74.13,65.73 73.99,65.59 73.4,65.59 73.15,65.33 71.97,65.33 71.83,65.47 v2(71.83,65.75)
  BOTTOM w0.076: v2(71.83,65.75) 71.59,65.51 71.59,65.3 71.7,65.19 71.84,65.19 72.05,65.4 72.33,65.4 72.54,65.19 72.68,65.19 72.82,65.33 72.96,65.33 73.1,65.19 73.23,65.19 73.5,65.46 74.88,65.46 74.99,65.39 75.21,65.39 U1.AE36
