# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB30_TX2+_C: length 1.4
  TOP w0.102: R430.2 23.46,37.56 23.82,37.56 24.06,37.79 C531.2
USB30_TX2+_C_R: length 11.8
  TOP w0.102: R430.1 21.88,37.56 21.66,37.56 C533.1 20.86,37.54 20.42,37.54 20.19,37.31 20.19,36.7 20.01,36.52 17.84,36.52 U17.6 17.72,36.52 16.61,36.52 16.52,36.44 15.56,36.44 15.05,36.94 14.16,36.94 13.56,37.54 13.31,37.54 13.1,37.75 CN3.9
USB30_TX2-: length 132.8
  TOP w0.102: C530.1 25.21,37.32 25.32,37.32 25.59,37.04 25.59,36.56 v1(25.33,36.31)
  IN3 w0.089: v2(98.58,43.65) 98.77,43.83 98.77,44 98.71,44.05 98.4,44.05 98.18,43.84 98.18,43.09 96.4,41.31 96.4,40.84 96.76,40.48 96.76,39.03 96.53,38.8 96.53,37.48 96.4,37.35 96.4,36.76 95.06,35.42 94.13,35.42 93.08,34.36 93.08,32.83 92.8,32.55 92.44,32.55 91.91,32.02 90.14,32.02 89.34,31.22 89.34,30.56 88.59,29.81 87.47,29.81 87.12,29.46 86.94,29.46 85.3,27.82 84.63,27.82 84.09,27.28 84.09,26.25 83.3,25.46 82.23,25.46 81.49,24.73 80.8,24.73 78.36,22.28 78.36,22.24 77.09,20.98 76.69,20.98 76.31,20.6 75.7,20.6 75.28,20.18 74.84,20.18 74.15,19.49 69.8,19.49 69.09,18.78 64.44,18.78 64.14,19.08 63.39,19.08 62.93,19.54 56.1,19.54 55.75,19.19 53.45,19.19 52.32,18.06 48.08,18.06 45.19,15.16 45.19,14.89 41.36,11.06 40.48,11.06 38.36,8.94 24.16,8.94 23.55,9.55 23.55,12.44 22.73,13.26 22.19,13.26 21.61,13.84 21.61,14.93 21.17,15.37 21.17,17.59 21.45,17.87 21.45,19.7 20.69,20.46 20.69,24.18 20.43,24.44 20.43,30.45 21.45,31.46 21.45,32.09 22.57,33.21 23.95,33.21 24.75,34.01 25.22,34.01 25.59,34.38 25.59,36.05 v1(25.33,36.31)
  BOTTOM w0.079: v2(98.58,43.65) 98.75,43.48 98.75,43.38 98.63,43.26 97.49,43.26 97.47,43.28 97.31,43.29 97.04,43.14 97.03,43.14 96.8,43.01 U1.CA2
USB30_TX2-_C: length 1.4
  TOP w0.102: C530.2 24.06,37.11 23.82,37.34 23.46,37.34 R429.2
USB30_TX2-_C_R: length 11.8
  TOP w0.102: R429.1 21.88,37.34 21.66,37.34 C532.1 20.9,37.32 20.51,37.32 20.41,37.22 20.41,36.61 20.1,36.3 19.8,36.3 U17.5 19.56,36.3 16.7,36.3 16.61,36.22 15.47,36.22 14.96,36.73 14.07,36.73 13.47,37.32 13.29,37.32 13.1,37.13 CN3.8
USB30_TX3+: length 178.5
  IN1 w0.089: v2(49.89,20.45) 49.67,20.23 49.22,20.23 48.09,19.1 48.09,17.89 48.45,17.54 48.45,16.32 48.71,16.06 49.23,16.06 49.39,16.22 49.39,17.88 49.48,17.97 49.83,17.97 49.92,17.88 49.92,15.94 50.13,15.73 50.65,15.73 50.89,15.97 50.89,18.9 50.95,18.96 51.31,18.96 51.42,18.85 51.42,16.37 51.6,16.19 52.13,16.19 52.36,16.42 52.36,18.31 52.45,18.4 52.61,18.4 52.89,18.11 52.89,15.89 53.08,15.71 53.6,15.71 53.81,15.92 53.81,17.88 53.9,17.97 54.03,17.97 54.34,17.66 54.34,15.49 54.08,15.23 49.71,15.23 47.32,12.83 47.32,12.14 45.2,10.02 41.87,10.02 37.91,6.05 37.91,4.39 37.67,4.15 35.4,4.15 35.19,3.94 35.19,3.34 35.1,3.25 34.74,3.25 34.65,3.34 34.65,3.94 34.45,4.15 32.15,4.15 31.94,3.94 31.94,3.34 31.85,3.25 31.5,3.25 31.41,3.34 31.41,3.94 31.2,4.15 29.08,4.15 28.74,3.82 28.74,3.33 28.27,2.85 14.64,2.85 13.47,4.02 13.47,10.09 13.78,10.4 15.26,10.4 15.7,9.96 22.14,9.96 22.83,10.65 24.05,10.65 v2(24.23,10.47)
  IN3 w0.089: v2(96.99,43.73) 97.04,43.73 97.19,43.57 97.19,43.37 96.39,42.57 96.39,42.27 95.29,41.16 95.29,38.35 95.11,38.17 95.11,37.64 91.83,34.36 91.83,33.19 91.54,32.9 89.78,32.9 87.57,30.69 87.12,30.69 86.76,30.34 86.02,30.34 84.49,28.8 84,28.8 83.37,28.18 83.25,28.18 82.99,27.92 82.99,27.43 82.38,26.81 81.89,26.81 81.49,26.41 81.49,26.12 80.99,25.61 80.44,25.61 77.91,23.07 77.37,23.07 76.92,22.63 76.92,22.07 76.71,21.86 76.33,21.86 75.97,21.5 75.36,21.5 74.98,21.13 74.54,21.13 74.26,20.85 67.83,20.85 67.3,20.31 67.3,20.08 67.02,19.8 65.42,19.8 64.71,20.51 50.6,20.51 50.25,20.16 49.98,20.16 49.89,20.24 v2(49.89,20.45) ; v1(22.25,22.13) 22.25,22.45 22.16,22.54 22.08,22.54 22,22.62 21.81,22.62 21.63,22.44 21.63,20.84 22.34,20.13 22.34,17.82 23.18,16.98 23.18,14.34 24.57,12.94 24.57,12.56 24.9,12.23 24.9,10.88 24.67,10.64 24.4,10.64 v2(24.23,10.47)
  BOTTOM w0.079: v2(96.99,43.73) 96.88,43.62 96.77,43.62 96.63,43.76 96.63,43.83 96.49,43.97 96.32,43.97 96.22,43.87 96.12,43.87 96.04,43.8 96.04,43.53 96.1,43.47 96.29,43.47 U1.BY3
  BOTTOM w0.102: v1(22.25,22.13) 22.25,22.48 22.19,22.53 22.03,22.53 21.88,22.68 21.66,22.68 21.59,22.61 C677.2
USB30_TX3-: length 178.6
  IN1 w0.089: v2(49.61,19.74) 49.61,19.93 49.52,20.03 49.31,20.03 48.3,19.02 48.3,17.98 48.65,17.62 48.65,16.41 48.79,16.27 49.15,16.27 49.19,16.31 49.19,17.96 49.39,18.17 49.92,18.17 50.13,17.96 50.13,16.03 50.21,15.94 50.57,15.94 50.68,16.05 50.68,18.98 50.87,19.16 51.39,19.16 51.62,18.93 51.62,16.46 51.69,16.39 52.04,16.39 52.16,16.51 52.16,18.4 52.37,18.6 52.69,18.6 53.1,18.2 53.1,15.98 53.16,15.91 53.52,15.91 53.61,16 53.61,17.96 53.81,18.17 54.11,18.17 54.54,17.74 54.54,15.4 54.16,15.02 49.8,15.02 47.52,12.75 47.52,12.06 45.28,9.82 41.96,9.82 38.11,5.97 38.11,4.3 37.76,3.95 35.48,3.95 35.39,3.86 35.39,3.25 35.18,3.05 34.66,3.05 34.45,3.25 34.45,3.86 34.36,3.95 32.23,3.95 32.14,3.86 32.14,3.25 31.94,3.05 31.41,3.05 31.2,3.25 31.2,3.86 31.12,3.95 29.16,3.95 28.95,3.73 28.95,3.24 28.36,2.65 14.56,2.65 13.27,3.94 13.27,10.18 13.69,10.6 15.34,10.6 15.78,10.16 22.05,10.16 22.75,10.86 24.03,10.86 v2(24.23,11.06)
  IN3 w0.089: v1(22.2,22.97) 22.05,22.83 21.73,22.83 21.42,22.52 21.42,20.76 22.13,20.04 22.13,17.73 22.97,16.89 22.97,14.25 24.37,12.86 24.37,12.47 24.7,12.15 24.7,10.96 24.58,10.85 24.44,10.85 v2(24.23,11.06) ; v2(49.61,19.74) 49.83,19.95 50.33,19.95 50.69,20.31 64.63,20.31 65.34,19.59 67.1,19.59 67.5,19.99 67.5,20.23 67.91,20.64 74.34,20.64 74.62,20.92 75.07,20.92 75.44,21.3 76.06,21.3 76.41,21.65 76.8,21.65 77.13,21.98 77.13,22.54 77.46,22.87 77.99,22.87 80.53,25.4 81.07,25.4 81.7,26.03 81.7,26.33 81.98,26.61 82.46,26.61 83.2,27.34 83.2,27.84 83.34,27.98 83.46,27.98 84.08,28.6 84.57,28.6 86.11,30.14 86.84,30.14 87.2,30.49 87.65,30.49 89.86,32.7 91.63,32.7 92.04,33.11 92.04,34.28 95.31,37.55 95.31,38.09 95.49,38.26 95.49,41.08 96.59,42.18 96.59,42.48 97.39,43.29 97.39,43.48 v2(97.57,43.65)
  BOTTOM w0.079: U1.BY4 96.02,43.31 96.99,43.31 97.33,43.5 97.42,43.5 v2(97.57,43.65)
  BOTTOM w0.102: C681.2 21.59,23.03 21.73,22.89 22.12,22.89 v1(22.2,22.97)
USB30_TX+_TYPEC1: length 21.7
  IN1 w0.089: v2(15.34,17.89) 15.15,17.89 15.05,17.8 15.05,16.98 14.64,16.57 14.64,16.35 14.78,16.22 15.8,16.22 16.04,16.45 16.04,18.13 16.26,18.35 16.65,18.35 16.85,18.15 16.85,16.08 16.17,15.4 13.83,15.4 v1(13.65,15.23)
  BOTTOM w0.102: C686.1 15.33,18.65 15.21,18.53 15.21,18.02 v2(15.34,17.89) ; CN10.A2 7.68,13.65 7.82,13.79 8.43,13.79 8.9,13.32 9.38,13.32 9.71,13.65 9.71,15.12 9.86,15.26 10,15.26 10.14,15.12 RV2.6 RV2.5 11.83,15.12 11.97,15.26 12.16,15.26 12.55,15.65 12.75,15.65 12.88,15.52 13.36,15.52 v1(13.65,15.23)
USB30_TX+_TYPEC1_C: length 3.8
  BOTTOM w0.102: C686.2 15.14,19.43 15,19.57 15,20.1 16.24,21.35 16.24,21.48 16.35,21.59 16.46,21.59 16.51,21.54 U6502.10
USB30_TX+_TYPEC2: length 24.4
  TOP w0.102: CN10.B2 5.52,18.11 9.2,18.11 9.61,17.7 9.61,17.18 9.82,16.97 10,16.97 10.14,17.12 RV3.6 RV3.5 11.76,17.12 11.88,17 12.09,17 12.19,17.1 12.19,17.57 v1(12.63,18.02)
  IN1 w0.089: v1(12.63,18.02) 12.42,17.8 12.25,17.8 12.05,18.01 12.05,18.5 12,18.55 12,19.62 11.36,20.26 11.36,23.07 12.01,23.72 13.16,23.72 14.92,25.49 17.69,25.49 18.01,25.81 18.01,26.08 v1(18.22,26.3)
  BOTTOM w0.102: v1(18.22,26.3) 18.22,26.03 C684.1
USB30_TX+_TYPEC2_C: length 1.6
  BOTTOM w0.102: C684.2 18.2,24.47 18.2,24.23 18.3,24.14 U6502.17
USB30_TX-_TYPEC1: length 21.7
  IN1 w0.089: v1(13.65,15.86) 13.9,15.61 16.09,15.61 16.65,16.17 16.65,18.06 16.56,18.15 16.34,18.15 16.24,18.05 16.24,16.37 15.89,16.01 14.69,16.01 14.44,16.27 14.44,16.66 14.85,17.07 14.85,17.81 14.77,17.89 v2(14.56,17.89)
  BOTTOM w0.102: CN10.A3 7.68,14.15 7.82,14.01 8.52,14.01 8.99,13.54 9.29,13.54 9.5,13.74 9.5,15.2 9.77,15.47 10,15.47 10.14,15.61 RV2.7 RV2.4 11.83,15.61 11.97,15.47 12.07,15.47 12.46,15.86 12.84,15.86 12.97,15.73 13.52,15.73 v1(13.65,15.86) ; v2(14.56,17.89) 14.77,17.89 15,18.12 15,18.54 14.89,18.65 C685.1
USB30_TX-_TYPEC1_C: length 3.8
  BOTTOM w0.102: C685.2 14.78,19.67 14.78,20.19 16.03,21.44 16.03,21.57 16.4,21.94 U6502.11
USB30_TX-_TYPEC2: length 24.4
  TOP w0.102: CN10.B3 5.52,17.89 9.11,17.89 9.4,17.61 9.4,17.09 9.73,16.76 10,16.76 10.14,16.62 RV3.7 RV3.4 11.74,16.62 11.91,16.78 12.18,16.78 12.4,17.01 12.4,17.26 12.53,17.39 v1(12.63,17.39)
  IN1 w0.089: v1(17.59,26.3) 17.8,26.08 17.8,25.89 17.61,25.69 14.84,25.69 13.07,23.93 11.93,23.93 11.16,23.16 11.16,20.17 11.8,19.54 11.8,18.46 11.85,18.42 11.85,17.92 12.17,17.6 12.42,17.6 v1(12.63,17.39)
  BOTTOM w0.102: C680.1 17.71,25.78 17.71,26.17 v1(17.59,26.3)
USB30_TX-_TYPEC2_C: length 1.6
  BOTTOM w0.102: C680.2 17.99,24.47 17.99,24.23 17.9,24.14 U6502.16
USB_BC_ON: length 221.4
  TOP w0.102: U37.97 197.25,29.27 197.62,28.89 197.62,28.52 197.11,28.01 197.11,27.24 196.87,27 195.78,27 195.16,26.39 195.16,25.86 195.49,25.53 195.49,24.27 196.91,22.85 196.91,22.31 196.61,22.01 196.61,20.86 196.77,20.71 197.34,20.71 v2(197.47,20.57) ; U14.4 22.31,47.03 v1(22.34,47.05) 22.62,47.05 v1(22.92,47.36)
  IN2 w0.089: v1(22.92,47.36) 23.25,47.36 24.04,46.57 24.04,46.32 24.55,45.8 24.55,44.99 24.75,44.79 25,44.79 25.26,44.54 25.26,43.79 24.75,43.28 24.75,41.13 24.87,41.01 24.87,37.47 24.52,37.12 24.52,35.4 26.63,33.29 26.75,33.29 28.33,31.71 29.42,31.71 31.57,29.56 34.34,29.56 36.11,27.79 39.46,27.79 39.89,27.37 39.89,26.64 43.07,23.46 46.79,23.46 49.01,21.24 52.17,21.24 52.75,20.66 57.67,20.66 59.46,18.87 61.75,18.87 63.59,17.03 71.18,17.03 72.17,18.03 76,18.03 76.16,17.87 78.82,17.87 83.67,22.72 89.1,22.72 94.14,17.68 97.91,17.68 98.08,17.5 102.34,17.5 102.41,17.57 104.34,17.57 105.18,18.4 111.27,18.4 112.86,19.99 113.27,19.99 114.13,20.85 119.91,20.85 120.96,21.89 125.63,21.89 127.15,20.37 130.35,20.37 131.25,19.47 131.81,19.47 132.66,20.32 134.5,20.32 135.07,20.89 136.79,20.89 137.34,20.34 155.14,20.34 155.26,20.22 163.3,20.22 163.58,20.5 165.01,20.5 165.19,20.67 167.34,20.67 167.56,20.45 175.66,20.45 176.13,20.92 176.13,21.35 176.46,21.68 176.95,21.68 177.12,21.52 178.28,21.52 178.35,21.6 179.91,21.6 180.54,20.97 180.74,20.97 181.02,20.69 181.67,20.69 181.87,20.49 186.26,20.49 186.49,20.72 187.54,20.72 187.77,20.49 191.3,20.49 191.66,20.13 192.85,20.13 193.48,20.76 193.79,20.76 194.25,20.3 194.53,20.3 195.39,19.44 196.1,19.44 196.33,19.67 196.33,20.25 196.76,20.67 197.37,20.67 v2(197.47,20.57)
USB_CHARGE_ON: length 217.3
  TOP w0.102: U37.96 197.61,28.18 197.34,27.91 197.34,27.15 196.97,26.78 195.87,26.78 195.39,26.3 195.39,25.96 195.72,25.63 195.72,24.37 197.17,22.92 197.17,22.24 196.84,21.91 196.84,21.41 197.01,21.23 197.01,21.18 v2(197.01,21.18) ; U14.5 23.04,47.88 23.17,47.75 R416.1 23.78,47.75 24.4,47.13 24.4,46.85 v1(24.9,46.34)
  IN2 w0.089: v2(197.01,21.18) 197.01,21.18 196.99,21.16 196.97,21.16 196.88,21.07 196.88,21.07 196.3,20.49 194.33,20.49 193.85,20.96 193.42,20.96 192.77,20.32 191.74,20.32 191.38,20.68 187.85,20.68 187.62,20.91 186.41,20.91 186.18,20.68 184.02,20.68 183.74,20.95 183.31,20.95 183.24,20.88 181.1,20.88 180.82,21.16 180.62,21.16 179.98,21.8 178.29,21.8 178.2,21.71 177.19,21.71 177.03,21.87 176.38,21.87 175.91,21.4 175.91,20.97 175.59,20.65 167.63,20.65 167.42,20.86 165.11,20.86 164.93,20.69 163.5,20.69 163.26,20.45 155.47,20.45 155.38,20.53 137.43,20.53 136.89,21.08 134.99,21.08 134.53,20.62 132.69,20.62 131.74,19.67 131.48,19.67 130.54,20.61 127.21,20.61 125.74,22.08 120.88,22.08 119.83,21.04 114.05,21.04 113.19,20.18 112.78,20.18 112.55,19.95 110.48,19.95 109.21,18.68 105.19,18.68 104.27,17.76 102.34,17.76 102.29,17.72 98.14,17.72 97.99,17.87 94.22,17.87 89.18,22.91 83.59,22.91 79.34,18.66 76.15,18.66 75.79,18.3 70.5,18.3 69.81,17.61 63.31,17.61 61.86,19.06 59.54,19.06 57.75,20.85 52.82,20.85 52.24,21.43 49.09,21.43 46.87,23.65 43.15,23.65 40.08,26.72 40.08,27.45 39.54,27.98 36.18,27.98 34.42,29.75 31.65,29.75 29.5,31.9 28.74,31.9 27.03,33.61 26.58,33.61 24.71,35.48 24.71,36.98 25.06,37.33 25.06,41.09 24.94,41.21 24.94,43.2 25.46,43.72 25.46,46.06 25.18,46.34 v1(24.9,46.34)
USB_CLT1: length 208.9
  TOP w0.102: v2(197.75,22.03) 197.75,21.75 198.12,21.38 U37.79 ; U14.6 23.76,48.38 24.4,47.74 v1(24.5,47.74) 24.9,47.33 v1(24.9,47)
  IN2 w0.089: v2(197.75,22.03) 197.65,22.13 196.96,22.13 195.51,20.68 194.41,20.68 193.93,21.15 193.34,21.15 192.69,20.51 191.82,20.51 191.45,20.87 187.93,20.87 187.7,21.1 186.33,21.1 186.1,20.87 184.16,20.87 183.86,21.17 183.26,21.17 183.16,21.07 181.18,21.07 180.9,21.35 180.7,21.35 180.06,22 178.21,22 178.12,21.9 177.27,21.9 177.11,22.06 176.01,22.06 175.88,21.93 175.3,21.93 174.21,20.84 167.71,20.84 167.48,21.07 165.03,21.07 164.89,20.92 163.46,20.92 163.2,20.66 156.79,20.66 156.72,20.72 137.51,20.72 136.97,21.27 134.92,21.27 134.5,20.85 132.61,20.85 131.66,19.9 131.52,19.9 130.57,20.85 127.58,20.85 126.15,22.27 121.92,22.27 121.8,22.39 120.92,22.39 119.85,21.32 114.07,21.32 113.13,20.38 112.71,20.38 112.56,20.23 110.49,20.23 109.13,18.87 105.11,18.87 104.21,17.97 102.28,17.97 102.23,17.92 98.2,17.92 98.06,18.06 94.3,18.06 89.26,23.1 83.51,23.1 79.27,18.86 76.08,18.86 75.75,18.53 70.46,18.53 69.73,17.8 63.56,17.8 62.09,19.26 59.6,19.26 57.82,21.04 52.9,21.04 52.32,21.62 49.16,21.62 46.95,23.84 43.22,23.84 40.27,26.79 40.27,27.52 39.62,28.17 36.26,28.17 34.5,29.94 31.73,29.94 29.58,32.09 28.82,32.09 27.03,33.88 27.03,36.75 26.31,37.48 25.25,38.53 25.25,41.17 25.13,41.29 25.13,43.12 25.72,43.71 25.72,46.42 25.13,47 v1(24.9,47)
USB_OC0#: length 158.1
  TOP w0.102: U14.13 17.57,49.38 16.93,50.02 15.05,50.02 14.79,49.77 14.79,49.26 15.68,48.37 15.68,47.84 15.48,47.64 15.48,47.03 14.29,45.83 14.29,45.48 16.95,42.81 16.95,37.71 17.46,37.2 v1(17.84,37.2)
  IN3 w0.089: v1(17.84,37.2) 17.59,37.2 16.25,35.86 16.25,25.94 17.35,24.84 17.35,15.11 19.34,13.12 19.34,10.09 22.18,7.25 22.18,6.25 23.1,5.33 24.6,5.33 25.28,4.65 30.54,4.65 31.21,3.99 32.02,3.99 32.26,4.23 37.17,4.23 41.69,8.75 43.85,8.75 47.56,12.46 47.56,12.61 49.48,14.52 49.78,14.52 50.1,14.85 71.67,14.85 72.97,16.15 78.31,16.15 83.74,21.58 89.45,21.58 90.52,20.51 95.31,20.51 96.96,22.16 96.96,25.26 96.43,25.79 v2(96.43,26.3)
  BOTTOM w0.079: 95.13,32.39 95.13,32.68 93.99,33.82 93.99,36.38 93.89,36.49 93.89,37.04 94.03,37.18 U1.CK6
  BOTTOM w0.102: v1(97.65,24.93) 97.58,25 C6614.2 ; 95.13,32.39 95.13,28.52 95.73,27.93 95.85,27.93 96.1,27.68 96.1,27.27 96.89,26.48 97.09,26.48 97.58,26 C6614.2 ; C6614.2 97.29,25.77 97.28,25.75 R60.1 96.43,26.11 v2(96.43,26.3)
USB_OC1#: length 171.8
  TOP w0.102: v1(23.63,45.86) 23.94,45.86 24.06,45.73 24.06,44.73 23.84,44.5 23.84,42.96 23.56,42.68 22.95,42.68 22.31,42.04 20.94,42.04 20.28,41.39 20.28,41.06 19.56,40.34 19.48,40.34 17.46,38.32 v1(17.46,37.83) ; v2(102.65,27.88) 102.65,27.95 102.04,28.56 101.53,28.56 100.89,29.21 100.89,30.1 100,30.98 R25439.1 99.78,31.45 C6613.2 99.12,31.84 98.51,32.45 98.06,32.45 98,32.5 v2(97.8,32.5)
  IN3 w0.089: v1(17.46,37.83) 17.46,37.71 16.06,36.31 16.06,27.26 12.78,23.98 11.8,23.98 11.33,23.5 11.33,21.71 11.92,21.11 16.54,21.11 17.16,20.49 17.16,15.03 19.15,13.04 19.15,10.01 21.99,7.17 21.99,6.17 23.02,5.14 24.52,5.14 25.2,4.46 30.46,4.46 31.13,3.8 32.1,3.8 32.34,4.04 37.24,4.04 41.77,8.56 43.93,8.56 47.75,12.38 47.75,12.53 49.56,14.33 49.86,14.33 50.18,14.66 72.02,14.66 73.32,15.96 79.83,15.96 80.27,15.51 80.99,15.51 81.06,15.58 81.06,17.61 84.08,20.62 89.22,20.62 90.05,19.8 95.57,19.8 97.95,22.19 97.95,23.96 99.02,25.03 101.69,25.03 102.09,25.44 102.09,27.06 102.65,27.62 v2(102.65,27.88)
  BOTTOM w0.079: U1.CK5 94.68,37.32 95.18,36.82 95.18,36.44 95.26,36.36 95.52,36.36 95.77,36.1 95.77,35.22 95.95,35.04 95.95,34.47 97.8,32.62 v2(97.8,32.5)
  BOTTOM w0.102: v1(23.63,45.86) 23.53,45.96 22.77,45.96 22.54,46.19 22.54,46.6 22.36,46.77 21.78,46.77 21.04,46.04 v1(20.74,46.04) 20.59,46.04 19.37,44.82 18.86,44.82 18.54,45.13 U15.3
USB_OC2#: length 137.4
  TOP w0.102: R25438.1 94.54,37.33 94.42,37.45 C6612.2 93.99,37.66 93.94,37.61 93.66,37.61 v2(93.2,38.06)
  IN1 w0.089: v2(208.04,19.65) 207.79,19.89 207.79,22.4 206.58,23.61 206.43,23.61 206.19,23.86 205.79,23.86 204.21,25.44 202.52,25.44 201.56,24.47 201.56,24.37 200.64,23.46 196.56,23.46 195.1,24.91 195.1,25.32 194.3,26.12 191.07,26.12 189.58,27.61 188.85,27.61 188.4,27.16 186.99,27.16 186.35,27.8 185.81,27.8 185.06,27.05 184.16,27.05 183.67,27.55 180.05,27.55 179.62,27.11 177.78,27.11 177.65,27.25 171.23,27.25 170.62,27.86 168.64,27.86 167.8,28.69 163.47,28.69 163.26,28.9 161.95,28.9 161.62,29.23 160.64,29.23 158.57,31.3 156.06,31.3 155.9,31.46 147.01,31.46 146.32,32.15 145.53,32.15 145.38,32.3 144.37,32.3 141.27,35.4 134.61,35.4 134.38,35.17 133.77,35.17 133.32,35.61 127.54,35.61 126.17,34.24 124.09,34.24 123.79,33.94 119.46,33.94 117.14,31.62 111.26,31.62 109.35,33.53 106.83,33.53 106.34,34.02 104.64,34.02 104.04,34.62 104.04,35.23 103.43,35.84 102.36,35.84 100.72,37.48 99.06,37.48 98.9,37.33 98.53,37.33 98.31,37.55 97.88,37.55 97.62,37.81 96.78,37.81 96.23,38.36 95.64,38.36 95.23,37.95 94.51,37.95 94.21,37.64 93.34,37.64 93.2,37.78 v2(93.2,38.06)
  BOTTOM w0.079: v2(93.2,38.06) 93.2,38.05 92.76,37.6 U1.CK8
  BOTTOM w0.102: U18.3 208.81,20.32 v1(209.1,20.03) 208.72,19.65 v2(208.04,19.65)
USB_OC3#: length 4.6
  TOP w0.102: R25437.1 93.41,35.92 TP9025.1 92.97,37.5 92.97,37.63 92.54,38.06 v2(92.24,38.06)
  BOTTOM w0.079: v2(92.24,38.06) 92.24,38.04 92.24,38.03 92.24,37.92 92.08,37.75 U1.CK9
USBON#: length 227.1
  TOP w0.102: v2(196.94,20.3) 196.66,20.3 196.38,20.59 196.38,22.11 196.66,22.39 196.66,22.78 195.26,24.18 195.26,25.44 194.93,25.77 194.93,26.49 195.69,27.24 195.89,27.24 196.04,27.39 196.04,28.11 196.58,28.65 196.58,28.92 196.45,29.05 U37.99
  IN1 w0.089: v2(203.31,19.87) 203.13,20.05 202.12,20.05 201.77,20.4 201.77,20.88 201.07,21.58 199.46,21.58 198.82,20.95 197.32,20.95 196.94,20.57 v2(196.94,20.3)
  IN2 w0.089: v2(196.94,20.3) 196.93,20.3 196.91,20.3 196.69,20.08 196.69,19.64 196.28,19.24 195.29,19.24 194.44,20.09 193.92,20.09 193.78,19.94 191.58,19.94 191.22,20.3 187.57,20.3 187.35,20.53 186.57,20.53 186.34,20.3 181.79,20.3 181.59,20.5 180.94,20.5 180.66,20.78 180.44,20.78 179.92,21.31 177.03,21.31 176.85,21.49 176.54,21.49 176.32,21.27 176.32,20.84 175.72,20.24 167.48,20.24 167.25,20.47 165.25,20.47 165.09,20.31 163.66,20.31 163.38,20.03 155.18,20.03 155.06,20.15 137.18,20.15 136.65,20.67 135.13,20.67 134.58,20.13 132.75,20.13 131.89,19.26 131.03,19.26 130.12,20.18 127.06,20.18 125.54,21.7 121.04,21.7 119.99,20.66 114.21,20.66 113.35,19.8 112.94,19.8 111.35,18.21 105.26,18.21 104.42,17.38 102.49,17.38 102.42,17.31 98.01,17.31 97.83,17.49 94.06,17.49 89.02,22.53 83.75,22.53 78.9,17.68 72.27,17.68 71.42,16.83 63.44,16.83 61.58,18.68 59.38,18.68 57.59,20.47 52.67,20.47 52.09,21.05 48.93,21.05 46.71,23.27 42.99,23.27 39.7,26.56 39.7,27.29 39.38,27.6 36.03,27.6 34.26,29.37 31.49,29.37 29.34,31.52 28.25,31.52 26.67,33.1 26.55,33.1 25.07,34.58 24.33,35.32 24.33,37.97 24.68,38.32 24.68,40.93 24.56,41.05 24.56,43.38 24.85,43.67 24.85,44.21 v1(24.83,44.23)
  BOTTOM w0.102: U18.4 204.62,20.32 204.18,19.87 v2(203.31,19.87) ; U15.4 21.97,45.13 23.13,43.98 24.57,43.98 v1(24.83,44.23)
USBP1+: length 220.5
  TOP w0.102: v1(23.09,45.52) 22.74,45.18 21.39,45.18 21.12,45.46 R25512.1
  IN3 w0.089: v2(97.91,39.89) 98.1,40.08 98.1,40.73 100.44,43.07 100.44,44.39 102.48,46.43 102.48,49.08 103.01,49.6 103.01,50.18 104.05,51.22 104.05,53.49 104.66,54.1 104.66,56.35 103.94,57.07 103.94,57.29 103.58,57.64 103.58,60.31 106.92,63.65 106.92,66.95 107.53,67.56 107.53,74.86 105.62,76.76 105.62,78.46 105.12,78.97 105.12,81.74 103.03,83.82 103.03,84.37 103.47,84.8 103.47,88.58 102.87,89.17 99.62,89.17 96.73,92.06 96.73,92.97 94.73,94.97 94.73,96.18 93.69,97.22 93.08,97.22 92.04,98.26 92.04,99.5 89.32,102.22 86.45,102.22 86.04,102.63 84.97,102.63 83.54,104.05 79.23,104.05 76.36,106.92 74.21,106.92 73.2,105.9 72.32,105.9 72.15,105.73 70.21,105.73 68.99,106.95 68.33,106.95 66.63,108.65 64.12,108.65 63.31,109.46 60.55,109.46 59.91,108.83 54.44,108.83 53.33,107.71 49.73,107.71 49.29,107.28 45.65,107.28 45.47,107.45 43.74,107.45 41.39,105.1 41.39,103.99 40.76,103.36 39.58,103.36 39.28,103.06 38.01,103.06 37.62,102.67 29.24,102.67 28.54,101.96 28.54,101.4 28.17,101.04 26.03,101.04 24.19,99.2 24.19,97.34 23.86,97.01 23.05,97.01 22.16,96.13 22.16,92.98 22.84,92.3 22.84,90.58 21.68,89.42 21.68,88.28 20.25,86.85 20.25,84.06 20.64,83.68 20.64,81.04 19.54,79.95 19.54,77.44 21.12,75.87 21.12,74.89 21.87,74.14 21.87,73.86 23.26,72.46 23.86,72.46 24.62,71.7 24.62,68.35 24.27,68 24.27,63.71 21.65,61.1 21.65,59.63 22.41,58.86 22.41,53.56 22.69,53.28 22.69,50.3 22.41,50.02 22.41,47.08 22.67,46.82 22.67,45.3 22.83,45.14 23.01,45.14 23.09,45.22 v1(23.09,45.52)
  BOTTOM w0.079: v2(97.91,39.89) 98.03,39.89 98.14,40 98.14,40.18 98.04,40.27 97.73,40.27 97.59,40.13 97.33,40.13 97.22,40.16 97.21,40.16 97.06,40.22 96.88,40.16 96.7,40.13 96.66,40.14 96.55,40.17 96.39,40.24 95.82,40.3 95.74,40.37 95.74,40.65 95.67,40.73 95.49,40.73 95.42,40.66 U1.CE4
USBP1+_C: length 2.9
  TOP w0.102: U14.10 20.38,50.75 20.22,50.91 20.22,51.97 20.41,52.16 20.56,52.16 20.66,52.06 R25518.1
USBP1+_C_R: length 11.9
  TOP w0.102: R25514.2 v2(22.06,45.71) ; R25516.1 21.62,51.6 21.98,51.6 v2(22.03,51.55)
  IN1 w0.089: v2(22.03,51.55) 22.03,52.05 21.94,52.14 20.85,52.14 20.33,51.62 20.33,50.62 21.86,49.09 21.86,47.35 21.47,46.97 21.47,45.28 21.69,45.06 22.05,45.06 22.06,45.07 v2(22.06,45.71)
USBP1+_C_R_N: length 16.3
  TOP w0.102: R25518.2 21.12,51.75 21.43,52.06 22.89,52.06 v2(23.1,51.85) ; v2(21.52,55.33) 21.35,55.51 19.9,55.51 19.11,56.31 18.37,56.31 U16.7 18.21,56.31 17.46,56.31 15.49,54.33 14.7,54.33 14.6,54.23 CN2.3
  IN1 w0.089: v2(21.52,55.33) 21.8,55.61 21.91,55.61 22.16,55.36 22.16,53.55 22.52,53.2 22.52,52.26 22.69,52.08 22.87,52.08 v2(23.1,51.85)
USBP1+_U14: length 3.1
  TOP w0.102: R25512.2 20.66,45.1 20.58,45.01 20.34,45.01 20.24,45.11 20.24,46.32 20.38,46.46 U14.3
USBP1-: length 220.5
  TOP w0.102: R25513.1 21.12,44.86 21.22,44.96 22.98,44.96 23.09,44.86 v1(23.09,44.75)
  IN3 w0.089: v2(98.49,39.89) 98.3,40.08 98.3,40.64 100.65,42.99 100.65,44.31 102.69,46.35 102.69,48.99 103.21,49.52 103.21,50.09 104.25,51.13 104.25,53.4 104.86,54.01 104.86,56.43 104.14,57.16 104.14,57.37 103.78,57.73 103.78,60.22 107.12,63.56 107.12,66.86 107.73,67.47 107.73,74.94 105.83,76.85 105.83,78.55 105.32,79.06 105.32,81.82 103.24,83.91 103.24,84.29 103.67,84.72 103.67,88.67 102.96,89.37 99.71,89.37 96.94,92.15 96.94,93.05 94.93,95.06 94.93,96.26 93.77,97.42 93.16,97.42 92.24,98.34 92.24,99.59 89.4,102.42 86.53,102.42 86.13,102.83 85.05,102.83 83.63,104.25 79.31,104.25 76.44,107.12 74.13,107.12 73.11,106.11 72.24,106.11 72.06,105.93 70.29,105.93 69.07,107.15 68.41,107.15 66.71,108.85 64.21,108.85 63.39,109.66 60.46,109.66 59.83,109.03 54.36,109.03 53.25,107.92 49.64,107.92 49.2,107.48 45.73,107.48 45.55,107.66 43.66,107.66 41.18,105.18 41.18,104.08 40.68,103.57 39.5,103.57 39.2,103.26 37.93,103.26 37.53,102.87 29.16,102.87 28.33,102.05 28.33,101.48 28.09,101.24 25.94,101.24 23.99,99.28 23.99,97.43 23.78,97.22 22.96,97.22 21.96,96.21 21.96,92.9 22.64,92.22 22.64,90.67 21.47,89.5 21.47,88.36 20.05,86.94 20.05,83.98 20.43,83.59 20.43,81.12 19.34,80.03 19.34,77.36 20.92,75.78 20.92,74.8 21.66,74.06 21.66,73.77 23.17,72.26 23.78,72.26 24.42,71.62 24.42,68.44 24.06,68.08 24.06,63.8 21.45,61.18 21.45,59.54 22.21,58.78 22.21,53.48 22.49,53.2 22.49,50.41 22.21,50.13 22.21,46.98 22.46,46.72 22.46,45.16 22.7,44.93 22.91,44.93 23.09,44.76 v1(23.09,44.75)
  BOTTOM w0.079: U1.CE3 96.46,40.39 96.61,40.32 96.7,40.3 96.71,40.3 96.83,40.32 97.06,40.4 97.11,40.37 97.26,40.31 97.26,40.31 97.35,40.29 97.52,40.29 97.66,40.43 98.11,40.43 98.3,40.24 98.3,40.09 v2(98.49,39.89)
USBP1-_C: length 2.9
  TOP w0.102: R25517.1 20.66,52.6 20.44,52.37 20.32,52.37 20,52.06 20,50.91 19.88,50.79 U14.11
USBP1-_C_R: length 12
  TOP w0.102: R25515.1 21.91,52.69 v2(22.03,52.82) ; R25513.2 v2(22.06,44.44)
  IN1 w0.089: v2(22.06,44.44) 22.06,44.77 21.97,44.86 21.61,44.86 21.27,45.2 21.27,47.05 21.65,47.43 21.65,49.01 20.13,50.53 20.13,51.71 20.76,52.34 21.56,52.34 v2(22.03,52.82)
USBP1-_C_R_N: length 16.2
  TOP w0.102: v2(21.52,55.92) 21.34,55.73 20.29,55.73 20.19,55.83 U16.4 20.09,55.73 19.99,55.73 19.2,56.52 17.37,56.52 15.4,54.55 14.7,54.55 14.6,54.65 CN2.2 ; v2(23.1,52.49) 22.89,52.28 21.22,52.28 21.12,52.38 R25517.2
  IN1 w0.089: v2(21.52,55.92) 21.96,55.92 22.39,55.49 22.39,53.68 22.72,53.35 22.72,52.41 22.81,52.32 22.93,52.32 v2(23.1,52.49)
USBP1-_U14: length 3.1
  TOP w0.102: R25511.2 20.66,44.69 20.56,44.79 20.25,44.79 20.02,45.02 20.02,46.32 19.88,46.46 U14.2
USBP2+: length 134.7
  TOP w0.102: v1(23.38,34.59) 23.27,34.71 23.1,34.71 22.88,34.49 22.66,34.49 22.55,34.39 R425.2
  IN3 w0.089: v2(100.29,37.1) 100.09,36.89 100.09,36.77 99.99,36.66 99.99,35.6 99.27,34.89 96.46,34.89 95.82,34.24 95.82,33.75 94.98,32.91 94.98,30.86 94,29.88 93.14,29.88 92.86,29.6 91.68,29.6 90.26,28.18 87.47,28.18 85.79,26.5 85.79,26.13 83.65,23.99 82.74,23.99 77.47,18.72 76.44,18.72 75.93,18.22 70.36,18.22 69.61,17.46 62.77,17.46 62.03,18.2 56.55,18.2 56.27,17.92 54.27,17.92 53.1,16.75 48.6,16.75 47.81,15.96 47.81,15.1 46.9,14.18 46.58,14.18 42.18,9.79 41.01,9.79 37.03,5.82 27.11,5.82 25.52,7.4 22.98,7.4 20,10.38 20,12.08 20.66,12.74 20.66,14.61 20.2,15.07 20.2,17.69 19.29,18.6 19.29,23.82 19.62,24.15 19.62,31.39 22.28,34.05 23.53,34.05 23.79,34.3 23.79,34.67 23.68,34.78 23.57,34.78 v1(23.38,34.59)
  BOTTOM w0.079: U1.CE2 96.98,40.57 97.23,40.83 97.55,40.83 97.62,40.75 98.38,40.75 99.03,40.11 99.03,39.49 98.9,39.37 98.9,38.44 99.4,37.93 99.45,37.93 99.46,37.92
  BOTTOM w0.102: v2(100.29,37.1) 100.12,37.27 100.12,37.52 99.85,37.79 99.58,37.79 99.46,37.92
USBP2+_C: length 9.4
  TOP w0.102: R425.1 21.38,34.54 20.47,34.54 19.91,35.1 19.35,35.1 18.61,35.85 17.84,35.85 U17.7 17.72,35.85 17.43,35.85 15.92,34.33 14.7,34.33 14.6,34.23 CN3.3
USBP2-: length 134.6
  TOP w0.102: v1(23.38,35.39) 23.48,35.29 23.48,35.12 23.38,35.03 23.2,35.03 23.1,34.92 23.01,34.92 22.79,34.71 22.64,34.71 22.55,34.8 R426.2
  IN3 w0.089: v1(23.38,35.39) 23.28,35.29 23.28,35.15 23.38,35.05 23.39,35.05 23.46,34.99 23.76,34.99 23.99,34.76 23.99,34.22 23.62,33.84 22.36,33.84 19.82,31.3 19.82,24.07 19.49,23.74 19.49,18.69 20.41,17.77 20.41,15.15 20.86,14.69 20.86,12.66 20.2,12 20.2,10.47 23.07,7.61 25.6,7.61 27.19,6.02 36.95,6.02 40.92,9.99 42.1,9.99 46.49,14.39 46.82,14.39 47.61,15.18 47.61,16.05 48.52,16.95 53.01,16.95 54.18,18.12 56.19,18.12 56.47,18.4 62.11,18.4 62.85,17.66 69.52,17.66 70.28,18.42 75.85,18.42 76.35,18.93 77.39,18.93 82.65,24.19 83.57,24.19 85.59,26.21 85.59,26.58 87.39,28.38 90.17,28.38 91.6,29.81 92.77,29.81 93.05,30.09 93.91,30.09 94.78,30.95 94.78,32.99 95.62,33.83 95.62,34.33 96.38,35.09 99.19,35.09 99.78,35.68 99.78,36.75 99.88,36.85 99.88,36.98 99.77,37.1 v2(99.55,37.1)
  BOTTOM w0.079: U1.CE1 97.4,40.6 98.31,40.6 98.87,40.04 98.87,39.56 98.74,39.43 98.74,38.37 99.29,37.82 99.29,37.79 99.3,37.79 99.3,37.77 99.31,37.76
  BOTTOM w0.102: 99.31,37.76 99.49,37.58 99.76,37.58 99.9,37.43 99.9,37.21 99.78,37.1 v2(99.55,37.1)
USBP2-_C: length 9.3
  TOP w0.102: R426.1 21.36,34.76 20.56,34.76 19.93,35.38 U17.4 19.38,35.38 18.7,36.06 17.34,36.06 15.83,34.55 14.7,34.55 14.6,34.65 CN3.2
USBP3+_TPC: length 114.1
  TOP w0.102: v1(22.42,12.18) 22.16,11.92 22,11.92 21.49,11.4 20.07,11.4 19.9,11.57 18.12,11.57 17.82,11.26 16.34,11.26 16.03,11.58 12.1,11.58 R25292.2
  IN3 w0.089: v2(98.13,38.8) 97.95,38.62 97.95,38.44 97.31,37.8 97.31,37.23 97.09,37.01 97.09,36.44 95.25,34.6 94.26,34.6 93.91,34.25 93.91,33.77 94.37,33.31 94.37,31.78 94.13,31.53 92.47,31.53 92.26,31.33 90.98,31.33 90.61,30.97 90.61,29.4 90,28.79 87.24,28.79 84.92,26.48 84.92,26.12 83.55,24.75 82.56,24.75 81.85,24.04 81.07,24.04 79.05,22.02 79.05,21.9 77.46,20.31 76.97,20.31 76.59,19.93 76.17,19.93 75.06,18.81 70.07,18.81 69.33,18.07 63.26,18.07 62.5,18.83 56.34,18.83 56.03,18.52 53.92,18.52 52.77,17.36 48.35,17.36 47.2,16.22 47.2,15.65 46.81,15.25 46.44,15.25 46.26,15.07 46.26,14.72 41.93,10.39 40.76,10.39 37.9,7.53 35.45,7.53 34.82,6.89 26.9,6.89 25.69,8.11 24.01,8.11 23.06,9.05 22.33,9.05 21.4,9.99 21.4,11.7 21.72,12.03 22.26,12.03 v1(22.42,12.18)
  BOTTOM w0.079: U1.CG4 95.62,39.38 95.82,39.51 96.12,39.53 96.26,39.53 96.54,39.67 96.65,39.7 96.84,39.7 96.97,39.63 97.02,39.63 97.26,39.68 97.26,39.68 97.44,39.71 97.53,39.7 97.56,39.69 97.59,39.69 97.94,39.34 97.94,38.99 v2(98.13,38.8)
USBP3-_TPC: length 114.1
  TOP w0.102: v1(22.42,11.43) 22.42,11.59 22.3,11.71 22.09,11.71 21.58,11.19 19.98,11.19 19.81,11.35 18.21,11.35 17.91,11.05 16.25,11.05 15.94,11.37 11.95,11.37 11.88,11.3 R25293.2
  IN3 w0.089: v1(22.42,11.43) 22.42,11.64 22.24,11.82 21.8,11.82 21.6,11.62 21.6,10.07 22.41,9.26 23.15,9.26 24.1,8.31 25.78,8.31 26.99,7.1 34.73,7.1 35.37,7.73 37.82,7.73 40.68,10.59 41.84,10.59 46.05,14.8 46.05,15.15 46.36,15.45 46.72,15.45 47,15.73 47,16.3 48.27,17.57 52.69,17.57 53.84,18.72 55.94,18.72 56.26,19.04 62.58,19.04 63.34,18.27 69.24,18.27 69.99,19.02 74.97,19.02 76.08,20.13 76.5,20.13 76.89,20.51 77.37,20.51 78.84,21.98 78.84,22.11 80.98,24.24 81.77,24.24 82.48,24.95 83.47,24.95 84.72,26.21 84.72,26.56 87.15,28.99 89.92,28.99 90.41,29.48 90.41,31.05 90.89,31.53 92.18,31.53 92.38,31.74 94.04,31.74 94.17,31.86 94.17,33.23 93.71,33.68 93.71,34.33 94.18,34.8 95.17,34.8 96.89,36.52 96.89,37.1 97.11,37.32 97.11,37.88 97.75,38.53 97.75,38.75 97.7,38.8 v2(97.55,38.8)
  BOTTOM w0.079: U1.CG3 95.9,39.26 95.83,39.19 95.83,39.06 95.92,38.98 96.3,38.98 96.4,39.08 96.4,39.39 96.44,39.43 96.61,39.51 96.68,39.54 96.79,39.54 96.92,39.46 97.04,39.46 97.29,39.51 97.44,39.54 97.47,39.53 97.52,39.53 97.78,39.26 97.78,38.92 97.66,38.8 v2(97.55,38.8)
USBP4+_DB: length 173.2
  IN3 w0.089: v1(212.38,40.12) 212.63,40.37 213.19,40.37 213.8,39.75 213.8,25.01 213.32,24.53 213.32,20.41 215.4,18.32 215.4,17.05 214.29,15.94 214.29,13.55 212.79,12.05 209.27,12.05 207.87,10.65 206.06,10.65 205.24,9.84 184.88,9.84 183.97,10.75 183.97,11.24 183.61,11.6 183.61,11.71 181.75,13.58 180.82,13.58 180.62,13.77 118.76,13.77 117.41,15.12 113.43,15.12 112.56,15.99 110.18,15.99 104.86,21.3 104.86,25.44 103.54,26.76 103.54,27.86 103.12,28.28 103.12,28.76 101.46,30.42 101.46,34.97 101.19,35.24 101.19,37.08 100.44,37.83 99.25,37.83 98.72,38.37 98.72,39.13 98.36,39.48 97.72,39.48 97.47,39.74 97.47,40.44 97.57,40.54 97.57,40.94 v2(97.77,41.14)
  BOTTOM w0.079: U1.CD4 96.21,40.83 96.99,40.83 97.16,40.99 97.63,40.99 v2(97.77,41.14)
  BOTTOM w0.102: CN35.16 212.66,40.4 v1(212.38,40.12)
USBP4-_DB: length 173
  IN3 w0.089: v1(212.38,40.75) 212.56,40.58 213.27,40.58 214.01,39.84 214.01,24.93 213.52,24.45 213.52,20.49 215.61,18.41 215.61,16.97 214.49,15.85 214.49,13.47 212.87,11.85 209.35,11.85 207.96,10.45 206.14,10.45 205.33,9.64 184.8,9.64 183.77,10.67 183.77,11.15 183.41,11.52 183.41,11.63 181.66,13.37 180.73,13.37 180.54,13.57 118.68,13.57 117.33,14.92 113.34,14.92 112.48,15.78 110.09,15.78 104.66,21.22 104.66,25.35 103.34,26.67 103.34,27.77 102.92,28.2 102.92,28.67 101.26,30.33 101.26,34.89 100.99,35.15 100.99,37 100.36,37.63 99.16,37.63 98.51,38.28 98.51,39.04 98.28,39.28 97.64,39.28 97.27,39.65 97.27,40.52 97.37,40.63 97.37,41.11 97.24,41.24 v2(96.88,41.24)
  BOTTOM w0.079: U1.CD3 96.54,40.99 96.78,40.99 96.88,41.1 v2(96.88,41.24)
  BOTTOM w0.102: CN35.15 212.53,40.9 v1(212.38,40.75)
USBP5+_CAM: length 115.7
  IN1 w0.089: v1(47.63,101.43) 47.49,101.43 47.38,101.54 47.38,101.89 47.44,101.95 50.09,101.95 50.89,102.75 50.89,103.57 51.19,103.87 51.19,105.85 51.8,106.46 52.51,106.46 54.92,104.05 58.56,104.05 60.21,102.4 60.94,102.4 62.97,100.37 65.14,100.37 65.39,100.62 77.1,100.62 77.77,99.95 81.16,99.95 82.51,98.6 83.51,98.6 86.68,95.44 86.68,85.24 86.07,84.63 86.07,79.92 85.71,79.56 85.71,72.14 85.84,72.01 85.84,67.72 86.73,66.83 86.73,49.73 85.99,48.99 85.99,48.19 86.02,48.17 86.02,44.59 86.42,44.18 87.49,44.18 87.79,43.88 87.79,41.06 88.63,40.22 88.96,40.22 89.77,39.41 93.86,39.41 93.94,39.33 93.94,39.18 93.79,39.03 v2(93.71,39.03)
  BOTTOM w0.079: v2(93.71,39.03) 94.03,39.34 U1.CG6
  BOTTOM w0.102: v1(47.63,101.43) 47.54,101.43 47.41,101.56 47.41,102.3 46.66,103.05 46.66,103.17 46.71,103.23 R25289.2
USBP5+_CAM_C: length 3.5
  BOTTOM w0.102: R25289.1 46.8,104.39 46.8,105.52 47.21,105.93 47.21,106.39 47.35,106.53 CN29.8
USBP5-_CAM: length 115.9
  IN1 w0.089: v1(47,101.43) 47.18,101.61 47.18,101.98 47.36,102.15 50.01,102.15 50.68,102.83 50.68,103.65 50.99,103.96 50.99,105.94 51.72,106.67 52.59,106.67 55,104.25 58.64,104.25 60.29,102.6 61.02,102.6 63.05,100.57 65.05,100.57 65.31,100.82 77.18,100.82 77.85,100.16 81.25,100.16 82.6,98.8 83.6,98.8 86.88,95.52 86.88,85.15 86.27,84.54 86.27,79.84 85.91,79.48 85.91,72.22 86.04,72.1 86.04,67.8 86.93,66.92 86.93,49.64 86.19,48.91 86.19,44.66 86.5,44.36 87.56,44.36 87.97,43.95 87.97,41.13 88.71,40.4 89.04,40.4 89.85,39.58 93.94,39.58 94.12,39.4 94.12,39.17 v2(94.28,39)
  BOTTOM w0.079: U1.CG5 94.68,39.4 v2(94.28,39)
  BOTTOM w0.102: v1(47,101.43) 47.19,101.63 47.19,102.21 46.17,103.23 R25288.2
USBP5-_CAM_C: length 3.5
  BOTTOM w0.102: CN29.7 46.85,106.53 46.99,106.39 46.99,106.02 46.58,105.61 46.58,104.43 R25288.1
USBP6+_CR: length 171.1
  IN3 w0.089: v2(99.73,38.26) 99.58,38.42 99.34,38.42 99.12,38.64 99.12,39.31 99.39,39.58 100.25,39.58 100.52,39.31 100.52,38.6 101.79,37.33 101.79,35.53 102.07,35.25 102.07,30.8 103.24,29.63 104.65,29.63 105.27,29.01 105.27,27.6 105.47,27.4 105.47,21.55 110.25,16.78 112.89,16.78 113.9,15.76 117.64,15.76 119.03,14.37 180.87,14.37 181.04,14.2 181.97,14.2 184.2,11.96 184.2,11.85 184.57,11.49 184.57,11.02 185.15,10.44 204.63,10.44 205.48,11.29 207.48,11.29 208.88,12.69 211.01,12.69 211.9,13.58 213.12,13.58 213.37,13.82 213.37,14.9 213.07,15.2 213.07,18.04 212.76,18.34 212.76,19.33 212.66,19.43 212.66,24.89 213.09,25.32 213.09,38.64 212.96,38.77 v1(212.23,38.77)
  BOTTOM w0.079: v2(99.73,38.26) 99.52,38.47 99.33,38.47 99.09,38.71 99.09,39.24 99.19,39.35 99.19,40.25 97.93,41.52 97.59,41.52 97.52,41.44 97.21,41.44 96.96,41.7 U1.CC2
  BOTTOM w0.102: CN35.19 212.36,38.9 v1(212.23,38.77)
USBP6-_CR: length 171
  IN3 w0.089: v1(212.33,39.43) 212.47,39.57 212.65,39.57 212.74,39.48 212.74,39.05 212.81,38.98 213.04,38.98 213.29,38.72 213.29,25.23 212.86,24.8 212.86,19.52 212.96,19.42 212.96,18.43 213.27,18.12 213.27,15.28 213.57,14.98 213.57,13.74 213.21,13.37 211.98,13.37 211.09,12.48 208.96,12.48 207.56,11.09 205.57,11.09 204.72,10.24 185.06,10.24 184.36,10.93 184.36,11.4 184,11.77 184,11.88 181.88,13.99 180.96,13.99 180.79,14.17 118.95,14.17 117.55,15.56 113.82,15.56 112.8,16.57 110.16,16.57 105.27,21.47 105.27,27.32 105.07,27.52 105.07,28.93 104.57,29.43 103.15,29.43 101.87,30.72 101.87,35.17 101.59,35.44 101.59,37.25 100.32,38.52 100.32,39.23 100.16,39.38 99.48,39.38 99.33,39.23 99.33,38.72 99.43,38.62 99.6,38.62 99.73,38.75 v2(99.73,38.95)
  BOTTOM w0.079: U1.CC1 97.4,41.67 97.99,41.67 99.35,40.32 99.35,39.28 99.25,39.18 99.25,38.78 99.39,38.63 99.67,38.63 99.73,38.7 v2(99.73,38.95)
  BOTTOM w0.102: v1(212.33,39.43) 212.36,39.4 CN35.18
USBP7+_FP: length 78.5
  IN3 w0.089: v1(55.81,23.1) 55.56,22.85 55.56,22.57 55.35,22.36 54.83,22.36 54.62,22.15 54.62,21.86 54.71,21.78 56.37,21.78 56.48,21.89 56.48,22.82 56.68,23.03 57.21,23.03 57.42,22.82 57.42,21.91 57.55,21.78 57.84,21.78 57.95,21.89 57.95,22.82 58.16,23.03 58.68,23.03 58.89,22.82 58.89,21.87 58.98,21.78 59.33,21.78 59.42,21.87 59.42,23.27 59.81,23.66 60.68,23.66 60.93,23.41 60.93,22.8 60.36,22.24 60.36,21.87 60.45,21.78 60.87,21.78 61.04,21.95 61.46,21.95 61.63,21.78 62.11,21.78 62.19,21.86 62.19,22.15 62.44,22.4 62.89,22.4 63.1,22.19 63.1,21.93 63.17,21.87 63.52,21.87 63.61,21.97 63.61,22.18 63.83,22.4 64.68,22.4 64.88,22.2 64.88,21.86 64.97,21.78 65.51,21.78 65.64,21.91 65.64,22.37 65.88,22.61 66.95,22.61 67.02,22.68 67.02,23.44 67.24,23.66 67.63,23.66 68.24,23.06 68.24,22.8 67.88,22.44 67.88,22.22 67.98,22.12 68.99,22.12 69.33,22.45 69.93,22.45 70.27,22.12 73.71,22.12 74.47,22.88 74.48,22.88 75.12,23.52 75.76,23.52 75.96,23.72 75.96,24.36 76.22,24.62 76.48,24.62 76.64,24.78 76.64,25.04 76.87,25.27 77.76,25.27 77.93,25.43 77.93,25.77 78.45,26.29 78.45,26.42 77.93,26.94 77.93,27.59 78.17,27.83 79.25,27.83 79.44,27.65 79.44,26.77 79.53,26.67 79.68,26.67 79.87,26.86 79.87,27.22 80.22,27.58 80.58,27.58 80.77,27.77 80.77,27.94 81.25,28.42 81.7,28.42 81.78,28.5 81.78,29.28 81.63,29.44 81.63,29.91 82.2,30.49 82.98,30.49 83.36,30.11 83.47,30.11 83.85,30.49 84.35,30.49 84.69,30.83 84.69,30.99 84.46,31.23 84.46,31.57 85.13,32.25 85.55,32.25 85.84,31.95 85.84,31.69 85.92,31.61 86.23,31.61 86.61,31.99 86.9,31.99 87.01,32.1 87.01,32.72 87.26,32.97 87.78,32.97 87.88,33.08 87.88,33.44 87.61,33.72 87.61,34.31 87.93,34.63 89.75,34.63 90.84,35.72 91.38,35.72 92.15,36.49 92.15,36.9 92.31,37.07 92.73,37.07 92.98,37.31 92.98,37.47 92.62,37.82 92.62,38.76 92.4,38.98 v2(92.36,38.98)
  BOTTOM w0.079: U1.CG9 91.8,39.45 91.73,39.38 91.73,38.92 91.83,38.82 92.21,38.82 v2(92.36,38.98)
  BOTTOM w0.102: CN14.7 57.45,21.43 57.9,21.88 57.9,22.13 EC7.2 58.03,22.52 58.13,22.62 58.13,23.35 58.06,23.42 57.68,23.42 57.26,23 56.7,23 56.28,23.42 56.01,23.42 55.81,23.23 v1(55.81,23.1)
USBP7-_FP: length 78.6
  IN3 w0.089: v1(55.18,23.1) 55.36,22.92 55.36,22.65 55.27,22.56 54.74,22.56 54.42,22.24 54.42,21.78 54.62,21.58 56.45,21.58 56.68,21.81 56.68,22.74 56.77,22.83 57.12,22.83 57.21,22.74 57.21,21.83 57.47,21.58 57.92,21.58 58.15,21.81 58.15,22.74 58.24,22.83 58.6,22.83 58.69,22.74 58.69,21.78 58.89,21.58 59.42,21.58 59.63,21.78 59.63,23.19 59.89,23.45 60.6,23.45 60.72,23.33 60.72,22.88 60.16,22.32 60.16,21.78 60.37,21.58 60.95,21.58 61.13,21.75 61.37,21.75 61.55,21.58 62.19,21.58 62.39,21.78 62.39,22.07 62.53,22.2 62.8,22.2 62.9,22.1 62.9,21.85 63.08,21.66 63.6,21.66 63.82,21.88 63.82,22.1 63.92,22.2 64.59,22.2 64.68,22.11 64.68,21.78 64.88,21.58 65.59,21.58 65.85,21.83 65.85,22.29 65.97,22.41 67.04,22.41 67.22,22.59 67.22,23.35 67.33,23.46 67.54,23.46 68.03,22.97 68.03,22.88 67.68,22.52 67.68,22.13 67.9,21.91 69.08,21.91 69.42,22.25 69.85,22.25 70.19,21.91 73.79,21.91 74.56,22.67 74.56,22.67 75.2,23.32 75.84,23.32 76.16,23.63 76.16,24.27 76.31,24.42 76.57,24.42 76.84,24.7 76.84,24.96 76.95,25.06 77.84,25.06 78.13,25.35 78.13,25.68 78.65,26.2 78.65,26.5 78.13,27.02 78.13,27.51 78.25,27.63 79.17,27.63 79.23,27.56 79.23,26.68 79.45,26.47 79.76,26.47 80.07,26.78 80.07,27.14 80.31,27.37 80.67,27.37 80.98,27.68 80.98,27.85 81.34,28.22 81.78,28.22 81.98,28.41 81.98,29.37 81.83,29.52 81.83,29.83 82.29,30.29 82.89,30.29 83.27,29.91 83.55,29.91 83.93,30.29 84.44,30.29 84.9,30.75 84.9,31.08 84.66,31.31 84.66,31.49 85.22,32.04 85.47,32.04 85.64,31.87 85.64,31.6 85.84,31.41 86.32,31.41 86.7,31.79 86.98,31.79 87.21,32.02 87.21,32.64 87.34,32.77 87.86,32.77 88.09,32.99 88.09,33.53 87.81,33.8 87.81,34.22 88.02,34.43 89.83,34.43 90.93,35.52 91.47,35.52 92.35,36.41 92.35,36.82 92.4,36.87 92.81,36.87 93.18,37.23 93.18,37.55 92.82,37.91 92.82,38.87 v2(92.92,38.98)
  BOTTOM w0.079: v2(92.92,38.98) 92.92,39.25 U1.CG8
  BOTTOM w0.102: v1(55.18,23.1) 55.71,23.63 56.37,23.63 56.79,23.21 57.17,23.21 57.59,23.63 58.15,23.63 58.34,23.44 58.34,22.76 EC8.1 58.11,22.04 58.11,21.79 57.95,21.63 CN14.6
USBP8+_TS: length 117.9
  IN1 w0.089: v2(44.26,101.36) 44.26,101.28 44.36,101.18 44.56,101.18 44.65,101.26 44.65,101.82 44.73,101.9 44.73,102.48 45.32,103.06 46.59,103.06 47.18,103.65 47.18,104.21 47.76,104.8 48,104.8 50.17,106.98 50.41,106.98 51.24,107.81 53.15,107.81 54.16,106.79 57.72,106.79 58.16,106.35 58.16,105.74 58.25,105.65 60.13,105.65 61.58,104.2 62.76,104.2 63.39,103.57 65.9,103.57 67.27,102.2 72.89,102.2 73.18,102.48 74.74,102.48 75.25,101.97 78.39,101.97 78.51,102.09 82.52,102.09 85.63,98.98 85.63,97.61 87.49,95.76 87.49,84.87 86.88,84.26 86.88,79.56 86.63,79.3 86.63,72.54 86.65,72.51 86.65,68.44 87.67,67.42 87.67,57.25 88.12,56.79 88.12,49.19 88.78,48.53 88.78,48.03 87.9,47.15 87.9,45.11 88.56,44.46 88.56,41.5 88.93,41.13 89.22,41.13 89.7,40.65 90.39,40.65 91.16,41.43 91.77,41.43 91.91,41.57 91.91,41.69 91.84,41.76 v2(91.77,41.76)
  BOTTOM w0.079: v2(91.77,41.76) 91.61,41.76 91.5,41.87 91.5,42.15 91.57,42.22 U1.CB9
  BOTTOM w0.102: v2(44.26,101.36) 44.18,101.36 44.13,101.41 44.13,101.51 44.56,101.94 44.56,103.11 44.68,103.23 R25291.2
USBP8-_TS: length 117.9
  IN1 w0.089: v2(44.26,100.77) 44.46,100.98 44.65,100.98 44.85,101.18 44.85,101.73 44.94,101.82 44.94,102.39 45.4,102.86 46.67,102.86 47.38,103.57 47.38,104.13 47.85,104.6 48.08,104.6 50.26,106.77 50.5,106.77 51.33,107.61 53.06,107.61 54.08,106.59 57.64,106.59 57.96,106.26 57.96,105.65 58.17,105.45 60.05,105.45 61.5,104 62.67,104 63.31,103.36 65.81,103.36 67.19,101.99 72.97,101.99 73.26,102.28 74.66,102.28 75.17,101.76 78.47,101.76 78.59,101.88 82.44,101.88 85.43,98.89 85.43,97.53 87.29,95.67 87.29,84.96 86.68,84.35 86.68,79.64 86.42,79.39 86.42,72.45 86.45,72.43 86.45,68.35 87.46,67.34 87.46,57.16 87.92,56.7 87.92,49.1 88.58,48.44 88.58,48.12 87.7,47.24 87.7,45.06 88.38,44.39 88.38,41.43 88.88,40.93 89.13,40.93 89.61,40.45 90.44,40.45 91.24,41.25 91.84,41.25 92.36,41.77 v2(92.39,41.77)
  BOTTOM w0.079: v2(92.39,41.77) 92.42,41.79 92.42,41.91 U1.CB8
  BOTTOM w0.102: R25290.2 44.35,103.01 44.35,102.03 43.85,101.54 43.85,101.18 v2(44.26,100.77)
USBP8_TS+_C: length 3.7
  BOTTOM w0.102: CN29.5 45.85,106.58 45.72,106.45 45.72,105.53 44.75,104.56 44.75,104.41 R25291.1
USBP8_TS-_C: length 3.7
  BOTTOM w0.102: CN29.4 45.35,106.56 45.5,106.41 45.5,105.62 44.53,104.65 44.53,104.41 R25290.1
USBP10+_BT: length 122.3
  IN3 w0.089: v2(169.68,27.01) 169.58,27.11 169.46,27.11 169.22,26.87 154.94,26.87 153.9,27.91 146.64,27.91 145.7,28.85 141.9,28.85 141.11,28.05 139.38,28.05 139.25,27.93 138.93,27.93 136.76,25.75 135.06,25.75 135.03,25.72 127.08,25.72 126.98,25.82 123.74,25.82 123.3,25.37 119.17,25.37 118.6,24.81 114.33,24.81 113.8,24.29 113.8,23.02 113,22.21 110.72,22.21 110.09,22.84 110.09,24.15 110.58,24.63 110.58,27.82 108.98,29.42 108.98,30.75 109.49,31.26 109.49,32.83 108.4,33.91 107.78,33.91 106.72,34.98 106.72,36.5 105.8,37.42 105.8,37.82 105.47,38.15 105.47,40.48 106.28,41.29 106.28,42.11 106.53,42.35 106.87,42.35 v2(107.25,42.73)
  BOTTOM w0.079: 101.84,41.69 101.81,41.67 99.93,41.67 99.59,42 97.71,42 97.57,42.14 97.37,42.14 97.35,42.16 97.26,42.12 97.23,42.12 97.17,42.1 96.91,42.1 96.82,42.14 96.65,42.14 96.6,42.12 96.32,42.04 96.26,42.02 96.12,41.98 95.97,41.98 U1.CC4
  BOTTOM w0.102: CN17.3 182.25,30.63 182.13,30.51 181.94,30.51 181.85,30.59 181.85,30.95 182.43,31.53 182.43,33.31 182.14,33.6 174.57,33.6 170.31,29.34 170.31,28.24 169.95,27.89 169.95,27.43 169.68,27.16 v2(169.68,27.01) ; 101.84,41.69 102.05,41.69 102.55,41.18 104.3,41.18 105.71,42.59 107.11,42.59 v2(107.25,42.73)
USBP10-_BT: length 122.4
  IN3 w0.089: v2(107.25,42.15) 106.61,42.15 106.49,42.02 106.49,41.21 105.68,40.4 105.68,38.24 106.01,37.91 106.01,37.5 106.92,36.59 106.92,35.06 107.87,34.11 108.49,34.11 109.69,32.91 109.69,31.18 109.18,30.67 109.18,29.5 110.78,27.9 110.78,24.55 110.3,24.07 110.3,22.92 110.81,22.41 112.91,22.41 113.6,23.1 113.6,24.37 114.24,25.01 118.52,25.01 119.08,25.58 123.21,25.58 123.66,26.02 127.06,26.02 127.16,25.92 134.94,25.92 134.98,25.95 136.67,25.95 138.85,28.13 139.17,28.13 139.3,28.26 141.02,28.26 141.82,29.05 145.78,29.05 146.72,28.11 153.99,28.11 155.02,27.08 169.14,27.08 169.47,27.4 169.87,27.4 v2(170.27,27.01)
  BOTTOM w0.079: 101.8,41.48 101.77,41.51 99.86,41.51 99.53,41.85 97.65,41.85 97.51,41.99 97.37,41.99 97.31,41.96 97.28,41.96 97.19,41.93 96.87,41.93 96.78,41.98 96.68,41.98 96.67,41.97 96.61,41.95 96.46,41.88 96.38,41.8 96.38,41.49 96.27,41.39 95.87,41.39 95.72,41.54 95.72,41.62 95.8,41.7 U1.CC3
  BOTTOM w0.102: v2(170.27,27.01) 170.17,27.11 170.17,27.8 170.52,28.15 170.52,29.25 174.66,33.39 182.05,33.39 182.22,33.22 182.22,31.62 181.63,31.04 181.63,30.5 181.85,30.29 182.13,30.29 182.29,30.13 CN17.5 ; 101.8,41.48 101.96,41.48 102.47,40.97 104.39,40.97 105.8,42.38 107.02,42.38 v2(107.25,42.15)
USBP_TYPC+_C: length 19.4
  TOP w0.102: v1(10.3,11.68) 10.3,11.6 10.51,11.38 10.89,11.38 11.1,11.59 R25292.1
  IN1 w0.089: CN10.B6 6.39,16.04 6.96,16.04 8.14,17.22 8.14,17.7 8.54,18.1 9.34,18.1 10.55,16.89 10.55,15.91 10.12,15.48 9.58,15.48 9.39,15.67 9.18,15.67 v1(9,15.5) 8.79,15.71 8.57,15.71 8.44,15.58 8.44,14.01 9.66,12.79 9.66,11.54 9.79,11.42 10.03,11.42 v1(10.3,11.68)
  BOTTOM w0.102: CN10.A6 7.55,15.65 7.68,15.78 7.96,15.78 8.04,15.71 8.79,15.71 v1(9,15.5) ; RV1.1 10.81,11.51 10.69,11.4 10.55,11.4 10.3,11.65 v1(10.3,11.68)
USBP_TYPC-_C: length 19.4
  TOP w0.102: v1(10.3,10.9) 10.56,11.16 10.91,11.16 11.1,10.97 R25293.1
  IN1 w0.089: CN10.B7 6.46,15.84 7.05,15.84 8.34,17.13 8.34,17.61 8.62,17.89 9.26,17.89 10.35,16.8 10.35,15.99 10.04,15.68 9.66,15.68 9.47,15.88 9.26,15.88 v1(9,16.13) 8.78,15.91 8.49,15.91 8.24,15.67 8.24,13.92 9.46,12.7 9.46,11.46 9.71,11.21 9.98,11.21 v1(10.3,10.9)
  BOTTOM w0.102: v1(10.3,10.9) 10.3,10.93 10.55,11.18 10.69,11.18 10.81,11.06 RV1.2 ; CN10.A7 7.55,16.15 7.69,16 8.05,16 8.13,15.92 8.79,15.92 v1(9,16.13)
USBPWRD2:
  vias: v1(212.79,25.08)
VA: length 165
  TOP w0.254: v1(130.62,33.97) 130.67,34.02 130.62,34.07 130.64,34.1 ; v2(134.73,34.99) 134.58,35.14 133.13,35.14 132.9,34.91 130.33,34.91 PR235.1
  TOP w0.508: 42.12,122.12 PC1.1
  IN2 w0.508: 43.11,121.02 43.24,120.89 48.7,120.89 50.42,122.6 59.05,122.6 60.33,123.88 61.45,123.88 61.46,123.89 64.12,123.89 65.01,124.78 70.88,124.78 71.61,124.04 71.61,120.66 75.6,116.67 75.6,114.11 76.82,112.89 80.33,112.89 81.98,111.24 81.98,110.22 83.88,108.32 87.95,108.32 88.62,107.64 89.43,107.64 90.36,108.57 91.25,108.57 92.01,107.81 92.01,104.96 95.03,101.94 95.72,101.94 96.31,101.35 96.31,100.21 95.64,99.55 95.64,97.8 95.11,97.27 95.11,93.99 95.52,93.58 95.52,92.19 96.25,91.45 98.31,91.45 98.41,91.55 101.03,91.55 102.51,90.07 102.51,90 105.77,86.74 106.22,86.74 108.24,84.72 110.86,84.72 112.09,83.49 112.09,83.22 116.65,78.66 116.65,76.92 120.71,72.86 120.71,70.34 121.42,69.63 123.92,69.63 128.43,65.12 128.43,49.57 129.3,48.7 129.3,44.03 128.66,43.38
  IN2 w1.016: v2(125.23,41.13) 125.23,41.02 126.09,40.17 128.13,40.17 128.66,40.7 128.66,43.38
  BOTTOM w0.102: v2(134.73,34.99) 134.73,34.94 135.31,34.36 PR31.1
  vias: v1(19.62,116.57) v1(19.62,115.94) v1(20.38,116.57) v1(20.38,115.94) v1(21.14,116.57) v1(21.14,115.94) v1(21.91,116.57) v1(21.91,115.94) v1(35.85,116.39) v1(39.41,122.29) v1(40.04,122.29) v1(40.68,122.29) v1(41.21,116.78) v1(41.31,122.29) v1(41.69,118.55) v1(41.84,116.78) v1(41.95,122.29) v1(129.98,33.95) v2(124.65,41.13)
VA2: length 163.8
  TOP w0.508: 44.14,119.95 PQ9054.1 45.03,120.76 45.98,120.76 46.48,121.27 PC2.1
  IN2 w0.406: v1(43.47,119.49) 45.2,119.49 46.47,118.22 55.03,118.22 57.12,120.32 60.45,120.32 61.48,119.29 61.48,117.61 61.38,117.51 61.38,116.93 61.78,116.53 62.29,116.53 68.46,110.36 68.46,107.34 71.06,104.74 72.64,104.74 73.09,105.19 75.34,105.19 76.07,104.47 77.1,104.47 77.67,103.9 81.35,103.9 83.61,101.64 88.9,101.64 90.49,100.05 90.49,98.79 91.83,97.45 91.83,92.32 96.69,87.46 97.14,87.46 97.75,86.85 97.75,85.84 98.07,85.52 102.25,85.52 102.92,84.85 105.28,84.85 107.02,83.11 109.55,83.11 114.99,77.67 114.99,74.31 116.14,73.15 116.14,70.47 116.77,69.84 117.92,69.84 118.43,69.33 118.43,66.33 120.08,64.68 123.8,64.68 127.62,60.86 127.62,49.24 128.23,48.63 128.23,46.49 124.01,42.28 v2(124.01,41.13)
  IN3 w0.406: v2(124.01,41.13) 124.01,40.88 124.88,40.02 124.88,39.61 126.66,37.83 126.66,36.71 129.27,34.1 v2(129.27,33.9)
  BOTTOM w0.102: v1(43.47,119.49) 43.29,119.49 43.14,119.65 43.14,119.75 43.03,119.85 43.03,120 v1(43.04,120)
  BOTTOM w0.406: PR28.1 133.37,34.56 129.68,34.56 129.27,34.15 v2(129.27,33.9)
VADJ1: length 4.8
  TOP w0.102: v1(56.78,108.32) 56.66,108.19 56.66,107.35 C558.1 R442.1 R441.2
  BOTTOM w0.102: CN29.27 56.85,107.92 56.83,107.94 56.83,108.27 v1(56.78,108.32)
VCORE_SENSE: length 37.4
  TOP w0.102: PR7043.1 118.43,53.76 118.41,53.74 PR7044.1 118.41,52.11 117.71,51.42 115.12,51.42 115.12,51.42 114.49,51.42 v1(114.36,51.55)
  IN1 w0.089: v1(114.36,51.55) 114.36,52.79 114.91,53.33 114.91,58.15 113.85,59.21 111.23,59.21 107.91,62.52 103.69,62.52 v2(103.6,62.61)
  BOTTOM w0.102: v2(103.6,62.61) 103.53,62.54 103.01,62.54 101.62,61.15 99.83,61.15 98.87,60.18 98.01,60.18 97.82,60.38 95.9,60.38 95.88,60.36 95.6,60.36 95.56,60.4 95.15,60.4 94.88,60.14 94.39,60.14 U1.AN6
VCORESS_SENSE: length 36.6
  TOP w0.102: PR7045.1 PR7046.1 118.33,50.83 118.07,51.09 114.54,51.09 v1(114.36,50.91)
  IN1 w0.089: v2(103.45,62.04) 103.75,62.04 103.94,62.23 107.79,62.23 111.11,58.91 113.73,58.91 114.62,58.03 114.62,53.45 113.88,52.72 113.88,51.01 113.98,50.91 v1(114.36,50.91)
  BOTTOM w0.102: U1.AN5 97.61,59.77 97.77,59.93 98.88,59.93 99.9,60.95 101.71,60.95 103.09,62.33 103.31,62.33 103.45,62.19 v2(103.45,62.04)
VGA_OVT#: length 46.9
  TOP w0.102: v1(99.55,123) 98.84,123 98.4,123.44 Q15.1 97.67,123.04 96.35,121.73 96.35,121.12 95.26,120.02 95.26,116.06 94.3,115.1 v1(94.3,114.29)
  IN2 w0.089: v2(94.55,106.49) 96.71,104.33 96.71,95.85 97.47,95.08 97.47,94.35 98.03,93.79 98.03,92.49 v2(97.59,92.05)
  IN3 w0.089: v2(94.55,106.49) 94.85,106.79 94.85,113.04 94.3,113.6 v1(94.3,114.29)
  BOTTOM w0.102: R395.1 91.04,89.41 91.04,90.01 92.42,91.38 95.33,91.38 95.92,91.98 97.51,91.98 v2(97.59,92.05) 97.77,92.05 98.43,92.71 U8.A6
VGA_RST#: length 20
  IN3 w0.089: v2(97.5,120.59) 97.52,120.59 97.55,120.56 97.55,120.43 98.23,119.75 98.23,117.84 98,117.61 98,112.46 v2(98.83,111.63)
  BOTTOM w0.102: v2(97.5,120.59) 97.19,120.89 97.19,122.21 97.7,122.72 97.7,123.76 97.5,123.96 97.5,124.65 v1(98.28,125.44) 98.69,125.84 100.14,125.84 100.65,125.34 C364.1 R296.2
  BOTTOM w0.127: U8.AC7 v2(98.83,111.63)
VGA_VCCSENSE: length 34.3
  TOP w0.102: PR9028.2 69.88,108.67 69.83,108.61 PR9026.2 69.48,108.22 v1(69.23,108.47)
  IN2 w0.089: v2(92.69,101.13) 92.69,101.1 92.66,101.08 91.37,101.08 88.07,104.38 88.07,104.84 86.52,106.39 83.45,106.39 83.04,105.98 77.66,105.98 76.8,106.84 72.23,106.84 71.79,107.28 70.04,107.28 69.53,107.78 69.53,108.16 v1(69.23,108.47)
  BOTTOM w0.102: U8.F2 94.71,97.55 94.17,97.55 92.77,98.94 92.77,100.99 92.69,101.08 v2(92.69,101.13)
