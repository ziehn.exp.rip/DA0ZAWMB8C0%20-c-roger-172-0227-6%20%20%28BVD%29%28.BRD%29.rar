# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SUSACK#: length 14.5
  TOP w0.102: R32.2 65.04,40.63 65.35,40.94 65.61,40.94 67.47,42.81 75.3,42.81 75.4,42.91 TP9018.1 75.8,42.86 77.29,42.86 v2(77.35,42.81)
  BOTTOM w0.089: U1.BY32 77.64,43.33 77.38,43.06 77.38,42.86 77.38,42.86 77.38,42.86 77.35,42.83 v2(77.35,42.81)
SUSB#: length 160.5
  TOP w0.102: U37.119 188.45,29.09 188.26,28.91 188.21,28.91 187.28,27.98 v2(187.28,27.73)
  IN2 w0.089: v2(64.12,30.56) 63.97,30.56 63.61,30.92 63.61,31.36 63.84,31.58 64.6,31.58 64.96,31.23 66.28,31.23 67.58,32.54 68.56,32.54 68.75,32.35 70.09,32.35 70.29,32.55 72.83,32.55 73.08,32.29 78.25,32.29 78.89,31.65 80.89,31.65 81.11,31.86 84.03,31.86 84.15,31.98 86.79,31.98 87.69,32.88 88.07,32.88 88.68,32.27 92.88,32.27 93.6,31.55 94.23,31.55 94.7,31.08 97.62,31.08 97.8,30.89 101.84,30.89 102.4,30.33 103.09,30.33 103.69,30.94 106.02,30.94 106.28,30.67 109.21,30.67 109.85,31.31 117.98,31.31 118.17,31.5 122.82,31.5 124.74,33.42 126.91,33.42 128.53,35.04 132.98,35.04 133.73,34.29 136.58,34.29 136.77,34.1 140.9,34.1 141.04,33.96 143.27,33.96 143.84,33.39 144.51,33.39 145.14,32.77 146.41,32.77 147.23,31.95 156.1,31.95 156.63,31.42 161.21,31.42 161.75,30.89 164.01,30.89 164.6,30.29 173.31,30.29 174.06,29.55 177.37,29.55 177.56,29.74 179.39,29.74 180.87,28.26 183.17,28.26 183.96,29.05 184.71,29.05 186.07,27.7 187.24,27.7 v2(187.28,27.73)
  BOTTOM w0.079: 70.46,42.15 70.69,42.38 70.88,42.38 73.75,45.25 74.51,45.25 74.61,45.35 75.11,45.35 U1.BU36
  BOTTOM w0.102: 70.46,42.15 68.68,40.37 C5.1 63.64,40.37 v1(63.53,40.25) 63.39,40.12 63.39,31.19 64.02,30.56 v2(64.12,30.56)
SUSC#: length 128.3
  TOP w0.079: v2(80.62,44.73) 80.6,44.73 80.31,45.01 80.31,45.72 80.53,45.93 80.84,45.93 81.02,46.12 81.37,46.12 81.6,46.34 C6.1
  TOP w0.102: v2(162.62,28.05) 162.62,25.49 163.61,24.5 163.61,22.97 164.15,22.44 164.15,21.63 164.02,21.5 v2(164.02,21.49) ; v2(181.98,21.45) 182.05,21.38 U37.18
  IN1 w0.089: v2(80.62,44.73) 81.81,44.73 82.66,43.88 82.66,41.95 83.07,41.54 83.07,41.19 84.27,39.99 84.27,38.69 84.49,38.47 84.9,38.47 85.26,38.83 86.04,38.83 86.75,38.12 86.75,37.25 87.48,36.52 88.05,36.52 88.48,36.09 91.5,36.09 92.36,36.94 95.21,36.94 95.42,36.73 96.16,36.73 97.55,35.34 98.91,35.34 101.01,33.24 103.64,33.24 104.39,32.49 105.31,32.49 105.73,32.07 109.48,32.07 110.87,30.68 117.96,30.68 118.51,31.23 122.98,31.23 125.05,33.3 126.65,33.3 128,34.64 132.92,34.64 133.44,34.12 136.5,34.12 136.7,33.91 140.58,33.91 143.14,31.36 144.99,31.36 145.14,31.21 145.93,31.21 146.62,30.52 155.51,30.52 155.67,30.36 158.18,30.36 160.25,28.29 161.23,28.29 161.56,27.96 162.53,27.96 v2(162.62,28.05)
  IN2 w0.089: v2(181.98,21.45) 181.98,21.91 181.7,22.19 178.13,22.19 178.04,22.09 177.35,22.09 177.19,22.26 176.45,22.26 175.89,22.81 174.89,22.81 174.16,22.08 174.16,21.41 173.78,21.03 167.79,21.03 167.4,21.42 166.58,21.42 166.08,21.93 165.77,21.93 165.32,21.47 164.03,21.47 v2(164.02,21.49)
  BOTTOM w0.089: v2(80.62,44.73) 80.62,44.76 80.99,45.13 U1.BU27
SUSCLK_32K: length 137.2
  IN1 w0.089: v2(194.7,22.03) 194.33,22.4 194.33,23.7 193.4,24.63 193.4,24.98 192.76,25.63 190.19,25.63 189.28,26.54 188.14,26.54 187.99,26.4 186.94,26.4 186.65,26.68 186.65,26.84 186.28,27.21 185.89,27.21 185.26,26.58 183.97,26.58 183.47,27.08 180.24,27.08 179.81,26.64 177.59,26.64 177.46,26.78 171.03,26.78 170.42,27.39 168.3,27.39 167.46,28.22 163.27,28.22 163.07,28.43 161.75,28.43 161.42,28.76 160.45,28.76 158.37,30.83 155.87,30.83 155.71,30.99 146.82,30.99 146.13,31.68 145.34,31.68 145.19,31.83 144.18,31.83 141.63,34.38 136.9,34.38 136.7,34.59 133.66,34.59 133.11,35.14 127.83,35.14 126.46,33.77 124.29,33.77 123.99,33.47 119.66,33.47 117.33,31.15 111.06,31.15 109.23,32.98 106.49,32.98 106.21,33.26 104.28,33.26 103.39,34.15 102.78,34.15 102.21,34.72 102.21,35.33 101.51,36.03 99.02,36.03 98.3,36.75 97.29,36.75 96.84,37.2 95.64,37.2 95.41,37.43 92.59,37.43 91.43,36.26 88.56,36.26 88.12,36.7 87.56,36.7 86.93,37.32 86.93,38.19 86.11,39.01 85.5,39.01 85.1,39.41 85.1,39.74 84.34,40.5 84.01,40.5 83.25,41.26 83.25,41.61 82.84,42.02 82.84,44.66 82.38,45.12 81.29,45.12 81.29,45.13 79.76,45.13 79.66,45.23 78.41,45.23 78.06,45.58 v2(78.06,45.64)
  BOTTOM w0.079: U1.BT32 77.74,45.99
  BOTTOM w0.089: v2(78.06,45.64) 78.06,45.67 77.74,45.99
  BOTTOM w0.102: v2(194.7,22.03) 194.63,21.97 194.47,21.97 R670.2
SUSCLK_32KHZ: length 3.9
  BOTTOM w0.102: R670.1 191.73,20.01 191.73,19.13 191.47,18.88 CN17.50
SUSD: length 16.9
  TOP w0.254: PQ11.2 113.5,41.28 v2(113.52,41.25) ; PQ25.3 117.43,35.42 v2(117.56,35.29) v1(117.99,34.86) 118.23,34.62 PR191.2 118.03,33.64 PC152.1
  IN2 w0.254: v2(117.56,35.29) 118.03,35.29 119.93,37.19 119.93,37.38 119.32,37.99 119.32,38.51 118.17,39.65 117.66,39.65 117.17,40.14 115.44,40.14 114.7,40.88 114.36,40.88 113.99,41.25 v2(113.52,41.25)
SUSLED#: length 53.8
  TOP w0.102: v2(191.93,21.68) 191.46,21.68 191.18,21.4 arc(191.18,21.4) 191.18,21.4 189.08,21.4 arc(189.08,21.4) 189.08,21.4 186.64,18.96 arc(186.64,18.96) 186.64,18.96 185.15,18.96 184.14,17.94 arc(184.14,17.94) 184.14,17.94 184.14,17.59 arc(184.14,17.59) 184.14,17.59 183.93,17.38 arc(183.93,17.38) 183.93,17.38 U37.28 ; v1(216.98,31.23) 216.98,30.85 217.21,30.62 217.21,26.53 216.83,26.15 215.61,26.15 215.1,25.64 214.74,25.64 212.51,23.4 208.57,23.4 206.94,25.03 v2(206.36,25.03)
  IN2 w0.089: v2(191.93,21.68) 191.93,21.25 192.11,21.07 192.7,21.07 193.32,21.69 193.78,21.69 193.82,21.65 194.85,21.65 195.06,21.86 196.13,21.86 196.87,22.6 199.58,22.6 199.65,22.67 201,22.67 202.95,24.62 205.95,24.62 v2(206.36,25.03)
  BOTTOM w0.102: CN35.21 214.47,37.9 216.57,35.8 arc(216.57,35.8) 216.57,35.8 216.57,31.35 arc(216.61,31.26) 216.69,31.23 v1(216.98,31.23)
SUSON: length 382.4
  TOP w0.102: v2(49.52,18.64) 50.04,19.17 50.04,20.02 50.31,20.28 50.31,21.62 51.55,22.86 51.55,22.92 v2(52,23.38) ; PR9251.1 30.76,26.5 v2(31.28,27.02) ; U37.120 188.05,29.07 187.03,28.05 185.58,28.05 184.95,28.67 184.45,28.67 183.92,29.21 183.92,29.64 183.83,29.73 183.83,30.34 183.63,30.54 182,30.54 181.9,30.44 R25320.1 181.32,30.44 179.84,31.91 179.84,32.27 179.16,32.96 v2(178.95,32.96)
  TOP w0.254: v1(65.44,125.56) 65.44,125.44 65.26,125.26 PR266.2
  IN1 w0.089: v1(61.66,110.07) 61.66,111.34 62.97,112.66 62.97,120.95 63.96,121.94 63.96,123.42 65.44,124.9 v1(65.44,125.56)
  IN2 w0.089: v2(31.28,27.02) 31.28,27.44 31.89,28.05 34.77,28.05 35.51,27.31 35.51,26.37 35.83,26.05 38.71,26.05 40.47,24.29 40.47,23.95 41.72,22.69 45.77,22.69 46.35,22.11 46.35,21.85 46.63,21.57 46.63,19.87 47.06,19.45 48.71,19.45 v2(49.52,18.64) ; v1(28.13,34.63) 28.55,35.06 28.55,36.72 26.87,38.41 26.87,46.21 26.76,46.31 26.76,49.14 26.26,49.64 26.26,74.17 25.93,74.5 25.93,81.33 26.8,82.21 26.8,84.19 25.77,85.22 25.77,87.47 27.75,89.45 27.75,91.77 30.33,94.35 30.33,95.56 32.12,97.35 43.93,97.35 45.14,98.56 48.92,98.56 49.92,99.55 49.92,101.08 51.05,102.21 51.05,103.05 51.31,103.3 52.04,103.3 53.88,105.14 54.6,105.14 55.08,105.62 55.08,106.72 55.54,107.17 56.83,107.17 57.69,108.04 57.69,109.84 58.06,110.21 58.79,110.21 59.48,109.52 61.11,109.52 v1(61.66,110.07) 62.01,110.07 62.37,109.71 63.78,109.71 65.84,107.65 65.84,106.56 70.42,101.98 74.29,101.98 75.07,101.2 78.07,101.2 82.87,96.4 82.87,94.27 84.61,92.53 84.61,89.43 85.15,88.89 85.15,85.97 85.38,85.74 86.23,85.74 86.57,86.08 86.57,88.01 87.01,88.44 92.05,88.44 94.37,86.12 94.37,84.65 96.73,82.29 100.23,82.29 100.63,81.89 100.63,79.5 100.11,78.99 100.11,77.32 99.34,76.55 99.34,75.22 97.9,73.77 97.83,73.77 97.6,73.55 97.6,71.86 97.78,71.69 98.72,71.69 99.02,71.39 99.02,71.08 99.27,70.83 100.06,70.83 102.55,68.34 103.14,68.34 104.95,66.52 109.81,66.52 110.23,66.11 111.85,66.11 114.42,63.54 114.42,55.12 114.11,54.81 114.11,52.38 114.76,51.73 114.76,50.2 115.01,49.95 115.01,48.2 112.99,46.18 112.99,44.66 v2(112.33,44) 113.33,44 114.92,42.41 117.27,42.41 117.71,41.97 117.95,41.97 118.83,41.09 118.83,40.46 120.36,38.94 120.36,38.42 121.97,36.81 123.7,36.81 124.7,35.81 125.92,35.81 128.16,38.05 135.68,38.05 136.46,38.82 139.09,38.82 139.86,39.6 143.55,39.6 146.54,36.61 146.54,36.04 147.17,35.41 147.46,35.41 147.55,35.32 148.15,35.32 148.74,34.73 155.95,34.73 156.82,35.6 159.03,35.6 159.69,34.94 162.52,34.94 163.33,34.12 163.34,34.12 163.95,33.51 164.77,33.51 165.32,32.96 166.91,32.96 167.2,33.24 173.92,33.24 174.01,33.33 178.66,33.33 178.95,33.03 v2(178.95,32.96)
  BOTTOM w0.102: v2(112.33,44) 111.87,43.55 110.93,43.55 110.68,43.8 PR9258.2 ; U3.3 60.73,26.97 60.27,26.51 C247.2 59.7,26.06 59.7,25.49 60.16,25.03 R215.2 59.59,24.79 59.37,25.01 55.14,25.01 54.31,24.17 52.31,24.17 52,23.86 v2(52,23.38) ; v2(31.28,27.02) 30.16,28.14 30.16,31.33 29.6,31.89 28.61,31.89 28.13,32.37 v1(28.13,34.63)
SUSPWRDNACK: length 21.9
  IN1 w0.089: v2(67.96,30.57) 67.63,30.9 67.63,33.41 68.44,34.23 68.67,34.23 69.53,35.08 69.53,36.18 69.86,36.51 69.86,37.42 70.54,38.09 70.54,39.6 v2(71.31,40.37)
  BOTTOM w0.079: U1.BV34 76.14,44.19 75.88,44.19 75.81,44.16 75.63,44.16 75.53,44.2 75.26,44.2 75.14,44.15 75,44.15 75,44.15 74.81,44.23 74.13,44.23 71.56,41.67 71.56,40.63 v2(71.31,40.37)
  BOTTOM w0.102: v2(67.96,30.57) 67.63,30.24 67.63,29.45 67.24,29.07 R31.2 R39.1
SYS_HWPG: length 171.7
  TOP w0.102: D60.1 169.39,32 v2(169.02,31.63) ; U37.124 186.45,30.62 186.17,30.9 v2(186.17,31.28) ; v2(143.19,34.73) 143.39,34.73 143.6,34.53 143.6,32.8 143.47,32.68 142.19,32.68 141.46,31.95 141.46,31.79 139.99,30.31 v2(139.99,29.09)
  IN2 w0.089: v2(96.89,14.78) 95.98,14.78 95.6,15.17 93.92,15.17 88.31,20.78 84.24,20.78 79.48,16.01 73.3,16.01 72.41,15.12 51.07,15.12 49.61,16.58 47.82,16.58 46.9,15.66 46.9,15.12 46.67,14.9 v1(46.67,14.85) ; v2(102.47,25.79) 102.88,26.2 106.36,26.2 107.92,27.77 110.87,27.77 111.64,28.54 118.76,28.54 119.03,28.8 124.13,28.8 124.6,29.28 128.74,29.28 129.2,29.74 130.53,29.74 130.79,29.48 132.19,29.48 132.32,29.35 138.52,29.35 138.77,29.09 v2(139.99,29.09)
  IN3 w0.089: v2(96.89,14.78) 96.97,14.86 96.97,19.17 100.14,22.34 101.66,22.34 102.68,23.35 102.68,25.26 102.47,25.46 v2(102.47,25.79) ; v2(186.17,31.28) 185.46,31.99 184.11,31.99 183.34,31.22 175.59,31.22 175.38,31.43 174.2,31.43 174,31.63 171.96,31.63 171.74,31.41 169.25,31.41 v2(169.02,31.63) 168.66,32 164.58,32 161.97,34.61 156.49,34.61 156.2,34.31 153.07,34.31 152.7,34.68 149.57,34.68 149.47,34.59 149.16,34.59 147.98,33.4 147.29,33.4 146.81,32.92 144.83,32.92 144.41,33.34 144.41,34.07 143.75,34.73 v2(143.19,34.73)
  BOTTOM w0.102: PR6004.2 143.04,34.58 v2(143.19,34.73) ; v1(46.67,14.85) 46.67,14.9 46.95,15.18 46.95,16.22 46.52,16.65 PR6022.2
SYS_PWROK: length 14.5
  BOTTOM w0.079: U1.CR10 91.7,34.63 91.7,33.64 91.84,33.5 91.84,32.93 92.77,31.99 92.87,31.99
  BOTTOM w0.102: 92.87,31.99 93.03,31.84 93.03,29.58 92.75,29.3 C7.1 92.59,29.18 92.16,28.75 92.16,27.93 92.23,27.86 92.23,26.67 TP5.1 92.81,26.05 92.81,24.52 R25362.1 R25359.1 91.24,24.48 91.1,24.33 U6504.4
SYS_RESET#: length 4.8
  BOTTOM w0.079: U1.CN10 91.67,35.71 91.49,35.53 91.49,34.54 91.53,34.49 91.53,33.57 91.67,33.43 91.67,32.79 92.47,31.99
  BOTTOM w0.102: 92.47,31.99 92.59,31.86 R43.1
SYS_SHDN#: length 206.8
  TOP w0.102: U37.85 198,23.78 197.83,23.61 197.6,23.61 197.27,23.94 197.27,24.47 197.34,24.55 v2(197.34,25.28) ; Q86.3 144.78,37.78 144.76,37.76 PR6009.1 144.76,33.78 144.26,33.29 PR6002.2 144.62,33.1 144.84,32.88 144.84,32.68 145.27,32.24 145.27,29.09 v1(144.64,28.46) 144.28,28.46 143.5,27.67 143.5,27.09 143.95,26.63 v2(143.95,26.2)
  IN2 w0.089: v2(197.34,25.28) 197.22,25.16 196.51,25.16 196.29,24.94 195.18,24.94 194.1,26.02 193.23,26.02 192.85,25.64 192.85,24.55 192.52,24.21 191.11,24.21 189.97,23.06 189.33,23.06 189.21,23.18 188.78,23.18 187.4,24.57 arc(187.4,24.57) 187.4,24.57 183.06,24.57 182.34,25.29 181.65,25.29 181.04,24.67 177.01,24.67 176.86,24.83 176.39,24.83 176.21,25.01 176.21,25.64 175.93,25.92 173.8,25.92 173.35,25.48 167.86,25.48 167.51,25.12 165.59,25.12 165.24,24.76 164.64,24.76 164.35,24.48 159.13,24.48 158.78,24.83 153.71,24.83 153.07,25.47 149.93,25.47 149.57,25.11 146.42,25.11 146.1,25.43 144.72,25.43 v2(143.95,26.2) 143.74,25.99 138.6,25.99 136.99,27.6 135.77,27.6 135.7,27.67 133.88,27.67 133.16,26.95 126.3,26.95 125.36,27.89 119.66,27.89 119.22,27.46 112.27,27.46 111.46,26.65 109.64,26.65 108.13,25.14 104.29,25.14 v2(104.2,25.06)
  IN3 w0.089: v1(48.11,10.83) 48.11,11.17 48.34,11.4 48.34,12.29 49.8,13.75 50.1,13.75 50.42,14.08 72.26,14.08 73.56,15.37 79.58,15.37 80.03,14.93 81.23,14.93 81.65,15.34 81.65,17.37 84.32,20.04 88.98,20.04 89.83,19.19 92.92,19.19 94.78,17.33 94.78,15.61 95.98,14.41 101.2,14.41 102.3,15.51 102.3,17.28 103.95,18.93 103.95,23.91 104.18,24.14 104.18,25.03 v2(104.2,25.06)
  BOTTOM w0.102: v1(48.11,10.83) 48.11,11.18 48.33,11.4 48.33,12.44 48.47,12.58 48.47,14.5 47.59,15.38 47.59,16.92 47.02,17.48 PR6020.2 ; PR3022.2 108.36,25.54 107.82,25.01 104.35,25.01 104.3,25.06 v2(104.2,25.06)
TEMP_MBAT#: length 115.5
  TOP w0.102: U37.73 198.13,18.98 197.84,18.7 197.41,18.7 197.22,18.89 197.22,19.41 196.98,19.64 196.56,19.64 195.92,20.28 195.92,21.62 195.39,22.15 195.39,22.25 194.75,22.88 194.75,23.06 193.47,24.35 193.47,25.08 192.77,25.78 189.63,25.78 189.32,25.46 v2(189.09,25.46) ; PR14.2 100.26,20.17 v2(100.24,20.15)
  TOP w0.178: PR18.1 137.11,28.54 PR8.1 136.74,28.23 v2(136.59,28.08)
  IN2 w0.089: v2(189.09,25.46) 187.22,25.46 186.74,24.98 185.67,24.98 185.09,25.56 182.63,25.56 182.51,25.68 180.57,25.68 180.15,25.26 177.44,25.26 176.81,25.89 176.51,25.89 176.1,26.31 173.63,26.31 173.19,25.87 168.47,25.87 168.4,25.94 166.73,25.94 166.31,25.51 165.43,25.51 165.3,25.38 164.17,25.38 163.92,25.13 160.15,25.13 160.06,25.23 153.88,25.23 153.23,25.87 149.77,25.87 149.41,25.51 146.58,25.51 146.27,25.82 145.47,25.82 144.72,26.57 144.34,26.57 144.13,26.78 143.21,26.78 142.82,26.38 138.79,26.38 137.12,28.05 136.64,28.05 136.61,28.08 v2(136.59,28.08) 136.21,28.46 135.85,28.46 135.45,28.06 133.23,28.06 132.59,27.42 128.78,27.42 127.38,28.83 125.06,28.83 124.52,28.29 119.49,28.29 119.06,27.85 111.97,27.85 111.16,27.04 109.47,27.04 107.97,25.54 103.64,25.54 v2(103.62,25.56)
  IN3 w0.089: v2(100.24,20.15) 100.24,20.66 101.15,21.58 101.53,21.58 103.25,23.29 103.25,24.05 103.72,24.52 103.72,25.46 v2(103.62,25.56)
TESTMODE: length 7
  BOTTOM w0.102: U8.AD9 101.29,112.41 101.94,112.41 102.17,112.64 102.17,115.3 102.95,116.08 R311.1
THERM+: length 1.4
  TOP w0.152: TP68.1 102.97,96.63 v2(102.97,96.64)
  BOTTOM w0.102: U8.F12 103.39,97.05 v2(102.97,96.64)
THERM-: length 9.3
  TOP w0.102: v2(103.82,95.01) 103.82,94.09 103.34,93.61 103.34,93.2 103.59,92.95 104.2,92.95 104.61,92.54 104.61,91.53 TP69.1
  BOTTOM w0.102: U8.E12 103.82,95.8 v2(103.82,95.01)
THERMTRIP#: length 64.3
  TOP w0.102: v2(142.71,42.02) 143.61,41.12 143.61,38.63 142.78,37.8 Q86.1 143.61,37.36 144.11,36.87 144.11,35.52 v1(143.75,35.17) 143.05,35.17 142.68,34.8 142.68,34.48 143.03,34.13 R822.1
  IN1 w0.089: v2(142.71,42.02) 142.68,42.05 142.68,45.07 142.4,45.35 141.13,45.35 140.65,45.83 135.15,45.83 133.84,44.52 131.56,44.52 130.54,43.5 127.59,43.5 126.88,44.21 120.92,44.21 119.83,43.12 119.83,42.46 119.37,41.99 114.85,41.99 114.18,42.66 114.18,43.28 111.11,46.34 110.04,46.34 109.54,46.85 109.54,47.61 109.15,47.99 109.15,48.35 108.89,48.61 108.02,48.61 106.02,50.61 105.6,50.61 104.74,51.47 v1(104.74,53.22)
  BOTTOM w0.102: R25479.1 102.65,52.92 102.8,52.77 103.39,52.77 103.59,52.97 103.87,52.97 104.13,53.22 v1(104.74,53.22)
THERMTRIP#_CPU: length 5.7
  BOTTOM w0.102: R25479.2 101.03,52.92 100.98,52.97 99.9,52.97 99.13,52.21 98.41,52.21 97.98,51.78 97.98,51.32 97.37,50.72 U1.BJ1
TP_I2C_CLK: length 40.6
  TOP w0.102: v2(77.13,19.93) 76.8,19.93 76.52,19.66 R565.1 76.52,18.94 76.11,18.53 75.47,18.53 R558.1 ; v2(91.31,33.28) 91.84,32.75 92.23,32.75 93.4,31.58 94.19,31.58 94.65,31.12 94.65,30.45 94.4,30.19 94.4,29.25 94.73,28.92 94.73,28.46 95.16,28.02 95.16,27.32 95.46,27.02 95.46,26.51 96.2,25.77 R25415.2 96.04,25.51 95.57,25.04 95.57,24.66 94.8,23.9 93.78,23.9 93.74,23.94 91.39,23.94 91.32,24.01 90.65,24.01 89.91,24.75 87.97,24.75 87.44,25.28 86.57,25.28 86.29,25.01 v2(86.29,24.85)
  BOTTOM w0.079: v2(91.31,33.28) 91.31,33.5 90.77,34.05 90.77,34.36 90.88,34.48 90.88,34.81 90.84,34.92 90.84,35.1 90.86,35.17 91.1,35.53 U1.CN11
  BOTTOM w0.102: v2(86.29,24.85) 85.58,24.14 85.58,23.15 84.42,21.98 v1(83.6,21.98) 83.48,21.98 81.7,20.2 80.17,20.2 79.41,19.44 77.74,19.44 77.25,19.93 v2(77.13,19.93)
TP_I2C_DATA: length 46
  TOP w0.102: R560.1 70.26,19.59 70.57,19.9 71.32,19.9 v2(71.52,20.1) 71.52,20.48 71.26,20.74 R563.1 ; v2(85.71,24.85) 85.71,25.06 86.29,25.63 87.67,25.63 88.2,25.11 90.05,25.11 90.8,24.36 91.47,24.36 91.54,24.29 93.89,24.29 93.93,24.25 94.66,24.25 95.18,24.78 95.18,25.13 95.03,25.29 R25413.2 95.03,26.07 95.1,26.14 95.1,26.87 94.8,27.17 94.8,27.88 94.37,28.31 94.37,28.77 94.04,29.1 94.04,30.34 94.3,30.59 94.3,30.97 94.04,31.23 93.25,31.23 92.11,32.37 91.6,32.37 90.79,33.18 v2(90.79,33.49)
  BOTTOM w0.079: U1.CM11 90.81,36.02 90.81,35.5 90.67,35.13 90.67,34.88 90.71,34.77 90.71,34.55 90.55,34.38 90.55,33.73 v2(90.79,33.49)
  BOTTOM w0.102: v2(85.71,24.85) 85.69,24.85 85.2,24.37 85.2,23.28 84.39,22.47 83.3,22.47 v1(82.31,21.47) 82.31,21.4 81.55,20.64 80.05,20.64 79.21,19.8 77.89,19.8 77.31,20.37 74.3,20.37 73.37,19.44 72.17,19.44 v2(71.52,20.1)
TP_INTH#_L: length 19
  TOP w0.102: R25471.2 76.01,21.58 75.83,21.4 R25472.1 75.36,21.64 v2(75.93,22.21)
  BOTTOM w0.102: Q29.1 80.71,22.35 80.71,22.11 80.3,21.7 77.07,21.7 77,21.78 77,22.47 76.73,22.73 76.3,22.73 76.03,22.47 76.03,22.31 v2(75.93,22.21) 75.73,22.21 75.04,22.9 75.04,23.23 74.79,23.48 74.05,23.48 73.85,23.28 71.61,23.28 71.4,23.06 v1(71.36,23.06) 70.79,23.06 70.62,22.9 70.62,22.29 70.32,21.98 CN33.7
TP_PWR_C: length 4.6
  BOTTOM w0.254: CN29.31 58.85,107.7 58.61,107.94 58.61,108.09 v1(58.38,108.32) 58.38,107.96 58.35,107.93 CN29.30
  BOTTOM w0.305: 58.61,106.29 v1(58.61,106.16) ; 58.61,106.29 58.35,106.54 CN29.30 ; 58.61,106.29 58.85,106.53 CN29.31
  vias: v1(59.04,105.14)
TP_SMB_CLK: length 10.3
  TOP w0.102: v2(71.05,22.52) 70.67,22.52 70.45,22.29 70.45,21.98 70.17,21.7 C699.1 69.61,21.7 69.45,21.55 R559.1 ; v2(71.23,17.79) 71.23,17.69 70.78,17.23 70.78,16.09 70.97,15.9 Q27.3
  BOTTOM w0.102: v2(71.05,22.52) 71.32,22.25 CN33.6 71.32,20.5 71.03,20.2 71.03,18.76 71.23,18.55 v2(71.23,17.79)
TP_SMB_DATA: length 6.1
  TOP w0.102: Q27.6 73.23,17.58 72.96,17.85 72.96,18.19 73.12,18.35 R562.1 73.12,18.86 73.33,19.08 C698.1 73.01,19.42 72.57,18.97 v1(72.29,18.97) 72.12,19.14 v2(72.12,20.15)
  BOTTOM w0.102: v2(72.12,20.15) 72.32,20.35 CN33.5
TPCLK: length 152.2
  TOP w0.102: v2(201.43,24.95) 201.43,24.98 200.98,25.44 200.57,25.44 200.24,25.11 199.89,25.11 199.62,25.38 U37.89 ; R566.2 67.68,21.6 v2(67.27,22.01) 67.19,22.08 67.19,22.31 66.99,22.52 L23.1
  IN2 w0.089: v2(67.27,22.01) 67.27,21.86 67.68,21.45 68.46,21.45 68.91,20.99 70.34,20.99 70.98,20.36 70.98,20.08 71.41,19.65 73.62,19.65 74.23,20.26 75.85,20.26 76.24,20.65 77.22,20.65 77.99,19.88 78.9,19.88 83.07,24.05 89.65,24.05 93.76,19.95 97.56,19.95 98.69,18.82 103.98,18.82 104.96,19.8 108.88,19.8 110.64,21.56 113.21,21.56 113.58,21.93 119.32,21.93 120.39,23 122.03,23 122.13,22.9 126.38,22.9 127.85,21.42 134.26,21.42 134.73,21.89 137.2,21.89 137.77,21.32 147.11,21.32 147.84,22.05 165.36,22.05 165.64,22.34 170.6,22.34 171.4,21.54 172.84,21.54 173.33,22.02 173.48,22.02 174.71,23.25 176.07,23.25 176.69,22.64 177.11,22.64 177.67,23.2 178.19,23.2 178.81,22.58 181.86,22.58 182.02,22.43 182.64,21.8 184.08,21.8 184.12,21.84 186.03,21.84 186.39,21.48 187.99,21.48 188.22,21.25 190.01,21.25 191.71,22.95 193.39,22.95 193.41,22.98 195.15,22.98 195.61,23.44 196.35,23.44 196.43,23.36 198.52,23.36 199.74,24.58 201.06,24.58 v2(201.43,24.95)
TPCLK-1: length 10.4
  TOP w0.102: L23.2 C696.1 69.12,23.49 69.48,23.13 71.66,23.13 v2(72.25,22.54)
  BOTTOM w0.102: CN33.2 75.32,22.24 v1(74.56,23) 72.53,23 72.25,22.72 v2(72.25,22.54)
TPD_EN: length 148.2
  TOP w0.102: v2(196.35,33.21) 196.25,33.11 R895.2
  IN2 w0.089: v2(200.19,26.08) 200.1,26.08 199.45,25.44 199.45,24.83 198.36,23.74 196.73,23.74 196.66,23.82 195.64,23.82 195.42,24.04 194.3,24.04 193.64,23.38 193.15,23.38 193.1,23.34 191.53,23.34 189.83,21.63 188.49,21.63 188.26,21.86 187.65,21.86 187.05,22.46 186.36,22.46 186.12,22.22 182.77,22.22 181.86,23.13 178.83,23.13 178.12,23.83 174.4,23.83 173.48,22.91 165.41,22.91 165.12,22.62 147.54,22.62 146.8,21.89 138.06,21.89 137.46,22.49 134.52,22.49 134.05,22.02 128.07,22.02 126.39,23.69 123.88,23.69 123.37,24.21 121.84,24.21 121.25,23.61 120.12,23.61 119.05,22.54 113.32,22.54 113.15,22.37 110.59,22.37 108.62,20.41 104.76,20.41 103.85,19.5 98.82,19.5 97.7,20.62 94.23,20.62 92.74,22.12 92.74,23.03 91.54,24.23 90.6,24.23 90.2,24.62 87.72,24.62 87.06,25.28 84.96,25.28 84.31,24.62 82.75,24.62 80.24,22.11 v2(79.67,22.11)
  IN3 w0.089: v2(196.35,33.21) 196.35,32.82 195.98,32.45 195.98,30.02 196.84,29.17 196.84,28.46 196.98,28.31 197.82,28.31 198.46,27.67 199.2,27.67 200.19,26.68 v2(200.19,26.08)
  BOTTOM w0.102: v2(79.67,22.11) 79.67,23.07 79.21,23.53 78.52,23.53 78.37,23.38 78.37,23.3 78.04,22.97 R574.1 78.03,23.77 v1(77.98,23.82) 77.86,23.94 76.96,23.94 R572.2
TPD_INT#: length 25.2
  TOP w0.102: v2(88.63,25.51) 88.03,26.12 86.09,26.12 85.26,25.28 84.96,25.28 84.17,24.5 82.64,24.5 79.84,21.7 79.28,21.7 79.12,21.86 R573.1
  BOTTOM w0.079: U1.CN14 89.15,35.91 88.88,35.64 88.86,35.62 88.79,35.47 88.79,35.22 88.84,35.09 88.84,34.93 88.82,34.87 88.8,34.78 88.8,33.82 88.72,33.74 88.72,32.79 89.11,32.4 89.72,32.4 90.13,31.99
  BOTTOM w0.102: v2(88.63,25.51) 88.73,25.51 89.7,26.48 89.7,27.42 89.92,27.64 R25477.1 90.1,28.21 v1(89.83,28.48) 89.83,28.82 90.18,29.17 90.18,31.23 90.23,31.28 90.23,31.89 90.13,31.99
TPD_INT#_EC: length 123.7
  TOP w0.102: R25473.1 78.17,20.56 v2(78.24,20.48) ; R25308.2 183.58,32.35 183.21,31.97 182.73,31.97 182.56,32.14 R25323.1 181.93,32.35 v2(181.75,32.17)
  IN2 w0.089: v2(78.24,20.48) 78.93,20.48 82.88,24.43 89.97,24.43 90.42,23.98 91.26,23.98 91.63,23.61 91.63,22.92 94.17,20.38 97.67,20.38 98.81,19.24 99.44,19.24 99.52,19.31 103.93,19.31 104.84,20.22 108.71,20.22 110.67,22.17 113.26,22.17 113.43,22.34 119.19,22.34 120.25,23.4 121.32,23.4 121.92,24 123.22,24 123.73,23.49 126.32,23.49 127.99,21.83 134.13,21.83 134.6,22.3 137.36,22.3 137.95,21.7 146.88,21.7 147.61,22.43 165.2,22.43 165.48,22.72 173.56,22.72 174.47,23.63 176.49,23.63 v2(176.9,23.23)
  BOTTOM w0.102: v2(181.75,32.17) 180.38,30.8 180.38,28.05 179.31,26.99 178.43,26.99 178.1,26.66 176.46,26.66 176.19,26.38 176.19,24.24 176.9,23.53 v2(176.9,23.23)
TPDAT-1: length 4.9
  TOP w0.102: L24.2 72.31,21.17 73.35,21.17 73.63,21.45 C697.1 73.63,22.2 73.47,22.36 v2(73.47,22.54)
  BOTTOM w0.102: CN33.3 74.32,21.66 73.47,22.52 v2(73.47,22.54)
TPDATA: length 144.4
  TOP w0.102: v2(72.72,20.2) 72.99,19.93 73.15,19.93 73.5,20.27 R567.2 73.5,20.56 73.25,20.81 L24.1 ; U37.90 199.79,25.78 v2(200.06,25.51)
  IN2 w0.089: v2(200.06,25.51) 200.06,25.17 198.44,23.55 196.51,23.55 196.43,23.63 195.46,23.63 195.02,23.19 193.23,23.19 193.18,23.14 191.61,23.14 189.91,21.44 188.3,21.44 188.07,21.67 186.58,21.67 186.22,22.03 182.69,22.03 182.05,22.66 181.79,22.92 178.75,22.92 178.27,23.4 177.6,23.4 177.03,22.83 176.77,22.83 176.15,23.44 174.58,23.44 173.35,22.22 173.1,22.22 172.67,21.79 171.42,21.79 170.68,22.53 165.56,22.53 165.28,22.24 147.69,22.24 146.96,21.51 137.88,21.51 137.28,22.11 134.68,22.11 134.19,21.63 127.92,21.63 126.26,23.28 123.67,23.28 123.15,23.81 122.03,23.81 121.42,23.2 120.32,23.2 119.25,22.13 113.49,22.13 113.34,21.98 110.76,21.98 108.79,20.01 104.9,20.01 103.99,19.1 99.57,19.1 99.52,19.05 98.73,19.05 97.6,20.18 93.8,20.18 89.73,24.24 82.99,24.24 78.82,20.07 78.07,20.07 77.3,20.84 76.16,20.84 75.78,20.46 74.15,20.46 73.53,19.84 73.08,19.84 v2(72.72,20.2)
TPM_LRESET#: length 2.2
  TOP w0.102: R601.2 122.87,23.74 v1(123.01,23.6) 123.09,23.52 U33.17
TPM_PIRQ#: length 12.7
  BOTTOM w0.079: U1.CF22 83.55,39.23 83.55,37.25 83.28,36.97 83.28,36.49 83.22,36.43 83.22,36.19 83.28,36.13 83.28,35.57 83.33,35.47 83.45,35.34 83.53,35.34 83.66,35.3 83.76,35.21 83.81,35.11 83.81,34.94 83.76,34.8 83.76,34.47 84.06,34.17 84.06,32 83.9,31.84 83.64,31.84 83.28,31.48
  BOTTOM w0.102: R102.1 82.96,28.84 83.2,29.07 83.2,31.39 83.28,31.48
TRA_V_DAC: length 18.1
  TOP w0.508: v1(29.65,101.56) 29.14,102.07 29.14,102.34 C645.1
  BOTTOM w0.508: 32.07,100.82 31.9,100.99 U25.7 ; 32.07,100.82 v1(31.2,100.82) 30.16,100.82 29.65,101.33 v1(29.65,101.56) 29.41,101.56 28.9,102.07 U25.10 ; 32.07,100.82 34.99,100.82 ; U25.1 37.9,101.33 37.39,100.82 34.99,100.82 ; 34.99,100.82 34.9,100.91 U25.4
TS_EN: length 242
  TOP w0.102: R956.1 203.03,23.33 v2(203.08,23.38) ; R436.2 56.84,105.41 57.19,105.75 v2(57.19,105.96)
  IN2 w0.089: v2(57.19,105.96) 57.19,107.15 57.89,107.85 57.89,109.76 58.14,110.02 58.71,110.02 59.4,109.33 59.87,109.33 60.69,108.51 60.69,108.17 60.91,107.95 63.06,107.95 63.47,108.36 64.45,108.36 64.99,107.83 64.99,107.14 70.34,101.79 72.67,101.79 73.45,101.01 77.98,101.01 82.61,96.38 82.61,93.22 84.42,91.41 84.42,89.36 84.95,88.83 84.95,85.79 85.2,85.53 86.3,85.53 86.78,86.01 86.78,87.94 87.09,88.25 91.97,88.25 94.18,86.04 94.18,84.57 96.65,82.1 100.12,82.1 100.44,81.78 100.44,79.58 99.92,79.06 99.92,77.4 98.44,75.92 97.73,75.92 97.41,75.6 97.41,71.01 97.79,70.64 99.98,70.64 100.84,69.77 100.84,68.86 102.61,67.09 102.61,66.66 102.94,66.33 109.73,66.33 110.15,65.92 111.77,65.92 114.23,63.46 114.23,55.2 113.92,54.89 113.92,50.78 114.82,49.87 114.82,48.28 112.8,46.26 112.8,45 111.96,44.16 111.96,43.68 112.01,43.63 113.43,43.63 114.84,42.22 117.19,42.22 118.03,41.38 118.03,40.75 118.27,40.5 118.52,40.5 120.17,38.86 120.17,38.34 121.89,36.62 123.62,36.62 124.63,35.62 125.99,35.62 128.21,37.83 135.73,37.83 136.53,38.63 139.17,38.63 139.94,39.41 143.32,39.41 145.61,37.11 145.61,36.35 145.84,36.11 146.2,36.11 147.09,35.22 147.38,35.22 147.47,35.13 148.07,35.13 148.66,34.54 156.03,34.54 156.86,35.37 158.67,35.37 159.44,34.61 162.58,34.61 163.26,33.93 163.87,33.32 164.69,33.32 165.26,32.75 167.41,32.75 167.68,33.03 173.73,33.03 174.2,32.55 175.75,32.55 176.34,31.96 180.48,31.96 180.84,31.6 182.13,31.6 183.09,32.56 184.92,32.56 185.35,32.13 186.58,32.13 186.96,31.76 186.96,31.28 187.28,30.95 188.08,30.95 188.2,30.83 192.04,30.83 192.72,30.15 196.29,30.15 199.68,26.76 201.08,26.76 201.38,26.45 201.38,26.12 201.54,25.96 201.54,25.41 201.79,25.16 202.09,25.16 202.35,25.42 202.35,26.13 203.35,27.12 206.48,27.12 206.93,26.67 206.93,26.47 207.17,26.22 207.17,25.74 206.77,25.34 206.77,24.91 205.59,23.73 203.43,23.73 v2(203.08,23.38)
TS_EN_C: length 4.9
  TOP w0.102: U37.81 199.62,22.18 199.99,22.55 201.01,22.55 C1210.1 201.42,22.65 201.54,22.54 202.96,22.54 R956.2
TS_EN_R: length 2.8
  TOP w0.102: v2(56.6,105.95) 56.6,105.57 56.06,105.03 R436.1
  BOTTOM w0.102: CN29.28 57.35,106.7 v2(56.6,105.95)
TYPEC_SBU1: length 11.5
  TOP w0.254: D19.2 11.23,12.82 TP77.1 11.62,12.43 v1(12.13,12.43)
  IN3 w0.254: v1(8.98,16.77) 8.72,16.77 8.32,16.37 8.32,14.08 9.33,13.07 11.11,13.07 11.75,12.43 v1(12.13,12.43)
  BOTTOM w0.203: 7.75,16.4 7.5,16.65 CN10.A8
  BOTTOM w0.254: v1(8.98,16.77) 8.72,16.77 8.35,16.4 7.75,16.4
TYPEC_SBU2: length 10.7
  IN1 w0.127: v1(8.7,19.67) 8.7,19.61 7.56,18.48 6.49,18.48 5.9,17.89 5.9,17.77 5.65,17.39 5.65,17 5.78,16.88 5.78,16.62 5.23,16.07 CN10.B8
  BOTTOM w0.254: v1(8.7,19.67) 9.08,20.05 TP78.1 10.48,20.05 11.11,19.42 11.11,18.54 D18.2
TYPEC_STRAP: length 29.4
  TOP w0.102: R25499.2 203.91,21.55 202.83,21.55 202.78,21.6 202.07,21.6 201.83,21.84 v2(201.83,22.08) 201.67,22.08 201.16,21.58 200.55,21.58 199.96,20.98 199.96,20.89 199.65,20.58 U37.77
  IN3 w0.089: v2(194.68,33.9) 194.81,34.02 196.45,34.02 197.04,33.44 197.04,29.82 198.19,28.66 198.19,28.48 198.55,28.12 200.9,28.12 203.06,25.96 203.06,24.78 201.89,23.61 201.89,22.15 v2(201.83,22.08)
  BOTTOM w0.102: v2(194.68,33.9) 194.31,33.53 R25500.1 191.87,33.53 191.58,33.82 191.58,34.1 v1(191.04,34.63)
UART2_CTS#: length 14.5
  BOTTOM w0.079: U1.CM12 90.4,36.63 89.93,36.16 89.72,36.16 89.5,35.93 89.5,35.83 89.32,35.65 89.12,35.65 89.02,35.54 88.96,35.43 88.96,35.25 89.01,35.12 89.01,34.91 88.98,34.82 88.96,34.76 88.96,33.75 88.89,33.67 88.89,32.86 89.17,32.57 89.85,32.57 90.44,31.99 90.44,31.99
  BOTTOM w0.102: 90.44,31.99 90.46,31.96 90.46,31.18 90.41,31.13 90.41,27.95 90.51,27.85 90.51,27.09 90.69,26.91 90.69,26.51 90.56,26.39 90.56,26.17 90.16,25.77 R604.1 89.73,25.77 v1(89.19,25.23)
UART2_RTS#: length 5.1
  BOTTOM w0.079: 91.22,32.07 91.11,32.07 90.03,33.15 90.03,34.82 90.1,34.97 90.12,34.99 90.18,35.17 90.18,35.57 U1.CN12
  BOTTOM w0.102: R607.1 91.37,31.92 91.22,32.07
UART2_RXD: length 7.4
  BOTTOM w0.079: 92.04,31.99 91.49,32.54 91.12,32.54 90.36,33.29 90.36,34.53 90.45,34.62 U1.CR12
  BOTTOM w0.102: 92.04,31.99 92.14,31.89 92.14,29.3 91.68,28.84 R606.1
UART2_TXD: length 7
  BOTTOM w0.079: 91.65,31.99 91.33,32.31 91.11,32.31 90.19,33.22 90.19,34.78 90.24,34.88 90.45,35.09 U1.CP12
  BOTTOM w0.102: 91.65,31.99 91.78,31.86 91.78,29.82 R605.1
UGATE1_CORE: length 1.9
  BOTTOM w0.508: PR7106.2 v1(125.12,72.34) 125.33,72.13 PQ7000.1
UGATE2_CORE: length 1.2
  BOTTOM w0.508: PQ7001.1 129.04,44.25 PR7078.2
UGATE_GT: length 1.7
  BOTTOM w0.508: PR7110.2 125.3,74.38 125.3,75.03 PQ7004.1
UGATE_SA: length 3.4
  BOTTOM w0.508: PR7114.2 139.33,39.69 v1(138.82,39.18) 138.58,38.93 138.33,38.93 137.87,38.47 PQ7002.4
ULT_EDP_HPD: length 204.8
  TOP w0.102: R25467.1 55.05,103.75 C6616.2 54.68,103.5 54.29,103.11 54.29,101.84 54.72,101.41 v2(54.72,100.49)
  IN1 w0.089: v1(29.02,68.03) 27.44,66.45 27.44,65.11 26.61,64.28 26.61,39.71 26.73,39.59 26.73,38.64 31.01,34.36 35.26,34.36 36.03,33.59 42.55,33.59 44.27,31.88 46.05,31.88 47.78,30.14 47.78,29.74 48.61,28.92 51.62,28.92 51.85,28.69 51.85,27.01 52.4,26.47 52.4,22.75 51.69,22.04 51.69,21.29 52.51,20.47 52.51,19.55 53.19,18.87 54.11,18.87 55.61,17.37 v2(55.61,17)
  IN3 w0.089: v2(55.61,17) 55.61,16.32 55.9,16.03 56.8,16.03 57.23,16.46 58.01,16.46 58.27,16.2 71.39,16.2 72.49,17.3 77.83,17.3 83.26,22.73 89.93,22.73 90.93,21.73 94.47,21.73 95.01,22.27 95.01,22.56 93.44,24.13 91.67,24.13 91.41,24.38 90.78,24.38 90.37,24.79 90.37,25.06 90.56,25.25 90.78,25.25 91.16,25.63 91.44,25.63 92.43,26.62 92.43,27.3 92.54,27.42 93.81,27.42 94.02,27.21 v2(94.4,27.21) ; v1(29.02,68.03) 29.01,68.04 29.01,73.4 28.3,74.11 27.18,74.11 25.86,75.42 25.86,76.65 25.25,77.26 25.25,81.62 26.1,82.47 26.1,83.55 25.77,83.88 25.77,86.31 26.06,86.6 26.43,86.6 28.34,88.52 28.34,92.68 29.98,94.32 29.98,95.25 32.5,97.76 42.85,97.76 44.51,99.43 54.04,99.43 54.72,100.11 v2(54.72,100.49)
  BOTTOM w0.079: U1.CM7 93.36,36.04 93.36,35.56 93.4,35.46 93.4,35.21 93.35,35.08 93.35,34.95 93.56,34.45 93.56,33.67 94.5,32.73
  BOTTOM w0.102: R10880.1 94.47,27.21 v2(94.4,27.21) 94.3,27.21 93.68,27.83 93.68,28.43 R1.2 94.5,29.31 94.5,32.73
ULT_EDP_HPD_R: length 2.3
  TOP w0.102: R25467.2 55.05,105.78 v2(55.47,106.19)
  BOTTOM w0.102: CN29.25 55.85,106.58 55.47,106.21 55.47,106.19 v2(55.47,106.19)
USB2_COMP: length 1.5
  TOP w0.102: v2(94.3,40.8) 94.87,40.8 R136.1
  BOTTOM w0.079: U1.CC5 94.68,41.13 94.35,40.8 v2(94.3,40.8)
USB2_ID: length 7.4
  TOP w0.102: v2(92.39,39.99) 92.9,39.48 93.18,39.48 93.31,39.36 93.31,38.77 93.46,38.62 94.9,38.62 95.06,38.47 95.06,37.76 v1(96.2,36.61) 96.56,36.97 R137.1
  BOTTOM w0.079: v2(92.39,39.99) 92.73,40.33 U1.CE8
USB2_VBUSSENSE: length 3.9
  TOP w0.102: v2(93.72,40.78) 94.11,40.4 94.5,40.4 94.73,40.17 95.08,40.17 95.92,39.33 R138.1
  BOTTOM w0.079: v2(93.72,40.78) 94.03,41.09 U1.CC6
USB3_SS0RX+: length 2.9
  BOTTOM w0.102: U6502.5 19.89,21.54 19.98,21.63 20.12,21.63 20.24,21.51 20.24,20.85 20.51,20.59 20.75,20.59 C683.1
USB3_SS0RX-: length 2.9
  BOTTOM w0.102: C682.1 20.77,20.8 20.6,20.8 20.46,20.94 20.46,21.6 20.21,21.85 19.98,21.85 19.89,21.94 U6502.4
USB3_SS0TX+: length 2
  BOTTOM w0.102: U6502.2 19.89,22.74 19.98,22.83 20.24,22.83 20.42,22.66 20.66,22.66 20.81,22.51 C677.1
USB3_SS0TX-: length 2
  BOTTOM w0.102: C681.1 20.81,23 20.69,22.87 20.51,22.87 20.33,23.05 19.98,23.05 19.89,23.14 U6502.1
USB30_RX1+: length 195.4
  TOP w0.102: C518.2 23.72,54.46 v1(23.71,54.47) R422.2
  IN3 w0.089: v1(23.71,54.47) 23.71,53.96 23.6,53.85 23.22,53.85 23.13,53.94 23.13,58.23 23.91,59.02 23.91,61.5 26.07,63.66 26.07,72.05 24.39,73.73 23.79,73.73 23.15,74.37 23.15,75.64 22.5,76.29 22.5,79.36 22.41,79.45 22.41,87.1 23.81,88.51 23.81,89.39 24.11,89.69 24.11,92.61 25.21,93.7 25.21,96.27 25.72,96.78 25.72,98.41 27.04,99.73 29.69,99.73 31.35,101.4 37.76,101.4 37.81,101.34 39.52,101.34 40.24,102.07 41.28,102.07 42.68,103.47 42.68,104.3 43.52,105.14 43.75,105.14 44.13,104.76 44.92,104.76 46.16,106.01 49.92,106.01 50.33,106.41 54.16,106.41 54.34,106.59 66.81,106.59 67.75,105.65 68.46,105.65 69.99,104.12 73.1,104.12 73.32,104.34 75.07,104.34 75.66,103.75 76.61,103.75 77.6,102.75 82.71,102.75 84.14,101.33 85.52,101.33 85.9,100.95 87.69,100.95 88.71,99.94 89.77,99.94 90.74,98.97 90.74,97.65 91.5,96.89 91.5,96.35 92.39,95.46 92.39,95.13 93.28,94.25 93.63,94.25 95.33,92.54 95.33,91.51 98.72,88.12 98.72,85.25 99.1,84.87 100.08,84.87 101.59,83.37 101.59,79.78 103.87,77.49 103.87,76.62 105.92,74.57 105.92,67.83 105.6,67.51 105.6,65.57 102.74,62.72 102.74,61.72 102.31,61.28 102.31,56.96 102.67,56.59 102.67,56.51 102.88,56.31 102.88,54.43 102.65,54.2 102.65,51.62 101.69,50.65 101.69,50.08 101.14,49.53 101.14,47.21 99.2,45.27 97.7,45.27 95.67,43.24 95.48,43.24 94.73,42.49 94.73,42.15 94.55,41.97 94.55,41.85 94.5,41.8 v2(94.33,41.8)
  BOTTOM w0.079: U1.CB6 94.33,42.22 94.39,42.16 94.39,41.86 v2(94.33,41.8)
USB30_RX1+_C: length 11.5
  TOP w0.102: CN2.6 13.1,51.65 13.2,51.55 13.47,51.55 14.32,52.4 15.64,52.4 16.98,53.73 18.19,53.73 U16.10 18.54,53.83 18.64,53.73 21.04,53.73 21.4,54.09 22.19,54.09 22.3,54.21 R422.1
USB30_RX1-: length 195.4
  TOP w0.102: C513.2 23.72,53.46 v1(23.71,53.45) R421.2
  IN3 w0.089: v2(94.93,41.8) 94.93,41.8 94.93,42.4 95.57,43.04 95.75,43.04 97.78,45.07 99.28,45.07 101.34,47.13 101.34,49.44 101.89,49.99 101.89,50.57 102.86,51.53 102.86,54.11 103.08,54.34 103.08,56.39 102.88,56.6 102.88,56.68 102.51,57.04 102.51,61.2 102.95,61.63 102.95,62.63 105.8,65.49 105.8,67.42 106.13,67.75 106.13,74.65 104.07,76.7 104.07,77.57 101.79,79.86 101.79,83.45 100.16,85.08 99.18,85.08 98.92,85.34 98.92,88.21 95.53,91.59 95.53,92.63 93.71,94.45 93.36,94.45 92.59,95.22 92.59,95.55 91.71,96.44 91.71,96.97 90.94,97.73 90.94,99.05 89.86,100.14 88.79,100.14 87.78,101.15 85.99,101.15 85.61,101.54 84.22,101.54 82.8,102.96 77.68,102.96 76.69,103.95 75.75,103.95 75.15,104.55 73.23,104.55 73.01,104.32 70.08,104.32 68.55,105.85 67.84,105.85 66.9,106.79 54.26,106.79 54.08,106.62 50.24,106.62 49.84,106.21 46.08,106.21 44.83,104.96 44.22,104.96 43.83,105.35 43.44,105.35 42.48,104.38 42.48,103.55 41.2,102.27 40.16,102.27 39.43,101.55 37.9,101.55 37.84,101.6 31.27,101.6 29.6,99.94 26.95,99.94 25.51,98.5 25.51,96.86 25,96.35 25,93.79 23.91,92.69 23.91,89.78 23.61,89.48 23.61,88.59 22.2,87.19 22.2,79.37 22.3,79.28 22.3,76.2 22.95,75.55 22.95,74.29 23.7,73.53 24.31,73.53 25.87,71.97 25.87,63.75 23.71,61.59 23.71,59.1 22.92,58.31 22.92,53.86 23.14,53.65 23.52,53.65 v1(23.71,53.45)
  BOTTOM w0.079: v2(94.93,41.8) 94.68,42.05 U1.CB5
USB30_RX1-_C: length 11.5
  TOP w0.102: R421.1 22.3,53.77 22.2,53.87 21.49,53.87 21.13,53.52 20.27,53.52 U16.1 20.1,53.52 17.07,53.52 15.73,52.18 14.41,52.18 13.56,51.33 13.2,51.33 13.1,51.23 CN2.5
USB30_RX2+: length 113.3
  TOP w0.102: v1(24.19,32.63) 24.12,32.55 23.79,32.55 23.56,32.78 C526.2 23.13,32.7 22.98,32.7 R428.2
  IN3 w0.089: v1(24.19,32.63) 24.37,32.45 24.75,32.45 24.95,32.24 24.95,30.75 24.9,30.69 24.9,25.01 24.21,24.31 24.21,18.61 24.78,18.03 25.96,18.03 26.5,17.49 26.5,12.11 26.92,11.7 31.29,11.7 31.9,11.09 37.47,11.09 39.59,13.21 41.44,13.21 42.32,14.08 42.32,15.23 43.89,16.8 44.61,16.8 48.6,20.79 48.6,20.96 49.97,22.33 53.56,22.33 54.96,23.73 58.93,23.73 59.55,24.35 60.63,24.35 61.38,25.11 65.45,25.11 65.81,24.75 67.2,24.75 67.53,24.42 67.82,24.42 68.63,23.61 69.51,23.61 70,23.13 73.66,23.13 74.07,23.53 74.18,23.53 76.8,26.15 76.91,26.15 77.25,26.48 77.25,27.86 78.17,28.79 80.67,28.79 80.95,29.07 80.95,30.19 81.94,31.18 83.11,31.18 84.09,32.15 84.09,32.68 84.86,33.46 85.45,33.46 85.65,33.67 86.54,33.67 86.63,33.76 86.63,34.36 87.58,35.32 89.48,35.32 90.57,36.41 91.12,36.41 91.48,36.77 91.48,40.39 91.15,40.72 91.15,42.05 91.45,42.35 91.86,42.35 91.93,42.43 91.93,42.58 v2(91.76,42.75)
  BOTTOM w0.079: v2(91.76,42.75) 91.76,42.78 92.08,43.09 U1.BY9
USB30_RX2+_C: length 10.7
  TOP w0.102: CN3.6 13.1,31.67 13.2,31.57 13.56,31.57 14.2,32.21 14.88,32.21 15.97,33.3 17.7,33.3 U17.10 17.87,33.3 20.09,33.3 20.67,32.71 21.35,32.71 R428.1
USB30_RX2-: length 113.3
  TOP w0.102: R427.2 22.92,32.49 23.2,32.49 C523.2 24.06,32.13 v1(24.19,31.99)
  IN3 w0.089: v1(24.19,31.99) 24.45,32.24 24.66,32.24 24.75,32.16 24.75,30.83 24.7,30.78 24.7,25.09 24.01,24.4 24.01,18.52 24.7,17.83 25.87,17.83 26.3,17.4 26.3,12.03 26.83,11.49 31.2,11.49 31.81,10.88 37.55,10.88 39.68,13 41.53,13 42.52,14 42.52,15.14 43.98,16.6 44.69,16.6 48.8,20.71 48.8,20.88 50.05,22.13 53.64,22.13 55.04,23.53 59.01,23.53 59.63,24.15 60.71,24.15 61.47,24.9 65.37,24.9 65.72,24.55 67.11,24.55 67.44,24.22 67.74,24.22 68.55,23.4 69.43,23.4 69.91,22.92 73.75,22.92 74.15,23.33 74.26,23.33 76.88,25.94 77,25.94 77.45,26.4 77.45,27.78 78.26,28.59 80.76,28.59 81.16,28.99 81.16,30.11 82.02,30.97 83.2,30.97 84.29,32.07 84.29,32.6 84.95,33.26 85.53,33.26 85.74,33.46 86.62,33.46 86.83,33.67 86.83,34.28 87.67,35.11 89.57,35.11 90.66,36.21 91.2,36.21 91.68,36.68 91.68,40.47 91.35,40.8 91.35,41.96 91.54,42.15 91.94,42.15 92.14,42.35 92.14,42.6 92.29,42.75 v2(92.38,42.75)
  BOTTOM w0.079: U1.BY8 92.73,43.09 v2(92.38,42.75)
USB30_RX2-_C: length 10.7
  TOP w0.102: CN3.5 13.1,31.19 13.27,31.36 13.65,31.36 14.29,31.99 14.97,31.99 16.06,33.08 19.58,33.08 U17.1 19.78,33.08 20,33.08 20.58,32.5 21.39,32.5 R427.1
USB30_RX3+: length 173.3
  IN1 w0.089: v2(25.3,10.79) 25.08,10.57 24.87,10.57 24.66,10.37 24.66,9.7 24.41,9.46 15.32,9.46 14.74,8.88 14.74,3.71 15.14,3.31 15.66,3.31 15.87,3.52 15.87,4.97 15.96,5.06 16.31,5.06 16.4,4.97 16.4,3.52 16.61,3.31 17.13,3.31 17.34,3.52 17.34,4.97 17.43,5.06 17.79,5.06 17.88,4.97 17.88,3.52 18.08,3.31 18.74,3.31 19.11,3.69 19.11,5.09 19.54,5.52 21.65,5.52 22.61,4.56 23.27,4.56 24.5,3.32 27.42,3.32 28.82,4.73 30.38,4.73 30.62,4.96 30.62,5.72 30.73,5.83 31.13,5.83 31.22,5.75 31.22,5.38 31.42,5.17 31.95,5.17 32.16,5.38 32.16,5.75 32.24,5.83 32.6,5.83 32.69,5.75 32.69,4.84 32.9,4.63 33.42,4.63 33.63,4.84 33.63,5.75 33.72,5.83 34.07,5.83 34.16,5.75 34.16,4.84 34.37,4.63 34.89,4.63 35.1,4.84 35.1,5.75 35.19,5.83 37.03,5.83 38.04,6.84 38.04,7.14 37.16,8.02 37.16,8.14 37.41,8.4 37.54,8.4 38.42,7.52 38.71,7.52 39.08,7.89 39.08,8.18 37.9,9.37 37.9,9.47 38.15,9.72 38.3,9.72 39.46,8.56 39.75,8.56 40.12,8.93 40.12,9.22 38.94,10.41 38.94,10.51 39.22,10.79 39.32,10.79 40.5,9.6 40.8,9.6 41.17,9.97 41.17,10.27 40.01,11.43 40.01,11.58 40.26,11.83 40.36,11.83 41.54,10.64 41.84,10.64 42.21,11.01 42.21,11.31 41.05,12.47 41.05,12.62 41.3,12.87 41.4,12.87 43.58,10.7 43.9,10.7 44.27,11.07 44.27,11.34 42.07,13.54 42.07,13.59 42.32,13.84 42.52,13.84 43.63,12.73 43.92,12.73 44.32,13.13 44.32,14.87 44.32,15 v2(44.51,15.19)
  IN3 w0.089: v2(94.35,42.78) 94.13,42.56 94.13,42.33 93.92,42.12 93.92,41.48 94.01,41.39 94.58,41.39 94.88,41.09 94.88,38.67 94.4,38.19 94.4,37.5 91.68,34.78 91.18,34.78 90.14,33.74 89.27,33.74 88.76,33.23 88.76,32.44 87.42,31.1 86.97,31.1 86.6,30.73 85.83,30.73 84.3,29.2 83.83,29.2 83.22,28.59 83.09,28.59 82.59,28.08 82.59,27.7 82.1,27.21 81.46,27.21 80.04,25.79 79.19,25.79 78.8,25.4 78.8,24.53 78.14,23.86 77.13,23.86 76.85,23.57 76.85,23.24 76.24,22.64 75.73,22.64 75.55,22.47 75.55,22.25 74.82,21.52 74.36,21.52 74.08,21.24 67.66,21.24 67.33,20.9 52.3,20.9 51.74,21.46 50.33,21.46 49.49,20.61 49.49,20.43 44.79,15.73 44.56,15.73 44.33,15.5 44.33,15.38 v2(44.51,15.19) ; v2(25.3,10.79) 25.53,10.56 25.75,10.56 25.89,10.7 25.89,11.12 25.63,11.38 25.63,16.93 25.53,17.03 24.54,17.03 23.33,18.24 23.33,20.6 23.23,20.71 22.77,20.71 v1(22.69,20.64)
  BOTTOM w0.079: U1.BY6 94.03,43.14 94.35,42.82 94.35,42.8 94.35,42.8 v2(94.35,42.78)
  BOTTOM w0.102: v1(22.69,20.64) 22.63,20.7 22.2,20.7 21.94,20.45 C683.2
USB30_RX3-: length 173.3
  IN1 w0.089: v2(25.3,10.15) 25.08,10.37 24.95,10.37 24.86,10.28 24.86,9.62 24.5,9.26 15.41,9.26 14.95,8.8 14.95,3.8 15.23,3.52 15.58,3.52 15.67,3.61 15.67,5.05 15.87,5.26 16.4,5.26 16.61,5.05 16.61,3.61 16.69,3.52 17.05,3.52 17.14,3.61 17.14,5.05 17.35,5.26 17.87,5.26 18.08,5.05 18.08,3.61 18.17,3.52 18.66,3.52 18.91,3.77 18.91,5.18 19.46,5.72 21.73,5.72 22.69,4.76 23.35,4.76 24.59,3.53 27.33,3.53 28.74,4.93 30.3,4.93 30.41,5.05 30.41,5.8 30.65,6.04 31.21,6.04 31.42,5.83 31.42,5.46 31.51,5.37 31.86,5.37 31.95,5.46 31.95,5.83 32.16,6.04 32.68,6.04 32.89,5.83 32.89,4.93 32.98,4.84 33.34,4.84 33.43,4.93 33.43,5.83 33.63,6.04 34.16,6.04 34.36,5.83 34.36,4.93 34.45,4.84 34.81,4.84 34.9,4.93 34.9,5.83 35.11,6.04 36.94,6.04 37.84,6.93 37.84,7.05 36.96,7.94 36.96,8.23 37.33,8.6 37.62,8.6 38.5,7.72 38.63,7.72 38.88,7.97 38.88,8.1 37.69,9.28 37.69,9.55 38.07,9.92 38.38,9.92 39.54,8.76 39.67,8.76 39.92,9.01 39.92,9.14 38.74,10.32 38.74,10.59 39.13,10.99 39.4,10.99 40.59,9.8 40.71,9.8 40.96,10.06 40.96,10.18 39.8,11.34 39.8,11.66 40.18,12.03 40.44,12.03 41.63,10.85 41.75,10.85 42.01,11.1 42.01,11.22 40.85,12.38 40.85,12.7 41.22,13.07 41.49,13.07 43.66,10.9 43.81,10.9 44.06,11.15 44.06,11.25 41.86,13.45 41.86,13.67 42.23,14.04 42.6,14.04 43.71,12.93 43.84,12.93 44.12,13.21 44.12,14.87 44.12,14.99 v2(43.92,15.18)
  IN3 w0.089: v2(93.7,42.76) 93.81,42.76 93.93,42.65 93.93,42.41 93.72,42.21 93.72,41.39 93.93,41.18 94.5,41.18 94.68,41.01 94.68,38.75 94.19,38.27 94.19,37.58 91.6,34.99 91.1,34.99 90.05,33.95 89.18,33.95 88.56,33.32 88.56,32.53 87.33,31.3 86.88,31.3 86.51,30.94 85.75,30.94 84.22,29.4 83.75,29.4 83.14,28.79 83.01,28.79 82.38,28.16 82.38,27.78 82.02,27.42 81.38,27.42 79.96,26 79.11,26 78.6,25.49 78.6,24.61 78.05,24.07 77.05,24.07 76.64,23.66 76.64,23.33 76.16,22.85 75.64,22.85 75.35,22.55 75.35,22.33 74.74,21.72 74.27,21.72 74,21.44 67.58,21.44 67.24,21.11 52.38,21.11 51.83,21.66 50.25,21.66 49.29,20.7 49.29,20.52 44.71,15.94 44.48,15.94 44.12,15.58 44.12,15.39 v2(43.92,15.18) ; v1(22.69,21.27) 22.69,21.14 22.82,21.01 22.9,21.01 23,20.92 23.31,20.92 23.54,20.69 23.54,18.33 24.63,17.24 25.61,17.24 25.83,17.02 25.83,11.46 26.09,11.2 26.09,10.61 25.84,10.36 25.51,10.36 v2(25.3,10.15)
  BOTTOM w0.079: U1.BY7 93.63,43.14 93.7,43.07 v2(93.7,42.76)
  BOTTOM w0.102: C682.2 21.94,21.08 22.11,20.92 22.36,20.92 22.69,21.25 v1(22.69,21.27)
USB30_RX+_TYPEC1: length 26
  TOP w0.102: v1(12.63,14.46) 12.42,14.68 12.16,14.68 11.73,15.12 RV3.1 RV3.10 10.28,15.12 10.19,15.21 9.9,15.21 9.7,15.01 9.7,13.94 9.21,13.45 7.97,13.45 7.73,13.69 5.52,13.69 CN10.B11
  IN1 w0.089: v1(12.63,14.46) 12.81,14.64 13.01,14.64 13.04,14.62 16.25,14.62 17.46,15.84 17.46,17.23 17.58,17.36 18.5,17.36 18.73,17.59 18.73,18.1 18.48,18.35 17.51,18.35 17.38,18.48 17.38,18.96 17.14,19.2 15.98,19.2 15.86,19.32 15.86,19.49 15.97,19.59 17.79,19.59 v2(17.97,19.42)
  BOTTOM w0.102: U6502.7 18.3,20.56 18.38,20.48 18.38,19.82 v2(17.97,19.42)
USB30_RX+_TYPEC2: length 25.9
  IN1 w0.089: v1(13.57,17.39) 13.57,17.22 13.65,17.14 14.04,17.14 14.13,17.23 14.13,17.43 13.98,17.58 13.98,18.22 13.65,18.55 13.65,18.88 13.9,19.12 14.76,19.12 14.88,19.24 14.88,19.43 14.79,19.52 13.73,19.52 13.28,19.06 12.61,19.06 12.39,19.28 12.39,19.64 12.61,19.86 12.94,19.86 13.07,19.98 13.07,20.98 12.98,21.07 11.96,21.07 11.76,21.28 11.76,21.66 11.97,21.87 12.31,21.87 12.46,22.02 12.46,22.85 v2(12.3,23)
  BOTTOM w0.102: U6502.14 16.41,23.14 16.33,23.06 15.95,23.06 15.87,22.99 14.15,22.99 13.46,23.67 12.75,23.67 12.55,23.47 12.55,23.24 v2(12.3,23) ; CN10.A11 7.65,18.15 7.82,17.98 8.23,17.98 8.35,18.11 9.19,18.11 9.75,17.55 9.75,17.07 9.88,16.95 10.15,16.95 10.31,17.12 RV2.10 RV2.1 11.69,17.12 11.97,16.83 12.72,16.83 12.98,17.09 13.31,17.09 13.57,17.36 v1(13.57,17.39)
USB30_RX-_TYPEC1: length 26
  TOP w0.102: v1(12.63,15.1) 12.63,14.97 12.56,14.9 12.25,14.9 11.87,15.28 11.87,15.49 11.74,15.61 RV3.2 RV3.9 10.28,15.61 10.09,15.43 9.81,15.43 9.48,15.1 9.48,14.03 9.12,13.66 8.06,13.66 7.82,13.91 5.52,13.91 CN10.B10
  IN1 w0.089: v2(17.97,20.05) 17.97,19.88 17.89,19.8 15.88,19.8 15.66,19.57 15.66,19.23 15.89,19 17.06,19 17.18,18.88 17.18,18.39 17.43,18.15 18.39,18.15 18.53,18.01 18.53,17.67 18.41,17.56 17.5,17.56 17.26,17.32 17.26,15.92 16.16,14.82 13.12,14.82 13.1,14.85 12.76,14.85 12.63,14.97 v1(12.63,15.1)
  BOTTOM w0.102: v2(17.97,20.05) 18.02,20.05 18.15,20.18 18.15,20.38 18.05,20.48 17.97,20.48 17.9,20.56 U6502.8
USB30_RX-_TYPEC2: length 25.9
  IN1 w0.089: v2(12.99,23) 12.78,23 12.66,22.88 12.66,21.93 12.4,21.67 12.05,21.67 11.96,21.58 11.96,21.36 12.05,21.28 13.06,21.28 13.27,21.07 13.27,19.9 13.03,19.66 12.7,19.66 12.6,19.56 12.6,19.36 12.69,19.26 13.19,19.26 13.65,19.72 14.87,19.72 15.08,19.51 15.08,19.16 14.84,18.92 13.98,18.92 13.85,18.79 13.85,18.63 14.18,18.3 14.18,17.66 14.33,17.51 14.33,17.15 14.13,16.94 13.61,16.94 13.55,16.88 v1(13.55,16.72)
  BOTTOM w0.102: CN10.A10 7.69,17.65 7.81,17.77 8.32,17.77 8.44,17.89 9.1,17.89 9.54,17.46 9.54,16.98 9.79,16.74 10.13,16.74 10.26,16.62 RV2.9 RV2.2 12.8,16.62 13.07,16.88 13.4,16.88 v1(13.55,16.72) ; v2(12.99,23) 12.88,23 12.76,23.11 12.76,23.38 12.84,23.46 13.37,23.46 14.06,22.77 15.96,22.77 16.04,22.85 16.27,22.85 16.38,22.74 U6502.13
USB30_TX1+: length 200.5
  TOP w0.102: v2(23,59.65) 23.16,59.82 24,59.82 24.52,59.3 26.3,59.3 26.77,58.82 26.77,58.37 26.66,58.26 26.51,58.26 C520.1
  IN3 w0.089: v2(98.61,42.4) 98.51,42.5 arc(98.51,42.51) 98.51,42.51 98.51,42.57 arc(98.51,42.57) 98.51,42.58 98.85,42.91 99.41,42.91 99.9,43.4 99.9,44.83 102.01,46.94 102.01,49.27 102.53,49.78 102.53,50.36 103.47,51.3 103.47,53.78 104.15,54.47 104.15,56.18 103.46,56.86 103.46,57.09 103.11,57.44 103.11,60.75 106.44,64.08 106.44,67.19 106.72,67.48 106.72,74.99 105.14,76.57 105.14,78.28 104.63,78.79 104.63,81.55 102.53,83.65 102.53,84.75 102.98,85.2 102.98,88.23 102.51,88.7 99.41,88.7 96.18,91.93 96.18,92.85 94.17,94.86 94.17,95.4 93.87,95.69 93.34,95.69 92.33,96.7 92.33,97.24 91.55,98.01 91.55,99.3 89.1,101.75 86.23,101.75 85.84,102.14 84.63,102.14 83.2,103.57 78,103.57 76.93,104.63 75.91,104.63 75.4,105.14 72.96,105.14 72.74,104.92 70.34,104.92 68.79,106.46 68.13,106.46 66.54,108.06 63.43,108.06 63.26,107.89 54.17,107.89 53.5,107.21 49.93,107.21 49.52,106.81 45.31,106.81 45.15,106.97 43.93,106.97 41.87,104.91 41.87,103.79 40.96,102.88 39.78,102.88 39.04,102.14 38.26,102.14 38.21,102.2 29.43,102.2 29.04,101.8 29.04,101.06 28.53,100.54 26.67,100.54 24.75,98.62 24.75,97.01 24.24,96.51 24.24,93.87 23.31,92.94 23.31,90.37 22.54,89.61 22.54,88.48 21.16,87.1 21.16,85.98 20.72,85.55 20.72,84.48 21.19,84.01 21.19,80.81 20.03,79.64 20.03,77.63 22.34,75.32 22.34,74.05 23.45,72.93 24.06,72.93 25.26,71.74 25.26,64.02 22.13,60.9 22.13,60.25 22.48,59.9 22.92,59.9 23,59.83 v2(23,59.65)
  BOTTOM w0.079: U1.CA3 96.16,42.87 96.4,42.86 96.61,42.76 96.68,42.74 96.78,42.74 96.94,42.81 97.09,42.81 97.37,42.74 97.55,42.74 97.73,42.92 98.04,42.92 98.31,42.66 arc(98.35,42.6) 98.38,42.53 arc(98.4,42.46) 98.45,42.4 98.45,42.4 v2(98.61,42.4)
USB30_TX1+_C: length 1.3
  TOP w0.102: R423.2 24.71,58.28 24.95,58.28 C520.2
USB30_TX1+_C_R: length 13.1
  TOP w0.102: CN2.9 13.1,57.65 13.2,57.55 13.69,57.55 14.28,56.95 18.21,56.95 U16.6 18.37,56.95 20.65,56.95 20.8,57.11 20.8,57.86 21.2,58.26 21.77,58.26 C522.1 22.55,58.26 23.15,58.26 R423.1
USB30_TX1-: length 200.5
  TOP w0.102: C519.1 26.51,58.04 26.75,58.04 26.99,58.28 26.99,58.91 26.39,59.51 24.61,59.51 24.09,60.03 23.27,60.03 23.16,60.13 23.16,60.14 v2(23,60.3)
  IN3 w0.089: v2(98.03,42.38) 98.36,42.71 arc(98.37,42.72) 98.37,42.72 98.77,43.12 99.33,43.12 99.69,43.48 99.69,44.91 101.8,47.02 101.8,49.35 102.32,49.87 102.32,50.44 103.26,51.38 103.26,53.87 103.95,54.55 103.95,56.09 103.26,56.78 103.26,57 102.91,57.36 102.91,60.83 106.23,64.16 106.23,67.28 106.52,67.56 106.52,74.9 104.94,76.48 104.94,78.2 104.43,78.71 104.43,81.46 102.32,83.57 102.32,84.83 102.78,85.29 102.78,88.14 102.42,88.5 99.32,88.5 95.97,91.85 95.97,92.76 93.97,94.77 93.97,95.31 93.79,95.49 93.25,95.49 92.12,96.62 92.12,97.15 91.35,97.93 91.35,99.22 89.02,101.55 86.15,101.55 85.76,101.94 84.54,101.94 83.12,103.36 77.91,103.36 76.85,104.43 75.82,104.43 75.31,104.94 73.04,104.94 72.82,104.72 70.25,104.72 68.71,106.26 68.05,106.26 66.45,107.86 63.52,107.86 63.34,107.68 54.25,107.68 53.58,107.01 50.01,107.01 49.6,106.6 45.23,106.6 45.06,106.77 44.01,106.77 42.07,104.83 42.07,103.71 41.05,102.68 39.86,102.68 39.13,101.94 38.18,101.94 38.13,101.99 29.52,101.99 29.25,101.72 29.25,100.98 28.61,100.34 26.76,100.34 24.95,98.54 24.95,96.93 24.45,96.42 24.45,93.79 23.51,92.86 23.51,90.29 22.74,89.52 22.74,88.39 21.37,87.01 21.37,85.9 20.93,85.46 20.93,84.56 21.4,84.09 21.4,80.72 20.23,79.56 20.23,77.71 22.54,75.4 22.54,74.14 23.54,73.14 24.14,73.14 25.46,71.82 25.46,63.94 22.34,60.82 22.34,60.34 22.57,60.11 22.81,60.11 v2(23,60.3)
  BOTTOM w0.079: U1.CA4 95.77,42.74 96.23,42.71 96.35,42.7 96.36,42.69 96.54,42.61 96.65,42.57 96.82,42.57 96.97,42.65 97.07,42.65 97.34,42.57 97.36,42.58 97.62,42.58 97.8,42.76 97.98,42.76 98.06,42.68 98.06,42.68 98.14,42.6 arc(98.14,42.59) 98.14,42.59 98.14,42.49 arc(98.14,42.49) 98.14,42.49 v2(98.03,42.38)
USB30_TX1-_C: length 1.3
  TOP w0.102: R424.2 24.75,58.06 24.91,58.06 C519.2
USB30_TX1-_C_R: length 13.1
  TOP w0.102: CN2.8 13.1,57.23 13.2,57.33 13.6,57.33 14.19,56.74 20.08,56.74 U16.5 20.29,56.73 20.73,56.73 21.02,57.02 21.02,57.77 21.29,58.04 21.77,58.04 C521.1 22.55,58.04 23.15,58.04 R424.1
USB30_TX2+: length 132.8
  TOP w0.102: v1(25.97,36.31) 25.8,36.47 25.8,37.13 25.36,37.58 25.22,37.58 C531.1
  IN3 w0.089: v2(99.17,43.6) 98.97,43.79 98.97,44.08 98.79,44.26 98.31,44.26 97.98,43.92 97.98,43.17 96.2,41.4 96.2,40.75 96.56,40.4 96.56,39.11 96.33,38.88 96.33,37.56 96.2,37.43 96.2,36.85 94.97,35.62 94.05,35.62 92.87,34.45 92.87,32.91 92.71,32.75 92.36,32.75 91.82,32.22 90.05,32.22 89.14,31.3 89.14,30.64 88.5,30.01 87.38,30.01 87.04,29.67 86.86,29.67 85.22,28.03 84.55,28.03 83.88,27.36 83.88,26.33 83.21,25.67 82.15,25.67 81.41,24.93 80.72,24.93 78.15,22.37 78.15,22.33 77.01,21.18 76.61,21.18 76.23,20.8 75.61,20.8 75.19,20.38 74.76,20.38 74.07,19.7 69.71,19.7 69,18.99 64.52,18.99 64.22,19.28 63.48,19.28 63.01,19.75 56.02,19.75 55.66,19.39 53.37,19.39 52.24,18.26 48,18.26 44.99,15.25 44.99,14.97 41.28,11.26 40.4,11.26 38.28,9.14 24.25,9.14 23.76,9.63 23.76,12.52 22.81,13.46 22.27,13.46 21.81,13.92 21.81,15.01 21.37,15.45 21.37,17.5 21.65,17.78 21.65,19.78 20.89,20.54 20.89,24.27 20.64,24.52 20.64,30.36 21.65,31.38 21.65,32.01 22.65,33.01 24.04,33.01 24.84,33.81 25.31,33.81 25.79,34.29 25.79,36.13 v1(25.97,36.31)
  BOTTOM w0.079: v2(99.17,43.6) 99.17,43.57 98.69,43.1 97.46,43.1 U1.CA1
