# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 100.21,77.68 100.28,77.61 100.28,77.48 100.15,77.35 97.9,77.35 97.7,77.56 97.7,78.09 97.88,78.27 100.21,78.27
GND on TOP (solid shape): 113.6,120.51 113.6,119.62 112.41,118.43 110.63,118.43 110.55,118.5 110.55,120.76 110.68,120.89 113.22,120.89
GND on TOP (solid shape): 27.3,74.22 27.3,71.04 27.11,70.85 26.22,70.85 25.84,71.23 25.84,72.38 26.22,72.76 26.22,74.28 26.35,74.41 27.11,74.41
GND on TOP (solid shape): 46.82,20.48 46.82,18.73 46.37,18.27 43.17,18.27 42.78,18.66 42.78,20.86 42.07,21.58 42.07,22.16 42.18,22.26 45.05,22.26
GND on TOP (solid shape): 49.2,97.8 50.44,97.8 50.73,97.51 50.73,96.76 50.63,96.66 45.32,96.66 45.12,96.86 45.12,98.28 45.22,98.39 48.62,98.39
GND on TOP (solid shape): 65.72,61.58 65.72,60.71 65.56,60.55 65.02,60.55 64.91,60.44 62.04,60.44 61.91,60.57 61.91,61.2 62.55,61.84 65.47,61.84
GND on TOP (solid shape): 193.05,10.81 193.05,10.7 192.75,10.4 189.5,10.4 189.39,10.5 189.39,11.01 189.8,11.42 190.71,11.42 190.89,11.59 192.26,11.59
GND on TOP (solid shape): 49.26,16.37 50.2,16.37 50.28,16.29 50.28,15.45 50.1,15.28 48.8,15.28 48.53,15.56 48.53,16.45 48.6,16.52 49.11,16.52
GND on TOP (solid shape): 91.87,61.29 91.87,60.84 91.37,60.34 89.93,60.34 89.93,60.8 89.95,60.82 91.22,60.82 91.45,61.05 91.45,61.36 91.53,61.43 91.73,61.43
GND on TOP (solid shape): 109.1,120.86 109.1,117.56 108.67,117.13 107.22,117.13 107,117.36 107,118.15 106.97,118.17 106.97,120.97 107.05,121.04 108.93,121.04
GND on TOP (solid shape): 102.25,17.05 102.25,16.19 101.74,15.68 101.36,15.68 100.93,15.25 100.16,15.25 98.87,16.55 98.87,17.03 98.97,17.13 102.17,17.13
GND on TOP (solid shape): 82.71,107.96 82.71,107.43 82.72,107.4 82.74,107.36 82.74,106.54 82.49,106.29 79.94,106.29 79.69,106.54 79.69,108.19 79.82,108.32 82.36,108.32
GND on TOP (solid shape): 80.48,30.62 80.66,30.62 80.68,30.6 80.68,29.17 80.63,29.12 78.73,29.12 78.6,28.99 77.47,28.99 77.47,29.15 77.34,29.28 77.34,30.63 77.63,30.92 80.17,30.92
GND on TOP (solid shape): 214.49,15.48 214.49,12.69 214.64,12.53 215.83,12.53 215.94,12.43 215.94,11.57 215.78,11.42 214.26,11.42 213.47,12.2 213.47,14.67 213.83,15.02 213.83,15.43 214.01,15.61 214.36,15.61
GND on TOP (solid shape): 128.51,30.69 128.51,29.04 128.03,28.56 126.68,28.56 126.43,28.31 122.62,28.31 122.36,28.56 122.36,28.94 122.49,29.07 125.03,29.07 125.41,29.45 125.41,30.34 126.3,31.23 127.98,31.23
GND on TOP (solid shape): 104.05,38.19 104.05,38.16 104.18,38.04 104.63,38.04 104.71,37.96 104.71,37.73 104.46,37.48 104.01,37.48 103.87,37.48 103.76,37.59 102.74,37.59 102.7,37.63 102.7,38.24 102.8,38.34 103.9,38.34
GND on TOP (solid shape): 136.71,98.79 136.71,96.65 136.71,96.62 136.71,95.11 136.46,94.86 136.24,94.86 134.17,96.92 134.17,97.52 134.17,97.52 134.17,97.67 134.15,97.7 134.15,99.2 134.38,99.43 136.08,99.43
GND on TOP (solid shape): 24.78,7.15 24.78,4.25 24.7,4.18 23.38,4.18 23.3,4.25 23.3,5.07 22.67,5.7 22.67,6.21 22.29,6.59 22.29,7.23 22.41,7.35 23.05,7.35 23.43,7.73 24.19,7.73
GND on TOP (solid shape): 27.24,22.02 27.24,21.79 27.19,21.73 27.19,21.16 27.24,21.11 27.24,20.85 27.07,20.68 27.07,20.69 26.42,20.69 26.26,20.84 26.1,20.84 25.37,21.58 24.97,21.58 24.94,21.58 24.07,21.58 24,21.65 24,21.99 24.1,22.09 27.17,22.09
GND on TOP (solid shape): 109.43,17.77 109.43,17.21 108.22,15.99 107.48,15.99 107.38,16.09 107.38,16.65 107.2,16.83 107.05,16.83 106.99,16.85 106.92,16.85 106.85,16.85 106.79,16.83 105.29,16.83 105.17,16.95 105.17,17.66 105.45,17.94 109.26,17.94
GND on TOP (solid shape): 115.84,72.3 115.84,69.43 115.48,69.07 110.73,69.07 110.55,68.9 110.55,68.01 110.35,67.8 106.84,67.8 106.72,67.93 106.72,68.87 106.74,68.9 107.45,68.9 107.89,69.33 107.89,69.71 108.14,69.96 112.3,69.96 112.35,70.01 112.54,70.01 112.54,72.54 112.86,72.86 115.28,72.86
GND on TOP (solid shape): 89.84,64.38 90.91,64.38 91.02,64.48 91.73,64.48 91.86,64.35 91.86,63.77 91.73,63.64 91.27,63.64 90.59,62.95 90.59,62.87 90.51,62.8 90.05,62.8 89.72,63.13 89.72,63.61 89.62,63.71 84.44,63.71 84.21,63.95 84.21,64.66 84.45,64.9 89.32,64.9
GND on TOP (solid shape): 32.29,24.4 32.29,23.56 32.73,23.13 33.21,23.13 33.26,23.07 33.26,22.72 31.15,20.61 29.4,20.61 29.27,20.74 29.2,20.74 28.71,21.23 28.71,21.47 28.81,21.58 30.16,21.58 30.26,21.68 30.26,23.96 30.64,24.34 31.63,24.34 31.74,24.45 32.24,24.45
GND on TOP (solid shape): 111.56,58.42 111.56,56.82 111.71,56.67 111.71,56.12 111.77,56.06 111.77,55.54 112.15,55.15 112.15,51.6 112,51.45 111.39,51.45 111.31,51.52 111.31,51.78 111.14,51.95 107.15,51.95 106.18,52.92 106.18,54.27 103.52,56.93 103.52,60.23 105.36,62.08 107.9,62.08
GND on TOP (solid shape): 42.48,113.52 42.48,112.61 42.38,112.51 41.82,112.51 41.62,112.3 41.62,111.9 41.59,111.87 39.43,111.87 39.2,112.1 39.2,113.24 39.36,113.4 39.76,113.4 39.98,113.18 40.31,113.18 40.32,113.19 41.34,113.19 41.59,113.45 41.59,113.52 41.72,113.65 42.35,113.65
GND on TOP (solid shape): 48.76,122.67 48.77,122.64 48.77,122.62 48.76,122.57 48.75,122.52 48.76,122.45 48.78,122.37 48.78,121.91 48.79,121.86 48.8,121.8 48.8,121.04 48.63,120.86 47.15,120.86 47.03,120.99 47.03,122.59 47.15,122.72 48.7,122.72
GND on TOP (solid shape): 159.37,29.02 159.37,27.34 159.07,27.04 159.07,26.78 158.67,26.39 157.33,26.39 157.21,26.28 152.33,26.28 151.98,26.63 151.98,26.96 152.08,27.06 152.08,27.55 152.23,27.7 152.87,27.7 153.4,27.16 156.32,27.16 156.96,27.8 157.92,27.8 158.05,27.93 158.05,29.32 158.18,29.45 158.94,29.45
GND on TOP (solid shape): 112.84,48.5 112.84,48.2 112.53,47.89 112.3,47.89 112.29,47.89 111.41,47.89 111.4,47.89 110.54,47.89 110.53,47.89 110.02,47.89 109.76,47.64 109.76,47.23 109.69,47.15 108.9,47.15 108.66,47.4 108.3,47.4 108.29,47.41 107.71,47.41 107.38,47.74 105.98,47.74 105.85,47.87 105.85,48.75 105.98,48.88 110.93,48.88 110.95,48.87 111.68,48.87 111.95,49.14 112.2,49.14
GND on TOP (solid shape): 39.18,5.07 39.18,4.69 39.05,4.56 37.83,4.56 37.81,4.56 37.8,4.57 37.53,4.69 37.26,4.57 37.24,4.56 37.22,4.56 35.57,4.56 35.49,4.56 35.24,4.81 35.24,5.45 35.37,5.57 38.67,5.57
GND on TOP (solid shape): 118.34,23.94 118.34,22.96 118.94,22.36 118.96,22.36 119.31,22.01 119.31,21.58 119.19,21.45 116.07,21.45 115.91,21.45 115.61,21.45 115.57,21.45 115.25,21.45 115.12,21.58 115.12,22.19 115.33,22.39 115.73,22.39 115.78,22.44 115.78,23.91 116.04,24.17 118.11,24.17
GND on TOP (solid shape): 102.88,45.4 102.88,44.72 102.73,44.56 101.79,44.56 101.28,45.07 100.39,45.07 100.27,45.19 100.27,45.52 100.28,45.56 100.32,45.58 100.93,45.58 100.96,45.57 101.34,45.57 101.38,45.58 101.48,45.58 101.71,45.81 102.47,45.81
GND on TOP (solid shape): 123.76,67.93 123.76,66.66 123.25,66.15 122.11,66.15 120.2,64.25 119.21,64.25 117.56,62.6 117.56,57.8 117.11,57.34 116.95,57.34 116.77,57.16 116.32,57.16 116.27,57.21 116.27,62.24 117.07,63.04 117.07,64.47 117.38,64.79 117.38,65.75 117.92,66.28 119.57,66.28 120.58,67.3 120.58,68.69 120.84,68.95 122.74,68.95
GND on TOP (solid shape): 109.92,125.08 109.92,122.41 109.54,122.03 105.73,122.03 105.47,122.29 105.47,123.58 105.69,123.8 105.77,123.92 105.8,124.07 105.72,124.3 105.51,124.44 105.49,124.44 105.47,124.47 105.47,125.26 105.49,125.29 105.52,125.31 109.69,125.31
GND on TOP (solid shape): 133.11,69.56 133.14,69.54 133.16,69.51 133.41,69.25 133.41,68.79 135.8,66.41 135.8,63.03 134.12,61.35 134.03,61.35 133.75,61.07 133.55,61.07 133.16,60.69 130.98,60.69 130.91,60.71 130.85,60.72 130.78,60.71 130.71,60.69 130.06,60.69 127.8,62.95 127.8,66.36 129.65,68.21 129.65,68.62 130.59,69.56
GND on TOP (solid shape): 37.65,32.12 37.65,31.2 37.43,30.97 35.88,30.97 35.62,30.72 34.8,30.72 34.66,30.89 34.45,30.95 34.24,30.89 34.1,30.72 33.34,30.72 33.21,30.85 33.21,31.61 33.59,31.99 33.6,31.99 33.85,32.24 37.53,32.24
GND on TOP (solid shape): 130.03,19.72 130.03,19.11 130.11,19.04 130.64,19.04 130.95,18.73 130.95,17.79 130.8,17.64 129.67,17.64 129.64,17.64 129.27,17.64 129.15,17.77 128.77,17.77 128.59,17.95 128.59,18.27 128.74,18.43 128.79,18.43 128.88,18.47 128.91,18.56 128.91,18.6 128.95,18.64 128.95,19.61 129.22,19.87 129.88,19.87
GND on TOP (solid shape): 90.4,59.4 90.4,58.95 90.59,58.76 91.61,58.76 91.89,58.49 91.89,58.25 91.7,58.06 91.44,58.06 91.3,58.19 91.12,58.23 90.93,58.18 90.7,57.95 89.27,57.95 89.19,58.03 89.19,58.36 89.65,58.82 89.65,59.19 89.92,59.47 90.33,59.47
GND on TOP (solid shape): 96.07,85.84 96.07,85.18 95.97,85.08 90.61,85.08 90.36,84.82 90.36,83.81 90.61,83.55 91.25,83.55 91.63,83.17 91.63,82.41 91.5,82.28 90.99,82.28 90.49,81.77 90.49,81.14 90.36,81.01 89.98,81.01 89.85,81.14 89.85,82.92 89.47,83.3 88.2,83.3 87.95,83.04 87.95,82.28 87.69,82.03 87.44,82.03 87.18,82.28 87.18,84.31 87.44,84.57 87.44,85.46 87.95,85.97 95.95,85.97
GND on TOP (solid shape): 76.68,125.87 76.71,125.86 77.62,124.42 79.2,123.87 81.34,123.87 81.38,123.85 81.39,123.82 81.39,120.41 80.73,119.75 73.85,119.75 73.54,120.05 73.54,125.64 73.78,125.87
GND on TOP (solid shape): 60.67,108.52 60.67,107.81 60.87,107.61 61.78,107.61 61.8,107.59 62.33,107.59 63.09,106.83 63.09,106.78 63.18,106.69 63.18,106.21 63.33,106.06 63.33,105.5 63.21,105.37 62.77,105.37 62.52,105.62 62.52,106.46 62.29,106.69 61.63,106.69 61.56,106.62 60.92,106.62 60.64,106.34 60.64,106.21 60.64,105.93 60.56,105.85 60.26,105.85 60.08,106.03 60.08,107.48 59.47,108.09 59.47,108.52 59.49,108.56 59.52,108.57 59.66,108.62 59.74,108.74 59.74,108.75 59.77,108.77 60.41,108.77
GND on TOP (solid shape): 118.38,125.31 118.41,125.29 118.43,125.26 118.43,123.94 118.04,123.56 118.04,123.27 117.99,123.07 118.04,122.88 118.04,122.05 118.04,122.01 118.04,120.02 118.04,120.01 118.02,119.88 118.04,119.75 118.04,119.75 118.04,119.39 118.04,119.38 118.02,119.25 118.04,119.12 118.04,119.11 118.04,118.6 117.79,118.35 117.28,118.35 116.9,118.73 116.9,118.93 116.9,125.26 116.92,125.29 116.95,125.31
GND on TOP (solid shape): 83.51,53.25 87.44,53.25 88.19,52.51 91.28,52.51 91.46,52.51 91.76,52.21 91.76,51.68 91.63,51.55 89.12,51.55 88.74,51.93 85.76,51.93 85.56,52.13 83.63,52.13 82.77,51.27 82.71,51.27 82.28,50.84 82.28,50.66 82.21,50.58 81.88,50.58 81.85,50.61 81.85,51.36 82,51.51 82,52.03 82.07,52.1 82.46,52.1 82.5,52.09 82.54,52.09 82.58,52.09 82.62,52.1 82.67,52.1 82.7,52.13 82.79,52.19 82.86,52.28 82.87,52.3 82.87,52.32 82.89,52.38 82.9,52.44 82.89,52.51 82.87,52.57 82.87,53.26 83.03,53.42 83.34,53.42
GND on TOP (solid shape): 90.62,71.63 90.62,69.36 90.62,69.31 90.78,69.15 91.31,69.15 91.54,69.06 91.78,69.15 92.78,69.15 92.83,69.14 93.05,68.92 93.05,68.47 92.9,68.31 91.6,68.31 91.25,68.67 91.04,68.67 90.99,68.68 90.94,68.68 90.89,68.68 90.84,68.67 90.74,68.67 90.48,68.41 90.48,68.3 89.88,67.69 89.88,66.51 89.72,66.36 89.16,66.36 88.86,66.66 87.87,66.66 87.87,66.71 87.67,66.92 87.67,68.21 87.87,68.42 88.56,68.42 88.63,68.49 88.63,71.84 88.76,71.97 90.28,71.97
GND on TOP (solid shape): 158.71,22.59 158.9,22.59 159.06,22.44 159.06,21.53 159.07,21.51 159.08,21.49 159.08,21.24 159.24,21.07 162.39,21.07 162.72,20.74 162.72,20.33 162.66,20.27 155.85,20.27 155.81,20.31 155.81,20.66 155.92,20.76 158.02,20.76 158.26,21 158.26,21.44 158.28,21.5 158.28,21.55 158.28,21.6 158.26,21.77 158,22.03 157.34,22.03 157.22,21.91 155.03,21.91 154.06,20.94 154.06,20.74 154.05,20.7 154.01,20.69 150.05,20.69 149.92,20.81 149.92,21.51 149.92,21.54 149.92,22.47 150.05,22.59 156.83,22.59 156.98,22.74 158.56,22.74
GND on TOP (solid shape): 43.84,31.97 43.84,31.61 43.53,31.3 43.53,30.77 42.86,30.1 41.7,30.1 41.63,30.03 41.63,28.79 39.55,26.72 38.7,26.72 38.6,26.81 38.6,27.11 38.72,27.23 39.11,27.23 39.27,27.39 39.27,27.94 39.64,28.31 39.64,28.84 39.71,28.9 40.76,28.9 40.82,28.95 40.82,30.8 40.86,30.85 41.11,30.97 41.21,31.23 41.14,31.45 40.95,31.59 40.88,31.66 40.9,31.76 41.24,32.1 43.72,32.1
GND on TOP (solid shape): 136.33,33.01 136.33,32.57 136.32,32.55 136.3,32.54 136.1,32.22 136.3,31.9 136.33,31.88 136.33,31.85 136.33,29.22 136.16,29.04 136.16,28.87 136.06,28.77 135.79,28.77 135.7,28.73 135.66,28.64 135.66,28.44 135.62,28.4 135.62,28.28 135.14,27.8 133.03,27.8 133.01,27.82 132.6,27.82 132.4,28.03 132.4,28.43 132.02,28.81 132.02,29.93 132.35,30.26 132.35,31.89 132.45,31.99 133.72,31.99 133.92,31.79 134.89,31.79 135.13,32.03 135.13,33.07 135.32,33.26 136.08,33.26
GND on TOP (solid shape): 41.18,109.64 41.18,108.09 41.32,107.95 41.98,107.95 42.23,107.71 42.56,107.71 42.68,107.58 42.68,107.33 42.5,107.14 42,107.14 42,107.17 41.94,107.23 41.95,107.27 41.95,107.32 41.6,107.7 41.19,107.37 41.17,107.34 41.17,106.35 41.12,106.31 41.08,106.31 41.01,106.27 40.85,106.27 40.79,106.31 40.38,106.72 39.69,106.72 39.38,106.41 38.82,106.41 38.62,106.62 38.62,107.22 40.24,108.85 40.24,109.59 40.36,109.71 41.12,109.71
GND on TOP (solid shape): 125.61,80.66 125.61,79.92 123.84,78.14 123.66,78.14 123.28,78.52 123.28,78.62 123.58,78.93 123.58,79.31 123.2,79.69 122.52,79.69 122.21,79.99 124.59,79.99 124.6,79.94 124.61,79.88 124.63,79.83 124.66,79.78 124.69,79.74 124.73,79.7 124.78,79.67 124.83,79.64 124.88,79.62 124.93,79.61 124.99,79.61 125.04,79.62 125.1,79.63 125.15,79.65 125.2,79.68 125.24,79.72 125.28,79.76 125.31,79.8 125.33,79.86 125.35,79.91 125.36,79.96 125.36,80.02 125.35,80.08 125.33,80.13 125.31,80.18 125.28,80.23 125.24,80.27 125.2,80.3 125.15,80.33 125.1,80.35 125.04,80.37 124.99,80.37 124.93,80.37 124.88,80.36 124.83,80.34 124.78,80.32 124.73,80.29 124.69,80.25 124.66,80.2 124.63,80.15 124.61,80.1 124.6,80.05 124.59,79.99 122.21,79.99 122.16,80.05 122.16,80.87 122.22,80.92 122.33,81.01 122.39,81.06 125.21,81.06
GND on TOP (solid shape): 138.87,57.85 138.87,57.34 139.1,57.11 139.61,57.11 139.97,57.47 140.83,57.47 141.11,57.19 141.11,57.03 141.04,56.96 140.87,56.72 140.82,56.42 140.82,55.18 140.84,55.01 140.9,54.85 141.15,54.6 141.54,54.6 141.54,53.96 141.79,53.71 141.79,52.31 141.67,52.18 139.54,52.18 139.4,52.31 139.22,52.36 139.06,52.33 138.93,52.23 138.01,52.23 137.83,52.06 137.83,50.48 137.73,50.38 137.02,50.38 136.25,51.15 135.73,51.15 135.61,51.27 135.61,52.68 135.72,52.79 135.95,52.79 136.31,53.15 136.31,57.49 136.43,57.62 137.98,57.62 138.34,57.97 138.75,57.97
GND on TOP (solid shape): 91.25,49.01 91.25,48.63 90,47.38 89.7,47.38 89.55,47.53 89.55,47.66 89.24,47.97 89.24,48.37 88.17,49.44 87.44,49.44 87.13,49.14 87.13,48.77 87.01,48.64 86.66,48.64 86.6,48.58 86.6,47.94 86.83,47.71 86.83,47.38 86.68,47.23 86.12,47.23 86.04,47.31 86.04,47.74 85.96,47.81 85.96,48.49 85.81,48.64 84.63,48.64 84.47,48.47 84.47,47.33 84.69,47.1 85.08,47.1 85.2,46.98 85.2,46.8 85.05,46.65 84.77,46.65 84.47,46.34 84.47,46.06 84.75,45.78 85,45.78 85.05,45.73 85.05,45.45 84.95,45.35 84.47,45.35 83.86,44.74 83.12,44.74 83.02,44.84 83.02,45.05 83.15,45.17 83.5,45.17 84.03,45.71 84.03,47.18 84.06,47.21 84.06,47.5 84.03,47.53 84.03,47.79 83.63,48.2 83.63,48.55 83.55,48.63 83.02,48.63 82.41,48.02 82.05,48.02 81.9,48.17 81.9,48.86 82.05,49.01 83.42,49.01 83.6,49.19 83.6,50.15 83.7,50.25 90,50.25
GND on TOP (solid shape): 114.37,38.84 114.4,38.76 114.35,38.68 114.21,38.55 114.16,38.37 114.26,38.11 114.51,38.01 114.59,38.02 114.68,38.05 115.17,38.05 115.37,37.84 115.98,37.84 116.14,37.69 116.14,36.31 116.27,36.18 116.27,35.82 116.23,35.77 116.22,35.71 116.22,35 116.23,34.95 116.27,34.9 116.27,34.53 116.65,34.15 116.65,33.51 116.52,33.39 116.14,33.39 115.76,33.77 113.86,33.77 113.82,33.73 112.82,33.73 112.71,33.84 112.71,33.84 112.62,33.93 112.62,40.03 112.63,40.06 112.67,40.08 113.14,40.08
GND on TOP (solid shape): 26.86,86.85 26.86,84.82 26.48,84.44 26.28,84.44 26.28,84.44 23.68,84.44 23.43,84.7 23.43,85.33 25.84,85.33 25.85,85.27 25.86,85.22 25.88,85.17 25.91,85.12 25.94,85.08 25.98,85.04 26.02,85 26.07,84.98 26.13,84.96 26.18,84.95 26.24,84.95 26.29,84.95 26.35,84.97 26.4,84.99 26.45,85.02 26.49,85.06 26.53,85.1 26.56,85.14 26.58,85.19 26.6,85.25 26.6,85.3 26.6,85.36 26.6,85.41 26.58,85.47 26.56,85.52 26.53,85.56 26.49,85.61 26.45,85.64 26.4,85.67 26.35,85.69 26.29,85.71 26.24,85.71 26.18,85.71 26.13,85.7 26.07,85.68 26.02,85.66 25.98,85.62 25.94,85.58 25.91,85.54 25.88,85.49 25.86,85.44 25.85,85.39 25.84,85.33 23.43,85.33 23.43,85.71 23.68,85.97 23.73,85.97 23.78,85.99 23.84,86.01 23.88,86.04 23.93,86.08 23.97,86.12 24,86.17 24.02,86.22 24.03,86.27 24.04,86.32 24.07,86.35 25.32,86.35 25.35,86.35 25.59,86.35 25.97,86.73 25.97,86.98 26.1,87.11 26.6,87.11
GND on TOP (solid shape): 82.17,58.2 82.17,57.79 82.23,57.73 82.29,57.66 82.36,57.6 82.39,57.58 82.42,57.58 82.54,57.56 82.67,57.58 82.7,57.58 82.73,57.61 82.79,57.66 82.84,57.72 83.03,57.91 83.24,57.91 83.57,57.58 83.83,57.58 83.92,57.53 84.03,57.51 84.14,57.53 84.24,57.58 88.6,57.58 88.76,57.42 88.76,56.38 89.2,55.94 89.47,55.94 89.47,55.94 89.93,55.94 89.94,55.94 90.81,55.94 90.85,55.94 90.85,55.98 91.08,56.2 91.44,56.2 91.87,55.77 91.87,55.27 91.71,55.11 91.48,55.11 91.34,54.97 91.34,54.96 91.34,54.59 91.33,54.59 91.33,54.48 91.2,54.34 89.22,54.34 88.96,54.6 88.96,54.95 88.54,55.37 87.34,55.37 87.32,55.38 87.3,55.39 87.25,55.45 87.18,55.5 87.11,55.57 82.91,55.57 82.86,55.61 82.86,55.93 82.9,56.09 82.86,56.25 82.86,56.53 82.66,56.73 81.81,56.73 81.56,56.97 81.56,58.18 81.66,58.28 82.1,58.28
GND on TOP (solid shape): 169.3,22.16 169.3,21.47 169.18,21.35 168.97,21.35 168.84,21.47 168.84,21.78 168.64,21.98 167.73,21.98 167.57,21.83 167.57,21.76 167.57,21.75 167.54,21.67 167.55,21.5 167.57,21.42 167.57,21.35 167.84,21.08 167.84,20.99 167.84,20.96 167.85,20.93 167.85,20.84 167.88,20.81 172.43,20.81 172.46,20.8 172.48,20.76 172.48,20.5 172.45,20.48 172.45,19.67 172.32,19.54 172.32,19.52 172.13,19.33 172.07,19.33 171.98,19.29 171.94,19.2 171.94,18.99 171.93,18.95 171.89,18.93 169.21,18.93 169.12,19 169.14,19.11 169.22,19.23 169.25,19.37 169.11,19.65 168.8,19.71 167.89,19.71 167.78,19.82 167.78,20.26 167.7,20.33 166.61,20.33 166.53,20.41 166.53,20.97 166.74,21.17 166.74,22.3 167.09,22.66 168.81,22.66
GND on TOP (solid shape): outline of 95 points within 50.09,51.04 53.27,53.96
GND on TOP (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,87.74 12.71,87.28 12.71,83.2 12.03,82.51 10.63,82.51 9.94,81.82 9.46,81.82 9.35,81.93 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.6 12.42,89.6
GND on TOP (solid shape): 22.01,69.96 22.01,66.36 19.29,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.9 9.38,70.93 9.71,70.93 9.82,70.83 9.82,70.27 10.15,69.94 12.91,69.94 15.66,72.68 19.29,72.68
GND on TOP (solid shape): outline of 98 points within 57.92,115.92 63.57,119.39
GND on TOP (solid shape): outline of 103 points within 155.89,34.66 162.49,38.06
GND on TOP (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 13.24,45.81 13.24,45.07 13.13,44.94 13.09,44.77 13.2,44.5 13.47,44.38 13.51,44.39 13.54,44.39 15.3,42.63 15.3,40.27 15.05,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on TOP (solid shape): 144.59,24.29 144.59,23.97 144.59,23.96 144.59,23.56 144.99,23.17 144.99,19.56 144.51,19.08 144.04,18.61 143.84,18.61 143.78,18.63 143.72,18.63 143.37,18.27 143.72,17.92 143.91,17.97 144.04,18.1 144.04,18.11 144.79,18.86 145.38,18.86 145.48,18.76 145.48,17.51 144.49,16.51 142.98,16.51 142.91,16.55 142.88,16.63 142.89,16.67 142.56,17.03 142.18,16.73 142.05,16.6 141.76,16.6 141.63,16.73 141.64,16.77 141.64,16.82 141.54,17.07 141.29,17.17 141.16,17.15 141.05,17.08 140.98,17.06 140.91,17.08 140.8,17.15 140.68,17.17 140.42,17.07 140.32,16.82 140.32,16.77 140.33,16.72 140.21,16.6 139.99,16.6 139.89,16.7 139.89,17 139.51,17.39 136.33,17.39 135.35,18.37 135.35,18.75 135.91,19.32 135.99,19.35 136.06,19.32 136.17,19.24 136.31,19.21 136.56,19.32 136.66,19.57 136.57,19.8 136.35,19.92 136.31,19.93 136.31,20.48 136.02,20.77 136.02,23.24 136.03,23.27 136.04,23.27 136.14,23.4 136.18,23.56 136.18,23.62 136.16,23.68 136.16,23.75 136.2,23.81 136.33,23.93 136.39,24.1 136.39,24.12 138.6,26.33 142.56,26.33
GND on TOP (solid shape): outline of 186 points within 46.29,26.53 54.04,30.85
GND on TOP (solid shape): outline of 278 points within 0.25,18.86 15.33,29.65
GND on TOP (solid shape): outline of 117 points within 0.25,102.5 34.22,122.97
GND on TOP (solid shape): outline of 1103 points within 78.42,63.49 81.98,80.38
GND on TOP (solid shape): outline of 1484 points within 0.25,0.25 219.55,127.75
GND on BOTTOM (solid shape): 21.14,42.15 21.14,40.63 21.02,40.5 19.11,40.5 18.73,40.88 18.73,42.15 18.83,42.25 21.04,42.25
GND on BOTTOM (solid shape): 48.73,122.59 48.73,121.12 48.53,120.92 47.28,120.92 47.05,121.14 47.05,122.67 47.23,122.85 48.47,122.85
GND on BOTTOM (solid shape): 84.02,101.7 84.26,101.46 84.26,100.32 84.14,100.19 78.8,100.19 78.67,100.32 78.67,101.46 78.93,101.71 82.51,101.71
GND on BOTTOM (solid shape): 123,119.62 123,114.54 122.74,114.29 121.35,114.29 120.84,114.79 120.84,118.5 122.08,119.75 122.87,119.75
GND on BOTTOM (solid shape): 21.14,55.36 21.14,54.93 20.86,54.65 20.86,52.26 19.59,52.26 18.98,52.87 18.98,55.49 19.11,55.61 20.89,55.61
GND on BOTTOM (solid shape): 66.23,96.13 66.23,95.74 66.1,95.62 65.34,95.62 64.96,95.24 62.93,95.24 62.8,95.36 62.8,96.25 63.05,96.51 65.85,96.51
GND on BOTTOM (solid shape): 66.74,85.97 66.74,83.25 65.89,82.41 63.8,82.41 63.49,82.72 63.49,83.24 63.21,83.53 63.21,86.78 63.28,86.85 65.85,86.85
GND on BOTTOM (solid shape): 157.08,27.75 157.08,26.83 156.91,26.66 155.13,26.66 154.87,26.91 154.87,27.29 155,27.42 156.53,27.42 156.91,27.8 157.03,27.8
GND on BOTTOM (solid shape): 109.79,20.84 107.69,18.74 107.69,17.12 107.33,16.75 105.22,16.75 104.96,17 104.96,19.59 106.36,20.99 106.36,21.7 106.74,22.08 109.79,22.08
GND on BOTTOM (solid shape): 124.27,95.49 124.27,94.22 123.76,93.71 120.61,93.71 120.61,94.32 120.33,94.6 120.33,94.68 120.2,94.8 120.2,95.69 120.38,95.87 123.89,95.87
GND on BOTTOM (solid shape): 68.13,101.33 68.13,100.95 68.51,100.57 69.2,100.57 69.4,100.37 69.4,98.16 69.28,98.03 68.64,98.03 66.99,99.68 66.99,101.33 67.12,101.46 68.01,101.46
GND on BOTTOM (solid shape): 113.22,120.64 113.22,118.73 112.61,118.12 111.59,118.12 111.44,118.27 111.44,119.87 111.31,120 111.31,120.76 111.44,120.89 112.96,120.89
GND on BOTTOM (solid shape): 130.17,78.18 130.17,77.62 129.78,77.23 126.86,77.23 126.85,77.21 126.72,77.21 126.6,77.33 126.6,77.71 126.71,77.81 128.81,77.81 129.42,78.42 129.93,78.42
GND on BOTTOM (solid shape): 46.24,113.52 46.24,112.2 46.14,112.1 44.51,112.1 44.31,112.3 44.31,113.12 44.21,113.22 43.6,113.22 43.5,113.32 43.5,113.52 43.6,113.63 46.14,113.63
GND on BOTTOM (solid shape): 88.2,84.19 88.2,82.16 87.95,81.9 87.18,81.9 86.93,82.16 86.93,84.19 87.18,84.44 87.95,84.44
GND on BOTTOM (solid shape): 90.87,84.19 90.87,82.16 90.61,81.9 89.85,81.9 89.6,82.16 89.6,84.19 89.85,84.44 90.61,84.44
GND on BOTTOM (solid shape): 97.65,79.69 97.65,78.42 97.48,78.25 97.45,78.23 97.43,78.22 97.27,78.22 96.38,79.11 95.72,79.11 95.59,79.24 95.59,79.51 96.33,80.25 97.09,80.25
GND on BOTTOM (solid shape): 23.23,115.2 23.28,115.2 23.81,114.67 23.94,114.67 23.94,113.91 23.05,113.02 22.16,113.02 21.02,114.16 18.6,114.16 16.44,112 16.06,112 15.17,112.89 15.17,113.91 16.83,115.56 22.87,115.56
GND on BOTTOM (solid shape): 192.04,10.91 196.61,10.91 196.91,11.21 197.72,11.21 197.93,11.01 197.93,9.87 197.91,9.84 197.88,9.82 189.26,9.82 189.19,9.89 189.19,10.81 189.8,11.42 191.53,11.42
GND on BOTTOM (solid shape): 38.64,120.18 38.64,119.57 38.92,119.29 39.86,119.29 39.94,119.21 39.94,117.46 39.56,117.08 36,117.08 35.62,117.46 35.62,119.62 35.88,119.87 37.5,119.87 37.86,120.23 38.59,120.23
GND on BOTTOM (solid shape): 118.43,125.72 118.43,123.94 117.41,122.92 117.41,122.39 117,121.98 117,120.22 116.93,120.14 116.64,120.14 116.55,120.23 116.55,123.33 116.65,123.43 116.65,125.59 116.9,125.84 118.3,125.84
GND on BOTTOM (solid shape): 97.59,36.55 97.7,36.55 97.98,36.27 97.98,35.42 97.09,34.53 96.96,34.53 96.75,34.74 96.75,35 96.58,35.17 96.58,36.18 96.84,36.44 96.84,37.07 96.87,37.1 97.03,37.1
GND on BOTTOM (solid shape): 108.14,120.64 108.14,119.87 108.39,119.62 109.13,119.62 109.41,119.34 109.41,117.51 109.08,117.18 107.4,117.18 107,117.59 107,120.84 107.01,120.88 107.05,120.89 107.88,120.89
GND on BOTTOM (solid shape): 142.84,73.98 142.84,71.94 142.53,71.64 141.81,71.64 141.74,71.67 141.54,71.87 141.54,72.5 141.36,72.68 137.55,72.68 137.32,72.91 137.3,72.91 137.12,73.09 137.12,73.98 137.37,74.23 142.58,74.23
GND on BOTTOM (solid shape): 89.24,119.16 89.63,119.06 90.02,118.99 90.28,118.73 90.28,118.55 92.52,116.32 92.52,112.25 92.26,112 90.61,112 90.23,112.38 90.23,116.32 89.72,116.83 88.2,116.83 87.95,117.08 87.95,118.99 88.12,119.16
GND on BOTTOM (solid shape): 128.46,31.46 128.46,29.42 128.66,29.22 128.97,29.22 129.3,28.89 129.3,28.43 129.17,28.31 128.66,28.31 128.51,28.15 127.25,28.15 126.97,28.43 125.79,28.43 125.66,28.56 125.66,30.97 125.76,31.07 126.02,31.07 126.7,31.74 128.18,31.74
GND on BOTTOM (solid shape): 102.47,29.81 102.47,28.18 102.38,28.1 102.32,28 101.67,27.35 101.5,27.35 101.41,27.44 101.41,28.1 101.05,28.46 101.05,28.97 100.85,29.17 100.6,29.17 100.21,29.55 100.21,29.78 100.37,29.93 102.35,29.93
GND on BOTTOM (solid shape): 92.98,22.03 93.43,22.03 93.64,22.24 93.89,22.24 94.25,21.88 94.25,18.73 94.55,18.43 94.55,15.28 94.8,15.02 94.8,14.26 94.55,14.01 93.84,14.01 93.64,14.21 93.64,14.62 93.94,14.92 93.94,18.02 93.43,18.53 93.43,20.97 93.18,21.22 92.57,21.22 92.42,21.37 92.42,22.29 92.72,22.29
GND on BOTTOM (solid shape): 49.73,16.58 49.73,15.67 49.74,15.66 49.74,15.61 50,15.35 53.22,15.35 53.4,15.18 53.4,14.18 53.39,14.15 53.35,14.13 49.06,14.13 48.83,14.36 48.83,15.23 48.83,15.28 47.94,16.17 47.94,16.75 48.04,16.85 49.46,16.85
GND on BOTTOM (solid shape): 109.66,33.51 109.66,33.41 109.66,31.84 108.8,30.97 108.8,29.96 108.6,29.75 107.83,29.75 107.63,29.96 107.63,30.75 107.05,31.33 107.05,32.12 106.74,32.42 106.29,32.42 106.03,32.68 106.03,32.7 106.01,32.82 105.95,32.92 105.95,33.59 106.01,33.64 109.54,33.64
GND on BOTTOM (solid shape): 123.25,38.47 123.25,37.07 123.89,36.44 124.67,36.44 124.88,36.23 124.88,35.39 124.78,35.29 123.63,35.29 122.68,36.25 122.67,36.26 122.62,36.34 122.54,36.39 122.53,36.4 122.24,36.69 122.24,37.45 122.11,37.58 121.73,37.58 121.6,37.71 121.6,38.09 121.85,38.34 122.24,38.34 122.49,38.59 123.12,38.59
GND on BOTTOM (solid shape): 158.43,37.71 158.43,37.3 158.33,37.2 158.33,36.8 158.31,36.73 158.3,36.66 158.31,36.6 158.33,36.53 158.33,36.38 158.13,36.18 156.12,36.18 156.06,36.24 156.06,36.41 156.07,36.46 156.07,36.51 156.07,36.56 156.06,36.61 156.06,36.7 155.89,36.87 155.89,37.71 156.14,37.96 158.18,37.96
GND on BOTTOM (solid shape): 59.6,125.16 59.63,125.15 59.78,124.9 60.02,124.81 60.1,124.82 60.12,124.81 61.12,123.81 61.12,123.43 61.96,122.59 61.96,117.98 61.38,117.4 58.65,117.4 57.26,118.78 57.26,123.02 56.72,123.57 51.36,123.57 51.27,123.66 51.27,124.88 51.55,125.16
GND on BOTTOM (solid shape): 117.16,42 117.16,41.46 117.12,41.45 116.88,41.11 117.12,40.77 117.16,40.76 117.16,39.69 116.93,39.69 116.93,40.5 116.75,40.68 115.48,40.68 115.28,40.88 115.28,41.87 115.56,42.15 117,42.15
GND on BOTTOM (solid shape): 109.92,125.46 109.92,122.41 109.54,122.03 105.73,122.03 105.47,122.29 105.47,123.64 105.48,123.68 105.51,123.69 105.8,124.07 105.51,124.44 105.48,124.45 105.47,124.49 105.47,125.46 105.85,125.84 109.54,125.84
GND on BOTTOM (solid shape): 143.93,39.41 143.93,38.9 143.19,38.16 143.19,37.6 143.1,37.51 138.5,37.51 138.31,37.71 138.31,38.29 138.42,38.39 138.67,38.39 139.51,39.23 139.62,39.23 139.66,39.21 139.67,39.2 139.71,39.16 139.77,39.15 140.19,39.15 140.27,39.08 141.9,39.08 141.91,39.09 142,39.09 142.13,39.22 142.33,39.22 142.39,39.21 142.45,39.2 142.68,39.28 142.82,39.47 142.83,39.51 143.83,39.51
GND on BOTTOM (solid shape): 102.8,79.21 102.8,77.84 104.07,76.57 106.61,76.57 107,76.95 107.76,76.95 108.11,76.59 108.11,75.46 107.78,75.13 106.55,75.13 106.34,74.92 106.34,74.28 106.08,74.03 103.5,74.03 103.25,74.28 102.68,74.28 101.7,73.3 101.38,73.3 101.28,73.41 101.28,75.37 101.28,75.38 101.28,75.67 101.28,75.68 101.28,76.14 101.28,76.14 101.28,76.43 101.28,76.44 101.28,76.82 101.15,76.95 101.15,77.28 101.18,77.28 101.69,77.78 101.69,78.78 101.18,79.29 100.49,79.29 100.39,79.39 100.39,79.87 100.52,80 102.02,80
GND on BOTTOM (solid shape): 130.9,75.81 130.93,75.79 131.06,75.48 131.33,75.37 131.34,75.37 131.39,75.36 131.44,75.35 131.48,75.34 131.48,74.36 131.23,74.1 127.75,74.1 127.6,74.26 127.6,74.74 127.9,75.04 128.16,75.04 128.17,75.04 128.3,75.02 128.43,75.04 128.44,75.04 128.54,75.04 128.54,75.05 128.85,75.05 129.08,75.27 129.08,75.63 129.25,75.81
GND on BOTTOM (solid shape): 104.24,63.74 109.79,63.74 111.69,61.84 111.69,56.76 111.78,56.67 111.78,53.03 111.44,52.69 110.81,52.69 110.68,52.56 110.42,52.56 110.3,52.69 109.28,52.69 109.15,52.56 108.9,52.56 108.77,52.69 107.76,52.69 107.63,52.56 107.38,52.56 107.25,52.69 106.49,52.69 106.26,52.92 106.26,54.36 105.44,55.18 105.01,55.18 103.95,56.25 103.82,56.37 103.82,58.65 102.83,59.65 102.8,59.65 102.46,60 102.46,60.39 103.42,61.35 103.74,61.35 104.14,61.76 104.14,62.17 104.29,62.33 104.29,62.89 103.89,63.3 103.32,63.3 103.25,63.22 102.94,63.22 102.94,63.95 103.01,64.03 103.95,64.03
GND on BOTTOM (solid shape): 70.8,125.72 70.8,125.21 70.55,124.95 69.1,124.95 69.02,124.95 68.9,124.83 68.9,124.75 68.9,123.81 68.64,123.56 68.02,123.56 67.93,123.61 67.94,123.72 67.93,124.17 67.51,124.3 67.41,124.32 67.37,124.4 67.37,125.72 67.5,125.84 70.67,125.84
GND on BOTTOM (solid shape): 23.43,73.52 27.11,73.52 27.24,73.39 27.24,70.34 27.11,70.22 23.81,70.22 22.57,71.46 23.56,71.46 23.56,71.41 23.57,71.35 23.59,71.3 23.62,71.25 23.65,71.21 23.69,71.17 23.74,71.14 23.79,71.11 23.84,71.09 23.9,71.08 23.95,71.08 24.01,71.09 24.06,71.1 24.11,71.12 24.16,71.15 24.2,71.19 24.24,71.23 24.27,71.27 24.3,71.33 24.31,71.38 24.32,71.43 24.32,71.49 24.31,71.54 24.3,71.6 24.27,71.65 24.24,71.7 24.2,71.74 24.16,71.77 24.11,71.8 24.06,71.82 24.01,71.84 23.95,71.84 23.9,71.84 23.84,71.83 23.79,71.81 23.74,71.79 23.69,71.76 23.65,71.72 23.62,71.67 23.59,71.62 23.57,71.57 23.56,71.52 23.56,71.46 22.57,71.46 21.65,72.38 21.65,73.65 22.03,74.03 22.92,74.03
GND on BOTTOM (solid shape): 139.25,43.85 139.25,42.76 139.51,42.51 141.06,42.51 141.21,42.66 141.21,42.96 141.21,42.96 141.21,43.7 141.31,43.8 141.44,43.8 141.47,43.79 141.49,43.75 141.49,42.86 141.77,42.58 142.17,42.58 142.43,42.33 142.43,42.24 142.42,42.23 142.37,42.14 142.35,42.04 142.35,42.02 142.23,41.9 140.02,41.9 139.58,41.46 139.58,41.44 139.46,41.31 139.46,40.32 139.2,40.07 138.84,40.07 138.82,40.07 138.67,40.2 138.49,40.25 138.29,40.25 138.01,40.52 137.53,40.52 137.5,40.55 137.5,42.15 138.7,43.34 138.7,43.83 138.85,43.98 139.13,43.98
GND on BOTTOM (solid shape): 207.48,15.63 209.23,15.63 209.36,15.51 209.36,13.09 209.26,12.99 207.53,12.99 207.33,12.79 207.33,12.43 207.22,12.33 206.41,12.33 206.28,12.2 205.6,12.2 205.45,12.36 205.45,12.67 205.48,12.75 205.57,12.77 205.61,12.76 205.65,12.76 206.01,13.12 205.65,13.47 205.61,13.47 205.57,13.47 205.48,13.48 205.45,13.56 205.45,15.35 205.46,15.37 205.46,15.9 205.65,16.09 207.02,16.09
GND on BOTTOM (solid shape): 81.96,43.57 81.99,43.48 82.05,43.4 82.19,43.25 82.41,43.22 82.43,43.22 82.46,43.21 82.62,43.04 82.62,42.88 82.53,42.79 82.5,42.66 82.55,42.51 82.69,42.42 82.7,42.42 82.85,42.26 82.86,42.24 82.94,42.08 83.11,41.99 83.13,41.99 83.3,41.81 83.3,39.84 83.2,39.74 82.81,39.74 82.38,40.17 82.05,40.17 81.61,40.61 81.61,42.24 81.5,42.34 81.5,42.34 81.3,42.55 81.3,43.25 81.65,43.61 81.95,43.61
GND on BOTTOM (solid shape): 46.92,22.85 47,22.85 47.89,21.96 47.89,21.02 47.13,20.26 46.11,20.26 45.88,20.48 43.62,20.48 43.62,21.27 43.47,21.42 42.28,21.42 42.15,21.55 42.15,21.8 42.25,21.9 42.25,21.98 46.67,21.98 46.67,21.93 46.69,21.87 46.71,21.82 46.73,21.77 46.77,21.73 46.81,21.69 46.85,21.66 46.9,21.63 46.96,21.61 47.01,21.6 47.07,21.6 47.12,21.61 47.18,21.62 47.23,21.64 47.27,21.67 47.32,21.71 47.35,21.75 47.39,21.8 47.41,21.85 47.42,21.9 47.43,21.95 47.43,22.01 47.42,22.07 47.41,22.12 47.39,22.17 47.35,22.22 47.32,22.26 47.27,22.29 47.23,22.32 47.18,22.34 47.12,22.36 47.07,22.36 47.01,22.36 46.96,22.35 46.9,22.33 46.85,22.31 46.81,22.28 46.77,22.24 46.73,22.19 46.71,22.14 46.69,22.09 46.67,22.04 46.67,21.98 42.25,21.98 42.25,22.24 42.05,22.44 42.05,22.44 42,22.49 42,23 42.48,23.48 46.29,23.48
GND on BOTTOM (solid shape): 75.36,112.55 75.36,111.73 75.68,111.42 76.08,111.42 76.21,111.29 76.21,110.91 76.01,110.7 76.01,110.07 75.42,109.49 75.25,109.49 75.22,109.48 75.17,109.46 75.12,109.46 74.99,109.33 74.99,109.08 74.64,108.72 72.79,108.72 72.65,108.72 72.45,108.93 72.45,108.95 72.36,109.19 72.12,109.31 72.1,109.31 72,109.41 72,109.61 72.38,109.99 72.73,110.39 72.35,110.76 72.28,110.75 72.21,110.73 72.07,110.73 71.82,110.98 71.82,111.49 71.94,111.62 72.38,111.62 72.63,111.87 74.08,111.87 74.26,112.05 74.26,112.43 74.39,112.56 75.34,112.56
GND on BOTTOM (solid shape): 127.29,43.47 127.29,43.42 127.26,43.35 127.19,43.32 127.15,43.32 127.11,43.31 127.08,43.32 127.04,43.32 126.68,42.96 127.04,42.61 127.08,42.61 127.11,42.61 127.15,42.61 127.19,42.61 127.36,42.65 127.49,42.77 127.56,42.82 127.65,42.79 128.03,42.4 128.03,41.64 127.82,41.44 125.42,41.44 125.33,41.48 125.23,41.49 125.14,41.48 125.06,41.45 125.05,41.44 124.95,41.44 124.88,41.52 124.88,43.06 124.38,43.56 124.38,43.84 124.45,43.9 126.86,43.9
GND on BOTTOM (solid shape): 76.65,125.94 76.68,125.93 77.57,124.43 79.19,123.84 81.24,123.84 81.28,123.83 81.29,123.79 81.29,121.19 80.15,120.05 79.68,120.05 79.64,120.09 79.64,121.63 79.13,122.14 79.09,122.14 76.66,122.14 75.82,121.3 75.82,118 75.74,117.92 75.11,117.92 74.85,117.67 74.85,116.53 74.59,116.27 74.59,115.71 74.46,115.58 74.03,115.58 73.98,115.63 73.98,116.55 73.98,116.73 73.9,116.8 73.76,116.91 73.59,116.95 73.46,116.93 73.35,116.86 73.34,116.85 73.28,116.85 73.1,117.03 73.1,121.32 73.71,121.93 73.71,125.57 73.71,125.59 73.73,125.6 74.06,125.94
GND on BOTTOM (solid shape): 114.23,33.64 114.23,32.96 114.23,32.95 114.23,32.72 114.18,32.59 114.18,32.44 112.96,31.23 112.96,29.32 112.84,29.2 111.92,29.2 111.82,29.3 111.82,32.36 111.86,32.45 111.87,32.55 111.87,32.57 111.9,32.65 111.98,32.68 112,32.68 112.38,33.06 112,33.44 111.92,33.43 111.84,33.41 111.64,33.28 111.57,33.06 111.57,33 111.59,32.93 111.56,32.91 111.52,32.9 111.49,32.9 111.45,32.9 111.43,32.9 111.41,32.91 111.19,33.13 111.19,33.72 111.2,33.75 111.24,33.77 114.11,33.77
GND on BOTTOM (solid shape): 54.19,21.98 54.19,21.02 53.91,20.74 53.25,20.74 52.74,20.23 52.74,19.77 52.4,19.43 50.02,19.43 49.93,19.48 49.93,19.58 49.97,19.76 49.9,19.94 49.89,20.04 49.97,20.1 50.02,20.78 49.6,20.24 49.61,20.15 49.54,20.09 49.48,20.07 49.38,20.08 49.34,20.16 49.34,21.78 49.8,22.24 52.69,22.24 52.69,22.24 53.93,22.24
GND on BOTTOM (solid shape): outline of 86 points within 26.22,19.29 30.16,22.21
GND on BOTTOM (solid shape): 80.81,96.15 80.81,95.72 80.99,95.54 81.44,95.54 81.57,95.41 81.57,95.16 82.08,94.65 82.71,94.65 82.84,94.52 82.84,92.7 82.94,92.59 82.94,92.44 83.37,92.01 83.37,90.41 83.63,90.16 85.92,90.16 85.97,90.1 86.04,90.1 86.5,89.65 86.5,88.96 86.48,88.93 86.45,88.91 82,88.91 81.47,89.44 81.47,94.4 81.44,94.4 81.19,94.65 79.94,94.65 79.84,94.55 79.72,94.55 79.49,94.78 77.79,94.78 77.61,94.6 77.61,93.25 77.53,93.18 77.53,88.53 78.17,87.9 78.17,86.52 78.83,85.86 78.83,84.54 78.7,84.42 77.86,84.42 77.81,84.47 77.81,85 77.68,85.13 76.21,85.13 75.37,85.97 75.37,86.86 75.38,86.87 76.14,88.21 76.4,89.73 76.14,91.25 75.38,92.59 75.31,92.68 75.25,92.75 75.25,93.59 76.11,94.45 76.11,94.96 76.24,95.08 76.72,95.08 77.15,95.52 77.15,95.59 77.28,95.72 79.59,95.72 80.17,96.3 80.66,96.3
GND on BOTTOM (solid shape): outline of 85 points within 77.15,100.19 91.25,108.47
GND on BOTTOM (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,84.75 12.71,84.29 12.71,83.2 12.03,82.51 10.63,82.51 9.98,81.86 9.44,81.86 9.35,81.95 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.6 12.42,89.6
GND on BOTTOM (solid shape): outline of 99 points within 34.73,4.69 43.88,10.78
GND on BOTTOM (solid shape): outline of 93 points within 114.23,32.57 117.97,38.54
GND on BOTTOM (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 13.24,45.81 13.24,45.07 13.13,44.94 13.09,44.77 13.2,44.5 13.47,44.38 13.51,44.39 13.54,44.39 15.05,42.89 15.05,41.68 15.3,41.43 15.3,40.55 14.77,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on BOTTOM (solid shape): 10.73,113.24 13.17,113.24 15.48,110.93 15.48,107.66 12.38,104.55 12.38,103.5 12.41,103.35 12.42,103.2 12.42,102.98 12.15,102.87 11.97,102.64 11.65,102.64 11.65,103.2 11.52,103.52 11.2,103.65 7.05,103.65 7.05,104.4 6.92,104.72 6.6,104.85 5.2,104.85 4.88,104.72 4.75,104.4 4.75,103.65 0.61,103.65 0.25,104.01 0.25,105.29 0.41,105.45 1.85,105.45 1.85,110.95 0.41,110.95 0.25,111.11 0.25,112.69 0.61,113.05 3.35,113.05 3.41,113.03 3.69,112.81 3.97,112.75 5.93,112.75 6.22,112.82 6.5,113.05 7.44,113.08 7.45,113.05 8.28,112.7 8.68,113.5 10.48,113.5
GND on BOTTOM (solid shape): 140.15,35.16 140.23,35.13 140.25,35.04 140.3,34.77 140.52,34.62 140.53,34.61 140.57,34.56 140.57,32.3 141.01,31.86 141.01,30.64 141.18,30.47 142.81,30.47 143.44,31.1 145.48,31.1 145.6,30.97 145.6,30.34 144.84,29.58 143.83,29.58 143.47,29.22 143.47,28 142.94,27.47 141.74,27.47 141.63,27.58 140.1,27.58 140.02,27.67 140.02,28.74 140.06,28.74 140.37,29.09 140.06,29.45 140.02,29.45 140.02,30.11 140.19,30.29 140.19,30.96 140.38,31.14 140.49,31.27 140.42,31.68 140.17,31.79 140.12,31.79 140.1,31.8 138.96,31.8 138.89,31.72 138.48,31.72 138.34,31.86 138.34,32.33 138.55,32.54 138.56,32.54 138.73,32.68 138.8,32.88 138.69,33.13 138.44,33.24 138.32,33.22 138.22,33.16 138.18,33.14 138.15,33.16 138.08,33.21 138,33.24 137.98,33.26 137.98,33.9 137.86,34.02 136.51,34.02 136.38,34.15 136.38,34.56 136.41,34.58 137.04,34.58 137.3,34.83 137.3,34.99 137.48,35.16
GND on BOTTOM (solid shape): outline of 144 points within 102.28,67.93 124.67,87.41
GND on BOTTOM (solid shape): outline of 123 points within 72.73,33.69 76.64,36.52
GND on BOTTOM (solid shape): outline of 104 points within 114.74,56.99 136.87,69.96
GND on BOTTOM (solid shape): 17,72.62 21.74,69.59 19.82,64.31 19.73,64.26 19.73,64.25 19.12,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.85 9.41,70.9 9.76,70.9 9.82,70.85 9.82,70.27 10.15,69.94 12.91,69.94 15.58,72.6 17,72.6
GND on BOTTOM (solid shape): outline of 217 points within 13.9,7.79 22.53,14.34
GND on BOTTOM (solid shape): outline of 194 points within 169.61,18.83 174.36,25.49
GND on BOTTOM (solid shape): outline of 278 points within 0.25,18.86 15.33,29.65
GND on BOTTOM (solid shape): outline of 108 points within 92.11,46.65 95.56,50.31
GND on BOTTOM (solid shape): outline of 255 points within 209.03,20.81 212.48,23.28
GND on BOTTOM (solid shape): outline of 113 points within 82.05,73.96 85.54,78.4
GND on BOTTOM (solid shape): outline of 310 points within 94.99,51.91 97.11,59.61
GND on BOTTOM (solid shape): outline of 392 points within 105.22,44.44 131.84,52.06
GND on BOTTOM (solid shape): outline of 156 points within 77.97,52.15 80.39,59.15
GND on BOTTOM (solid shape): outline of 1507 points within 0.25,0.25 219.55,127.75
GND on BOTTOM (solid shape): outline of 2020 points within 74.83,47.73 80.58,72.64
GND on BOTTOM (solid shape): outline of 2915 points within 74.53,59.44 83.28,80.07
GND on SGND (solid shape): outline of 3339 points within 0.25,0.25 219.55,127.75
GND on IN1 (solid shape): 80.78,28.99 77.23,28.99 77.23,30.62 80.78,30.62
GND on IN1 (solid shape): 46.24,113.52 46.24,112.2 46.14,112.1 44.51,112.1 44.31,112.3 44.31,113.12 44.21,113.22 43.6,113.22 43.5,113.32 43.5,113.52 43.6,113.63 46.14,113.63
GND on IN1 (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,87.74 12.71,87.28 12.71,83.2 12.03,82.51 10.63,82.51 9.97,81.85 9.43,81.85 9.35,81.93 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.62 12.42,89.62
GND on IN1 (solid shape): 19.2,72.61 21.27,70.54 21.27,70.29 21.57,69.99 21.57,69.66 21.85,69.38 21.85,66.35 20.72,65.22 20.72,65.07 19.29,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.82 9.46,70.93 9.71,70.93 9.82,70.83 9.82,70.27 10.15,69.94 12.91,69.94 15.66,72.68 19.2,72.68
GND on IN1 (solid shape): 10.73,113.24 13.17,113.24 15.48,110.93 15.48,107.4 12.38,104.3 12.38,103.5 12.41,103.35 12.42,103.2 12.42,102.5 11.65,102.5 11.65,103.2 11.52,103.52 11.2,103.65 7.05,103.65 7.05,104.4 6.92,104.72 6.6,104.85 5.2,104.85 4.88,104.72 4.75,104.4 4.75,103.65 0.61,103.65 0.25,104.01 0.25,105.29 0.41,105.45 1.85,105.45 1.85,110.95 0.41,110.95 0.25,111.11 0.25,112.69 0.61,113.05 3.35,113.05 3.41,113.03 3.69,112.81 3.97,112.75 5.93,112.75 6.22,112.82 6.5,113.05 7.44,113.08 7.45,113.05 8.19,112.67 8.7,113.33 8.79,113.41 10.56,113.41
GND on IN1 (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 13.24,45.81 13.24,45.07 13.13,44.94 13.09,44.77 13.2,44.5 13.47,44.38 13.51,44.39 13.54,44.39 15.3,42.63 15.3,40.27 15.05,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on IN1 (solid shape): outline of 278 points within 0.25,18.86 15.33,29.65
GND on IN1 (solid shape): outline of 1507 points within 0.25,0.25 219.55,127.75
GND on IN2 (solid shape): 80.78,30.62 80.78,28.99 77.23,28.99 77.23,30.62 77.33,30.73 80.68,30.73
GND on IN2 (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,87.74 12.71,87.28 12.71,83.2 12.03,82.51 10.63,82.51 9.97,81.85 9.43,81.85 9.35,81.93 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.6 12.42,89.6
GND on IN2 (solid shape): 22.01,69.96 22.01,66.36 19.29,63.64 16.11,63.64 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.8 9.49,70.93 9.74,70.93 9.82,70.85 9.82,70.27 10.15,69.94 12.91,69.94 15.66,72.68 19.29,72.68
GND on IN2 (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 13.24,45.81 13.24,45.07 13.13,44.94 13.09,44.77 13.2,44.5 13.47,44.38 13.51,44.39 13.54,44.39 15.3,42.63 15.3,40.27 15.05,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on IN2 (solid shape): 10.37,113.92 10.43,113.83 10.43,113.55 10.73,113.24 13.17,113.24 15.48,110.93 15.48,107.4 12.38,104.3 12.38,103.5 12.41,103.35 12.42,103.2 12.42,102.5 11.65,102.5 11.65,103.2 11.52,103.52 11.2,103.65 7.05,103.65 7.05,104.4 6.92,104.72 6.6,104.85 5.2,104.85 4.88,104.72 4.75,104.4 4.75,103.65 0.61,103.65 0.25,104.01 0.25,105.29 0.41,105.45 1.85,105.45 1.85,110.95 0.41,110.95 0.25,111.11 0.25,112.69 0.61,113.05 3.35,113.05 3.41,113.03 3.69,112.81 3.97,112.75 5.93,112.75 6.22,112.82 6.5,113.05 7.44,113.08 7.45,113.05 8.34,112.73 8.62,113.64 8.62,113.75 8.72,113.79 8.78,113.78 8.84,113.78 9.86,113.78 10.07,113.81 10.26,113.91
GND on IN2 (solid shape): outline of 278 points within 0.25,18.86 15.33,29.65
GND on IN2 (solid shape): outline of 383 points within 72.71,33.5 79.26,48.58
GND on IN2 (solid shape): outline of 1532 points within 0.25,0.25 219.55,127.75
GND on IN2 (solid shape): outline of 28664 points within 29.02,31.74 82.48,97.78
GND on SVCC (solid shape): 218.28,51.43 217.55,50.87 217.28,50 217.28,48.84 216.87,48.43 216.82,48.41 216.77,48.37 216.32,48.37 215.96,48.73 215.96,49.64 215.94,49.74 215.89,49.82 215.38,50.33 215.3,50.39 215.2,50.41 212.89,50.41 212.79,50.51 212.79,50.79 212.78,50.84 214.4,53.59 215.76,56.48 218.28,56.48
GND on SVCC (solid shape): 7.57,46.12 8.17,45.67 8.9,45.52 10.42,45.52 11.04,45.15 11.75,45.02 11.75,43.86 11.04,43.73 10.42,43.36 8.9,43.36 8.17,43.21 7.57,42.76 4.64,42.76 4.26,43.14 4.26,45.63 4.75,46.12
GND on SVCC (solid shape): 123.18,126.4 123.77,124.97 125.2,124.38 131.21,124.38 132.63,124.97 133.22,126.4 133.22,126.48 143.48,126.48 143.48,124.8 143.01,125.04 142.5,125.13 140.87,123.5 142.5,121.87 143.01,121.96 143.48,122.2 143.48,81.78 143.21,81.52 142.1,81.52 142.02,81.56 141.92,81.57 141.83,81.56 141.74,81.52 141.58,81.52 141.24,81.77 140.89,81.52 126.41,81.52 123.51,84.42 123.51,85.58 123.49,85.68 123.43,85.76 121.02,88.18 120.94,88.23 120.84,88.25 111.55,88.25 110.04,89.75 110.04,91.05 110.02,91.14 109.97,91.22 107.95,93.24 107.86,93.44 107.66,93.53 106.62,94.58 106.62,96.29 107.08,96.76 109.54,96.76 109.63,96.78 109.72,96.83 110.1,97.22 110.15,97.3 110.17,97.4 110.17,114.05 114.92,118.81 114.98,118.89 115,118.99 115,125.86 115.61,126.48 123.18,126.48
GND on SVCC (solid shape): outline of 233 points within 25.08,34.28 85.41,96.38
GND on IN3 (solid shape): 80.78,29.14 80.63,28.99 77.23,28.99 77.23,30.6 80.78,30.6
GND on IN3 (solid shape): 46.24,113.52 46.24,112.2 46.14,112.1 44.51,112.1 44.31,112.3 44.31,113.12 44.21,113.22 43.6,113.22 43.5,113.32 43.5,113.52 43.6,113.63 46.14,113.63
GND on IN3 (solid shape): 12.42,89.2 12.37,88.88 12.25,88.59 12.25,87.74 12.71,87.28 12.71,83.2 12.03,82.51 10.63,82.51 9.94,81.82 9.51,81.82 9.35,81.98 9.35,83.9 8.33,85.05 7.07,84.15 2.11,84.15 1.75,84.51 1.75,87.15 0.25,87.15 0.25,88.4 0.61,88.75 4.75,88.75 4.75,88 4.88,87.68 5.2,87.55 6.6,87.55 6.92,87.68 7.05,88 7.05,88.75 11.2,88.75 11.52,88.88 11.65,89.2 11.65,89.6 12.42,89.6
GND on IN3 (solid shape): 21.53,69.8 21.59,69.64 21.64,69.47 21.64,66.83 21.61,66.74 21.58,66.65 18.98,64.05 18.7,63.95 18.4,63.88 16.36,63.88 15.3,62.83 15.3,60.54 14.82,60.06 13.67,60.06 13.27,59.65 13.27,59.24 12.5,59.24 12.5,61.84 11.88,62.58 11.04,62.09 8.9,62.09 8.54,61.95 8.4,61.59 8.4,61.49 2.21,61.49 1.85,61.85 1.85,67.89 2.21,68.25 7.07,68.25 8.33,67.35 9.35,68.5 9.35,70.85 9.46,70.95 9.74,70.95 9.82,70.88 9.82,70.27 10.15,69.94 13.58,69.94 15.65,72.01 19.31,72.01
GND on IN3 (solid shape): 10.73,113.24 13.17,113.24 15.48,110.93 15.48,107.4 12.38,104.3 12.38,103.5 12.41,103.35 12.42,103.2 12.42,102.5 11.65,102.5 11.65,103.2 11.52,103.52 11.2,103.65 7.05,103.65 7.05,104.4 6.92,104.72 6.6,104.85 5.2,104.85 4.88,104.72 4.75,104.4 4.75,103.65 0.61,103.65 0.25,104.01 0.25,105.29 0.41,105.45 1.85,105.45 1.85,110.95 0.41,110.95 0.25,111.11 0.25,112.69 0.61,113.05 3.35,113.05 3.41,113.03 3.69,112.81 3.97,112.75 5.93,112.75 6.22,112.82 6.5,113.05 7.44,113.08 7.45,113.05 8.19,112.67 8.7,113.33 8.89,113.51 10.46,113.51
GND on IN3 (solid shape): 13.27,49.39 14.08,48.58 14.72,48.58 15.07,48.22 15.07,47.64 13.24,45.81 13.24,45.07 13.13,44.94 13.09,44.77 13.2,44.5 13.47,44.38 13.51,44.39 13.54,44.39 15.3,42.63 15.3,40.27 15.05,40.02 13.54,40.02 13.27,39.74 13.27,39.25 12.5,39.25 12.5,41.84 11.88,42.58 11.04,42.09 8.9,42.09 8.54,41.95 8.4,41.59 8.4,41.49 3.35,41.49 2.99,41.85 2.99,47.03 3.35,47.39 8.4,47.39 8.4,47.29 8.54,46.93 8.9,46.79 11.04,46.79 11.88,46.3 12.5,47.04 12.5,49.62 13.27,49.62
GND on IN3 (solid shape): outline of 278 points within 0.25,18.86 15.33,29.65
GND on IN3 (solid shape): outline of 1517 points within 0.25,0.25 219.55,127.75
GND on SGND1 (solid shape): outline of 2581 points within 0.25,0.25 219.55,127.75
VCC1_CORE on BOTTOM (solid shape): 116.11,69.2 116.11,68.36 116.37,68.11 117.44,68.11 117.82,68.49 118.1,68.49 118.1,67.52 117.92,67.52 117.82,67.42 116.27,67.42 116.14,67.3 115.4,67.3 115.15,67.55 115.15,69.23 115.2,69.28 116.04,69.28
VCC_GT on BOTTOM (solid shape): 130,79.23 131.36,79.23 131.41,79.18 131.41,78.45 131.21,78.26 130.3,78.26 129.98,78.57 129.32,78.57 128.92,78.17 128.65,78.17 128.62,78.18 128.6,78.22 128.6,79.15 128.71,79.26 129.98,79.26
VCCAMPHYPLL_1P05 on TOP (solid shape): 100.09,45.43 100.12,45.41 100.14,45.37 100.14,45.15 100.48,44.8 100.48,44.27 100.39,44.18 100.14,44.18 99.58,44.74 98.46,44.74 98.18,44.46 98.03,44.46 97.9,44.59 97.9,45.37 97.92,45.41 97.95,45.43
VCCAPLL_1.05V on TOP (solid shape): outline of 703 points within 87.41,42.79 101.03,49.13
VCCDPHY_1P24 on BOTTOM (solid shape): 82.41,35.19 82.41,34.63 82.08,34.3 82.08,32.57 82.13,32.52 82.13,31.81 82.23,31.71 82.23,31.02 82.15,30.95 82.15,29.55 81.98,29.37 81.75,29.37 81.67,29.46 81.67,31.02 81.52,31.16 81.52,33.11 81.8,33.39 81.8,33.4 81.91,33.52 81.91,34.42 81.85,34.48 81.9,34.53 81.9,35.14 82.05,35.29 82.31,35.29
