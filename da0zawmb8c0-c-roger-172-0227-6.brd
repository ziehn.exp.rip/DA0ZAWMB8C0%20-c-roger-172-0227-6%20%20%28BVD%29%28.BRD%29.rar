# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1V8_GFX_MAIN: length 114.5
  TOP w0.254: L4.1 105.99,99.28 v2(105.6,98.89)
  TOP w0.356: C402.1 102.99,109.4 v2(102.99,109.99) ; v2(102.13,109.95) 101.67,109.49 R299.2
  TOP w0.381: C362.1 109.14,109.47 v2(109.64,109.97) ; C395.1 101.61,110.47 v2(102.13,109.95) ; C399.1 110.25,110.09 v2(110.42,109.91)
  TOP w0.508: PR9085.1 74.23,115.82 73.59,116.45 v1(73.59,116.57) ; 88.7,104.98 C392.1 88.7,102.29 L5.1 88.84,101.96 89.46,101.34 L6.1 ; 88.7,104.98 89.5,104.98 ; 88.7,104.98 87.68,106 L7.1 L8.1
  IN3 w1.016: 73.98,117.59 75.47,119.09 80.53,119.09 81.87,120.43 88.03,120.43 89,119.45 92.78,119.45 94.45,121.12 94.45,122.69 95.72,123.96 99.73,123.96 101.1,125.34 106.41,125.34 107.81,123.94 110.09,123.94 110.55,124.4 113.63,124.4 115.07,122.95 115.07,117.59 114.31,116.83 ; 24.12,103.29 24.93,103.29 25.44,103.79 25.44,104.79 26.43,105.78 37.78,105.78 41.13,109.12 46.21,109.12 46.91,109.83 51.87,109.83 52.64,110.6 52.64,111.87 54.67,113.91
  BOTTOM w0.305: U8.AF27 115.73,113.67 v2(115.34,114.06) ; v2(110.42,109.91) 110.8,109.53 U8.AA21 110.84,109.53 111.63,110.32 U8.AB22 ; U8.AE25 v2(114.53,113.23) U8.AF26 ; v2(112.06,111.6) U8.AC23 ; v2(112.91,112.45) U8.AD24
  BOTTOM w0.356: v2(102.99,109.99) U8.AA12 ; v2(102.13,109.95) 101.77,109.59 U8.AA10
  BOTTOM w0.381: U8.AA16 107.46,109.59 v2(107.94,110.07) 108.35,109.66 U8.AA18 U8.AA19 109.26,109.59 v2(109.64,109.97) 109.99,109.62 U8.AA20 ; U8.AA13 104.19,109.6 v2(103.82,109.97)
  vias: v1(23.43,103.36) v1(23.73,102.78) v1(23.94,103.75) v1(118.04,117.21) v1(119.06,117.21) v1(119.7,117.21) v2(99.25,98.79) v2(99.66,98.31)
+1V8_MAIN_EN_G: length 7.3
  TOP w0.508: PQ9084.2 124.41,120.88 123.81,121.47 122.74,121.47 122.02,122.2 PQ9083.3 v1(121.04,122.8) 120.55,123.29 PR9104.1 PR9102.2
+1V_S5_ON: length 93.2
  TOP w0.102: v2(197.75,27.74) 197.79,27.78 U37.95
  IN2 w0.089: v1(122.41,40.73) 122.72,40.73 123.2,40.25 124.57,40.25 125.66,39.15 132.77,39.15 137.29,43.67 140.3,43.67 142.33,41.65 142.86,41.65 143.68,40.82 143.68,40.28 147.11,36.85 147.11,36.28 147.41,35.98 148.3,35.98 148.62,35.65 153.24,35.65 153.52,35.37 155.79,35.37 156.64,36.23 159.38,36.23 160.05,35.55 162.71,35.55 163.57,34.7 164.44,34.7 164.79,34.35 164.79,34.29 165.41,33.67 166.79,33.67 167.04,33.92 179.15,33.92 179.68,33.39 180.02,33.39 180.12,33.29 180.12,32.78 180.34,32.56 180.69,32.56 180.87,32.74 182.46,32.74 182.85,33.13 185.16,33.13 185.59,32.7 187.34,32.7 188.11,33.46 190.71,33.46 191.75,32.43 195.17,32.43 195.79,33.06 v2(195.79,33.44)
  IN3 w0.089: v2(197.75,27.74) 197.45,28.04 196.99,28.04 196.65,28.38 196.65,29.09 195.79,29.94 v2(195.79,33.44)
  BOTTOM w0.203: v1(122.41,40.73) 121.96,41.18 PR274.2
+1V_SUS: length 48.4
  TOP w0.203: PR7102.2 136.98,59.46 137.4,59.88 137.4,60.62 138.47,61.68 141.01,61.68 141.85,62.52 v2(142.45,62.52)
  IN1 w0.203: v2(142.45,62.52) 142.54,62.52 143.93,61.12 143.93,59.85 144.34,59.45 144.34,58.03 144.87,57.49 144.87,57.41 144.95,57.33 144.95,55.29 144.03,54.37 142.86,54.37 141.67,53.17 138.29,53.17 137.76,52.64 137.76,51.95 135.95,50.15 134.55,50.15 133.92,50.79 131.63,50.79 130.11,49.26 127.6,49.26 124.75,52.11 121.32,52.11 120.84,51.62 119.52,51.62 119.14,51.24 119.14,50.33 119.65,49.82 119.65,49.69 v2(119.77,49.57)
  vias: v1(113.7,42.79)
+2.5V_SUS: length 212.6
  TOP w0.254: U5.R9 34.89,51.43 34.17,50.71 ; 34.07,85.33 34.89,86.16 U6.R9 ; 34.17,72.14 34.89,72.86 U7.R9
  TOP w0.356: U4.B1 46.3,45.51 46.72,45.51 ; U5.B1 45.47,58.09 45.83,58.45 ; U7.B1 45.47,80.7 47.06,82.29 C283.2 ; U4.R9 35.07,38.04 34.86,37.83 ; U6.B1 48.47,95.56 C284.2
  TOP w0.508: 34.17,72.14 32.84,72.14 32.31,71.6 30.94,71.6 C346.2 C345.1 30.55,69.99 30.08,69.52 v1(29.79,69.52) ; v1(28.38,81.27) 28.38,81.55 28.76,81.93 28.76,82.53 C334.1 C341.1 30.11,82.58 31.34,83.81 31.66,83.81 33.18,85.33 34.07,85.33 ; 34.86,37.83 32.95,35.93 31.8,35.93 C344.1 C330.1 C281.2 33.33,34.92 33.84,34.4 ; 47.43,57.95 46.92,58.45 45.83,58.45 ; 34.17,50.71 33.72,50.71 33.64,50.79 32.23,50.79 31.62,50.18 30.78,50.18 C282.2 C333.1 C329.1 30.55,48.12 30.04,47.61 v1(28.94,47.61) ; 52.51,96.38 51.88,95.74 50.99,95.74 50.62,96.12 C335.1 C331.1 C284.2 ; 47.89,84.19 48.06,84.02 C332.1 C283.2
  TOP w1.016: 52.51,96.38 53.4,95.49 53.66,95.49 54.39,94.75 ; 35.49,33.01 36.39,33.9 45.99,33.9 46.61,34.52 46.61,36.45 47.94,37.78 47.94,43.42 47.56,43.8 47.56,44.66 46.72,45.51 46.72,46.95 47.46,47.69 47.46,49.16 47.56,49.26 47.56,51.42 47.28,51.7 47.28,53.82 47.81,54.36 47.81,57.57 47.43,57.95 ; 54.39,94.75 54.88,95.24 57.95,95.24 59.35,96.63 64.7,96.63 65.97,97.9 65.97,100.95 67.24,102.22 ; 54.39,94.75 54.37,94.73 54.37,93.86 54.39,93.84 54.39,92.78 53.67,92.06 48.83,92.06 47.89,91.12 47.89,84.19
  BOTTOM w0.508: 28,47.74 28.13,47.61 v1(28.94,47.61) ; v1(29.79,69.52) 29.22,68.95 28,68.95
  BOTTOM w1.016: 27.87,87.87 29.02,86.73 29.02,83.43 28.38,82.79 v1(28.38,81.27) 28.59,81.06 28.59,73.6 28,73.01 28,69.58 28,68.95 28,64.5 28.64,63.87 28.64,62.98 28,62.34 28,47.74 28,38.95 32.55,34.4 33.59,34.4 ; 30.44,99.45 30.67,99.22 30.67,99.17 31.3,98.54 39.05,98.54 39.53,99.02 49.61,99.02 50.84,97.8 51.64,97.8
  vias: v1(28.28,99.81) v1(29.22,27.55) v1(29.22,25.61) v1(29.58,27.01) v1(33.72,33.51) v1(34.48,33.51) v1(49.97,27.11) v1(50.61,27.09) v1(51.5,97.52) v1(52.13,97.52) v1(54.09,30.01) v1(69.66,117.66) v1(70.29,117.66) v2(67.63,103.59) v2(67.78,103.01)
+3V: length 331.1
  TOP w0.203: v2(202.12,16.47) 202.17,16.42 202.17,16.09 202.09,16.01 R340.2 ; PR186.1 32.37,26.05 33.06,26.73 v2(33.06,27.01) ; v1(45.78,28.43) 45.68,28.33 45.68,27.82 45.4,27.55 45.4,25.89 45.16,25.65 42.42,25.65 42.2,25.87 42.2,26.41 PR9255.1 ; R439.1 52.36,108.3 v2(52.39,108.33) ; R385.2 100.74,122.95 101.03,122.67 v1(101.03,122.29) ; R25367.2 58.6,111.12 58.76,110.96 R440.1 60.16,110.96 61,110.12 v1(61,110.07) ; C280.1 55.52,31.73 55.56,31.76 C278.1 55.94,31.23 55.38,30.67 v1(55.38,30.54) ; Q3.5 69.39,17.51 69.63,17.27 R114.1 ; v2(169.3,28.69) 169,28.38 169,25.31 PR6416.1 ; R25372.1 179.37,27.66 v2(179.28,27.57) 179.13,27.42 179.13,27.1 R25307.1 ; R94.2 82.08,28.08 v2(81.8,27.8) ; v2(181.16,32.17) 181.16,31.99 181.11,31.94 181.11,31.69 181.35,31.45 R25502.2 ; R120.2 77.88,23.32 77.72,23.48 v2(77.46,23.48) ; v2(74.84,106.46) 74.74,106.36 74.74,106.13 74.51,105.9 PR9009.1 ; R25312.2 172.01,28.31 172.22,28.51 R576.2 172.66,27.95 172.4,27.7 v2(171.97,27.7)
  TOP w0.254: Q41.2 24.32,65.9 v1(24.7,66.28) ; U23.18 20.02,75.44 19.81,75.23 18.8,75.23 C618.2 18.69,74.71 19.57,74.71 v1(19.62,74.66) ; U23.22 22.02,75.31 ; v2(92.59,30.8) 92.75,30.8 93.09,30.45 93.09,29.26 93.79,28.56 93.79,26.61 93.61,26.43 v1(93.61,25.11) ; v1(24.32,61.33) Q41.5
  TOP w0.305: R100.2 81.09,26.28 v1(80.83,26.02) 81.09,25.77 R96.1 ; R179.2 78.13,25 77.76,25.36 77.76,25.41 v2(77.53,25.64)
  TOP w0.356: 66.66,19.01 66.15,18.5 66.15,17.79 66.43,17.51 Q3.2 Q3.5
  TOP w0.381: R25482.1 79,23.54 R25429.1 78.46,23.85 v2(77.86,24.45) ; v2(77.46,23.48) 77.28,23.66 R25428.1 ; v2(92.29,25.18) 92.01,25.46 R25475.1 ; v1(94.5,22.39) 97.09,22.39 97.74,23.04 101.8,23.04 103.31,24.55 v1(103.31,25.03) ; R25444.2 59.62,98.41 59.82,98.6 Q6531.2 61.13,97.97 R25445.2 63.88,97.97 64.04,98.13 v1(64.07,98.13) ; R386.2 85.53,95.12 v1(85.15,94.74) ; R25271.2 60.33,109.59 60.71,109.97 60.89,109.97 v1(61,110.07)
  TOP w0.508: v2(89.29,26.66) 89.29,26.96 89.13,27.12 R212.2 ; v1(54.42,26.78) 54.42,25.64 54.04,25.26 R582.1 ; v1(45.78,28.43) 45.41,28.81 45.41,29.68 45.38,29.71 45.38,30.87 45.6,31.1 R226.1 46.41,32.65 46.67,32.91 46.67,33.01 R225.1 47.64,34.57 47.64,36.02 50.61,38.99 50.61,42.19 48.58,44.22 48.58,45.09 47.81,45.85 47.81,46.6 48.58,47.37 48.58,51.84 48.3,52.12 48.3,53.45 48.75,53.91 49.01,53.91 49.69,54.6 R227.1 ; v1(101.03,122.29) 99.38,122.29 99.06,121.97 98.68,121.97 98.26,121.55 97.27,121.55 96.91,121.19 96.91,120.89 95.82,119.79 95.82,114.03 94.23,112.44 93.47,112.44 92.52,111.49 91.37,111.49 v1(88.71,108.83) ; 148.27,22.18 149.91,23.82 149.91,24.73 PR9245.2 ; R638.2 126.67,16.66 v2(126.93,16.93) ; v2(139.48,16.85) 136.1,16.85 134.84,18.11 R25348.2 ; v1(24.7,66.28) 24.4,66.28 23.96,66.72 23.96,68.11 24.42,68.57 C1692.1
  IN1 w0.508: v1(53.29,28.94) 53.17,28.82 53.17,27.93 54.32,26.78 v1(54.42,26.78) ; v1(60.56,112.71) 60.67,112.71 61.81,113.85 61.81,115.91 61.17,116.55 61.17,117.23 61.43,117.49 61.43,122.64 63.38,124.6 v1(63.38,124.62) ; v2(203.52,12.13) 203.52,12.43 203.29,12.66 203.29,15.91 202.73,16.47 v2(202.12,16.47) ; v1(216.01,31.53) 216.22,31.33 216.22,29.6 216.01,29.4 216.01,26.25 213.22,23.46 213.22,19.7 215.48,17.44 215.48,16.37 214.29,15.18 214.29,10.68 v2(213.78,10.17) ; v2(127.04,42.96) 125.72,42.96 125.44,42.68 123.35,42.68 123,43.04 120.84,43.04 120.46,42.66 120.46,42.02 119.72,41.29 v1(119.72,40.68)
  IN2 w0.508: v2(71.89,98.49) 71.69,98.28 65.85,98.28 65.34,98.79 64.65,98.79 64.07,98.21 v1(64.07,98.13) 64.04,98.16 59.62,98.16 57.85,99.94 57.85,101.69 58.25,102.09 v1(58.71,102.09) ; v1(85.02,98.41) 85,98.39 85,94.89 v1(85.15,94.74) ; v2(169.3,28.69) 167.69,28.69 167.6,28.6 165.97,28.6 165.19,27.82 163.21,27.82 162.81,27.42 161.99,27.42 161.96,27.44 160.11,27.44 158.9,28.65 156.91,28.65 156.36,29.21 155.25,29.21 154.9,29.56 150.72,29.56 v2(150.51,29.35) ; v2(207.28,10.07) 209.21,12 213.14,12 213.78,11.36 v2(213.78,10.17)
  IN3 w0.254: v2(92.59,30.8) v2(93.89,30.8)
  IN3 w0.508: v2(142.53,16.67) 142.53,17.18 142.23,17.48 139.83,17.48 139.48,17.13 v2(139.48,16.85) 130.01,16.85 129.42,17.44 127.65,17.44 127.21,17 127.01,17 v2(126.93,16.93)
  BOTTOM w0.203: v1(93.61,25.11) 94.15,25.64 R551.2 94.4,25.64 94.93,26.18 R10880.2 ; R43.2 v2(92.59,30.8) ; PR7068.1 141.92,60.72 141.92,60.95 142.28,61.3 142.84,61.3 142.89,61.25 v1(142.91,61.25) 143.04,61.25 143.06,61.23 143.35,61.23 143.7,61.58 143.7,62.47 143.44,62.72 143.44,65.95 143.35,66.04 143.35,66.57 142.9,67.02 142.9,68.76 PR9088.1 ; v1(103.31,25.03) 103.19,25.03 103.06,25.16 R25436.2 ; v2(179.28,27.57) 179.97,28.26 179.97,30.97 v2(181.16,32.17) ; v2(93.89,30.8) 93.91,30.82 R25434.2 ; v2(81.8,27.8) 81.93,27.93 R98.2 R102.2
  BOTTOM w0.254: JDIM1.255 57.34,30.71 57.28,30.65 55.49,30.65 v1(55.38,30.54) 55.28,30.65 53.88,30.65 53.29,30.06 v1(53.29,28.94) ; R554.2 93.86,30.77 v2(93.89,30.8)
  BOTTOM w0.381: v2(199.99,28.69) 200.02,28.65 R452.2 ; R732.2 205.78,26.68 v2(205.9,26.55) ; v2(77.53,25.64) 77.46,25.57 R25430.1 77.46,24.84 v2(77.86,24.45) ; R25474.2 91.71,25.77 v2(92.29,25.18) ; PR9265.2 62.91,125.12 ; R134.2 93.38,25.34 v1(93.61,25.11)
  BOTTOM w0.508: v2(148.02,21.55) 147.54,21.55 147.04,21.04 147.04,16.75 146.45,16.17 143.04,16.17 v2(142.53,16.67) ; v1(22.49,40.63) 22.49,40.19 22.29,39.99 PR106.1 ; 62.91,125.12 63.38,124.65 v1(63.38,124.62) ; R641.2 140.78,21.08 141.29,20.57 141.29,19.32 139.48,17.51 v2(139.48,16.85) ; R25486.2 40.4,116.52 40.98,115.94 42.61,115.94 43.42,115.12 45.45,115.12 46.72,113.85 46.72,113.02 v2(47.66,112.08) ; PR9075.1 71.97,98.41 v2(71.89,98.49)
  vias: v1(17.08,87.74) v1(17.71,87.74) v1(23.37,38.72) v1(23.84,39.38) v1(24.09,76.03) v1(24.09,75.4) v1(24.57,83.43) v1(24.57,82.79) v1(25.21,83.3) v1(25.21,82.66) v1(25.84,5.88) v1(25.84,5.24) v1(26.48,5.88) v1(26.48,5.24) v1(27.11,5.27) v1(33.08,28.83) v1(33.72,28.83) v1(57.85,112.71) v1(58.48,112.69) v1(58.89,103.11) v1(59.12,112.69) v1(59.35,102.09) v1(59.88,112.71) v1(65.26,27.93) v1(65.52,28.51) v1(89.11,99.33) v1(89.75,99.33) v1(150.05,27.98) v1(195.6,28.41) v1(195.6,27.77) v1(212.46,26.68) v1(212.46,26.05) v1(215.07,32.65) v2(51.8,105.45) v2(52.39,105.52) v2(66.84,20.33) v2(136.1,27.11) v2(136.69,27.11) v2(148.75,29.35) v2(149.03,28.82) v2(149.34,29.35) v2(149.64,28.82) v2(149.92,29.35) v2(150.25,28.82) v2(150.84,28.82) v2(197.75,26.66)
+3V3_TPM: length 4.1
  TOP w0.203: U33.22 122.4,19.71 122.33,19.64 C744.1 ; R580.2 122.01,24.34 122.24,24.12 122.24,23.58 122.46,23.35 v2(122.46,23.33) ; C744.1 121.83,19.87 v2(121.6,20.1) ; C744.1 C741.1
  vias: v1(131.53,21.37) v2(128.61,23.1) v2(129.14,23.38)
+3V3_TPM_VSB:
  vias: v1(128.61,17.39)
+3V_CCD_PWR1_C: length 5.9
  BOTTOM w0.305: 59.35,106.14 CN29.32 59.35,107.66 59.5,107.81 59.75,107.81 59.85,107.71 CN29.33 59.85,105.75 59.46,105.36 R25459.2 59.12,105.9 59.35,106.14
+3V_DEEP_SUS: length 99.1
  TOP w0.203: v1(61.15,47.76) 61.25,47.87 R117.2 ; R97.2 95.6,28.5 95.72,28.38 95.72,27.57 v2(95.67,27.52) ; v2(97.04,29.5) 97.21,29.5 97.53,29.18 R95.2 ; v1(62.8,23.86) 63.12,23.86 63.46,23.52 C246.2
  TOP w0.508: R1260.2 100.4,34.75 v1(100.77,34.38)
  IN3 w0.254: 96.96,30.58 97.04,30.5 v2(97.04,29.5) ; v2(95.67,27.52) 95.67,29.42 95.36,29.73 ; v1(60.95,30.33) 63.3,30.33 v1(63.43,30.47)
  IN3 w0.508: v2(92.37,22.87) 90.84,22.87 89.57,24.14 89.57,26.1 ; 90.87,27.04 90.87,27.27 92.12,28.53 93.3,28.53 93.58,28.81 94.44,28.81 96.21,30.58 98.22,30.58 99.38,31.74 99.38,33.72 100.04,34.38 v1(100.77,34.38) ; v1(92.98,14.44) 92.98,14.31 93.49,13.8 111.67,13.8 112.41,14.54 v2(112.41,14.9)
  BOTTOM w0.203: R1252.2 81.29,27.19 v2(82.26,26.22) ; R186.1 61.38,48.66 61.15,48.42 v1(61.15,47.76) ; v2(88.71,31.01) 88.48,31.24 R104.1 ; v1(64.53,36.38) 64.73,36.59 R89.2 ; 90.26,22.44 89.88,22.82 U6504.5 ; R103.1 89.95,31.4 89.72,31.18 v2(89.72,31.02)
  BOTTOM w0.254: R31.1 66.53,28.89 66.53,28.48 66.83,28.18 v1(67.24,28.18) 68.01,28.18 68.51,27.67 68.51,25.89 68.82,25.59 68.82,24.24 v1(68.69,24.12) ; R1273.2 87.83,29.84 87.62,29.63 v2(87.62,29.42) 87.62,29.35 87.83,29.14 R1274.2 ; v1(60.95,30.33) 60.95,47.57 v1(61.15,47.76)
  BOTTOM w0.508: v1(92.98,14.44) 92.98,14.83 93.43,15.28 93.43,17.61 92.01,19.04 92.01,21.22 ; v2(112.41,14.9) 113.27,14.9 113.83,15.45 113.83,21.88 113.51,22.2 R25343.1
  vias: v1(61.4,23.81) v1(61.71,24.4) v1(62.04,23.81) v1(62.34,24.37) v1(86.96,29.5) v2(82.84,26.35) v2(83.23,26.79) v2(87.51,26.68) v2(88.1,26.68) v2(88.68,26.68)
+3V_DMIC:
  vias: v1(38.87,115.71)
+3V_EC: length 7.1
  TOP w0.203: U37.11 182.23,24.18
  TOP w0.254: C1189.1 179.87,25.46 180.17,25.16 180.17,24.83 180.39,24.61 181.13,24.61 v1(181.32,24.8) 181.49,24.8 182.12,24.18 182.23,24.18 ; C1189.1 179.64,25.74 180.04,26.14 R25307.2 ; C1189.1 179.13,25.46 179.06,25.39 R25317.2
+3V_LAN: length 11.3
  IN1 w0.635: 50.76,109.69 50.1,109.03 50.1,108.15 47.93,105.98 47.39,105.98 46.25,104.84 46.25,104.44 45.76,103.95 44.77,103.95 43.83,103.01 v1(43.83,102.14)
  vias: v1(40.52,110.83) v1(40.5,110.2) v1(41.08,110.48) v1(50.3,110.98) v1(50.94,111.01)
+3V_LDO_EC: length 74.6
  TOP w0.203: R25309.2 195.42,32.65 195.21,32.85 194.93,32.85 194.12,33.67 193.53,33.67
  TOP w0.381: R359.1 178.82,32.3 178.19,32.94 v2(178.19,32.96) 178.19,33.18 178.52,33.51 183.09,33.51 183.37,33.79 186.07,33.79 186.19,33.92 188.99,33.92 189.65,34.58 190.61,34.58 190.94,34.91 191.96,34.91 192.59,34.28 192.59,33.39 192.34,33.13 ; v2(174.53,25.54) 173.82,24.82 D63.1 174.86,24.67 175.82,23.72 R25306.1 175.82,22.94 176.07,22.69 176.07,22.26 v1(176.16,22.18) 176.64,21.69 R25300.2
  IN3 w0.381: 175.25,32.97 v2(175.25,32.92) ; 175.25,32.97 175.25,33.14 175.57,33.46 177.03,33.46 177.53,32.96 v2(178.19,32.96) ; 175.25,32.97 174.79,33.44 165.44,33.44 164.79,34.09 164.79,34.31 164.15,34.96 164.09,34.96 163.82,35.23 163.11,35.23 162.47,35.88 160.17,35.88 159.38,36.67 159.38,36.99 159.07,37.3 158.56,37.3 158.35,37.1 154.85,37.1 154.37,36.61 153.91,36.61 153.79,36.5 153.39,36.5 153.13,36.24 149.4,36.24 148.87,36.77 147.84,36.77 147.59,36.51 v2(147.57,36.51)
  BOTTOM w0.381: PR6017.2 145.77,37.45 v1(146.49,37.45) 147.43,36.51 v2(147.57,36.51) ; v2(175.25,32.92) 175.25,32.66 173.7,31.1 173.7,29.83 173.72,29.81 173.72,28.97 172.88,28.13 172.88,27.42 173.26,27.04 174.13,27.04 174.53,26.63 v2(174.53,25.54)
+3V_RTC: length 130.9
  TOP w0.305: R25310.1 65.1,103.37 64.58,103.9 64.58,104.15 v1(64.35,104.38)
  IN1 w0.635: v3(48.45,24.24) 48.82,23.87 48.82,20.99 46.93,19.1 46.93,18.52 45.51,17.1 45.51,16.39
  IN2 w0.635: v1(64.35,104.38) 60.62,104.38 59.94,103.71 57.58,103.71 55.19,101.31 54.14,101.31 53.45,100.62 53.45,99.6 52.58,98.73 51.69,98.73 50.81,97.85 50.81,97.24 49.62,96.05 45.22,96.05 44.69,95.52 33.13,95.52 32.21,94.6 32.21,93.59 29.67,91.05 29.67,82.4 29.07,81.8 29.07,80.94 28.38,80.25 28.38,73.9 28.65,73.63 28.65,68.64 28.34,68.34 28.34,61.33 28.24,61.22 28.24,47.12 28.34,47.01 28.34,39.29 31.71,35.93 36.21,35.93 39.05,33.08 40.83,33.08 44.94,28.97
  IN3 w0.635: v1(61.66,22.67) 62.13,23.14 65.37,23.14 65.58,23.35 v1(66.23,23.35)
  vias: v1(45.63,12.66) v1(46.24,27.93) v1(46.87,27.9) v1(47.59,26.96)
+3V_RTC_0: length 46.6
  IN1 w0.508: v1(16.23,5.94) 16.76,6.46 19.34,6.46 19.7,6.82 21.6,6.82 22.97,5.45 23.89,5.45 24.9,4.43 27.18,4.43 27.74,4.99 27.74,5.69 28,5.96 29.53,5.96 30.44,6.87 34.47,6.87 34.69,7.09 34.82,7.09 35.64,7.92 35.64,8.63 36.4,9.39 36.55,9.39 46.02,18.85 46.02,19.5 47.43,20.92 47.43,21.7 47.15,21.98 v1(47.05,21.98)
  BOTTOM w0.508: v1(16.23,5.94) 15.62,5.94 14.93,6.64 CN1.1 14.93,8.78 v1(15.61,9.46)
+3V_RTC_1:
  vias: v1(48.02,22.41)
+3V_RTC_2:
  vias: v1(45.1,25.13)
+3V_S5: length 256.3
  TOP w0.203: R25413.1 94.58,25.21 94.5,25.13 v2(94.5,24.75) ; R25520.2 83.37,27.82 v2(83.58,27.62) ; v2(96.51,24.32) 96.2,24.62 R25415.1
  TOP w0.254: v1(27.85,10.83) 26.22,12.46 R25504.2 ; v1(103.67,28.41) 103.34,28.41 100.78,30.97 R25439.2 100.78,31.35 99.88,32.24 99.33,32.24 98.31,33.26 97.34,33.26 95.57,35.04 R25437.2 95.07,35.43 95.44,35.8 95.44,36.7 R25438.2 ; R33.2 60.75,51.56 R36.2 60.77,51.23 v1(60.39,50.85) ; v2(91.65,27.04) 91.4,27.29 91.4,28.66 91.27,28.79 v2(91.27,30.77)
  TOP w0.381: v1(64.6,24.4) 64.6,25.07 63.63,25.07 63.44,25.26 R25397.2 63.19,25.39 62.54,26.04 R25399.2 ; R25330.1 180.87,29.9 181.37,29.4 v2(181.37,29.17)
  TOP w0.508: R25317.1 176.67,25.39 v2(176.59,25.46)
  IN1 w0.381: v1(19.62,95.62) 22.24,98.23 23.89,98.23 26.6,100.95 30.8,100.95 31.43,101.59 36.41,101.59 38.19,99.81 42.99,99.81 v1(43.24,100.06)
  IN2 w0.508: 15.94,25.72 15.63,26.02 14.71,26.02 13.16,24.48 9.22,24.48 v1(8.79,24.05)
  IN2 w1.016: 19.24,8.75 19.24,13.58 17.21,15.61 17.21,17.13 17.77,17.69 18.76,17.69 19.62,18.55 19.62,21.14 19.19,21.58 19.19,24.04 18.05,25.18 16.47,25.18 15.94,25.72 15.94,27.42 16.06,27.55 16.06,43.14 14.84,44.36
  IN3 w0.254: v2(194.49,27.55) 194.49,28.79 192.83,30.45 191.69,30.45 191.06,31.08 189.83,31.08 189.6,31.3 189.6,32.5 v2(189.42,32.68)
  IN3 w1.016: 63.75,122.3 63.18,121.73 55.84,121.73 55.31,122.26 51.75,122.26 47.61,118.12 47.61,114.18 48.39,113.41
  BOTTOM w0.203: R25382.2 83.88,28.18 83.58,27.88 v2(83.58,27.62) ; R25480.2 94.78,25.03 v2(94.5,24.75) ; R25477.2 90.1,26.86 v2(90.28,26.68) 90.1,26.5 90.1,26.3 R604.2 ; v2(96.51,24.32) 95.82,25.01 R202.2 ; v2(78.73,27.11) 78.39,27.45 R144.2 ; R605.2 91.27,30.25 v2(91.27,30.77) 91.37,30.87 R607.2
  BOTTOM w0.254: R215.1 60.32,24.01 61.05,23.28 61.99,23.28 62.18,23.09 62.18,21.88 62.35,21.7 63.66,21.7 64.54,22.58 ; v2(85.08,28.46) 85.08,27.49 84.96,27.38 R25381.2 84.96,26.47 84.36,25.88 R25383.2
  BOTTOM w0.305: CN33.1 76.32,21.76 76.52,21.96 v2(76.52,22.28) ; v2(20.94,19.06) 20.99,19.01 R6508.1 ; R6504.1 28.13,18.79 28.13,19.88 27.82,20.19 R6505.1 R6506.1 26.55,20.41 v1(25.53,21.44) 25.26,21.7 24.09,21.7 23.52,21.14 23.52,19.95 23.22,19.65 22.26,19.65 21.77,19.15 R6508.1 ; R6510.1 21.31,17.93 21.77,18.39 R6508.1 ; v2(96.51,24.32) 96.79,24.6 R60.2
  BOTTOM w0.381: v2(91.65,27.04) 91.68,27.06 R606.2 ; v2(24.29,11.75) 24.5,11.75 24.73,11.51 R6516.1 R6515.1 ; R574.2 78.81,22.6 78.42,22.21 v2(77.51,22.21) ; v1(60.39,50.85) 60.64,51.1 R38.2 60.14,51.79 59.87,52.06 59.87,54.21 60.51,54.85 60.51,55.99 62.55,58.03 62.55,64.12 61.91,64.76 61.91,65.9 63.18,67.17 63.31,67.17 65.05,68.91 65.05,78.38 61.21,82.22 61.21,91.03 60.7,91.54 60.7,96.25 59.64,97.32 56.3,97.32 55.01,98.6 53.08,98.6 52.26,99.43 50.76,99.43 50.21,99.97 43.33,99.97 v1(43.24,100.06) ; R25384.2 80.04,24.71 80.52,24.23 Q29.2 79.48,24.06 78.46,25.09 78.46,25.62 78.73,25.89 v2(78.73,27.11) ; v2(181.37,29.17) 181.37,28.34 179.51,26.48 178.62,26.48 177.61,25.46 v2(176.59,25.46)
  BOTTOM w0.508: v1(8.79,24.05) Q6505.2
  vias: v1(13.47,44.77) v1(13.96,45.2) v1(16.17,90.26) v1(16.72,90.84) v1(18.98,7.86) v1(18.98,7.23) v1(33.03,24.01) v1(33.67,24.01) v1(43.01,26.86) v1(43.32,26.3) v1(43.65,26.86) v1(43.95,26.3) v1(44.28,26.86) v1(44.59,26.3) v1(44.92,26.88) v1(49.08,113.47) v1(49.72,113.47) v1(63.97,24.4) v1(64.1,28.41) v1(64.3,23.84) v1(64.53,123.23) v1(64.96,23.84) v1(65.26,24.4) v1(66.61,21.96) v1(74.69,22.24) v1(159.65,21.58) v1(160.29,21.55) v1(160.62,22.11) v1(160.92,21.55) v1(161.56,21.55) v1(162.19,21.55) v1(193.91,24.98) v1(194.55,25.01) v2(85.51,28.87)
+3V_SSD:
  vias: v1(21.8,3.36) v1(21.98,5.85) v1(22.13,3.97) v1(22.44,3.36) v1(22.84,3.86) v1(23.24,3.36) v1(36.13,3.26) v1(36.76,3.26) v1(38.42,3.26) v1(39.05,3.26)
+3V_WLAN_P: length 46.4
  TOP w0.381: Q63.2 174.76,20.44 v1(174.76,19.47) 174.76,18.76 174.26,18.25 174.26,17.28 v2(174.39,17.14)
  IN2 w0.381: v2(174.39,17.14) 175.09,16.45 176.8,16.45 177.38,17.03 182.05,17.03 184.39,14.69 190.17,14.69 190.92,13.94 192.01,13.94 192.31,13.64 196.8,13.64 v2(198,14.85)
  BOTTOM w0.203: Q33.2 181.71,18.58 181.71,19.42 181.51,19.62 R652.2 ; C2610.1 180.55,14.75 R651.2 179.53,14.75 179.46,14.81 ; v2(194.37,18.25) 194.27,18.15 R672.2 193.71,18.43 193.25,18.88 R671.2
  BOTTOM w0.381: Q33.2 180.9,18.14 180.63,17.87 180.63,16.67 179.92,15.96 179.77,15.96 179.46,15.66 179.46,14.81 179.44,14.79 175.71,14.79 174.75,15.75 174.75,16.79 v2(174.39,17.14)
  vias: v1(191.08,24.61) v1(191.72,24.61) v1(192.35,24.61) v1(192.9,12.28) v2(193.28,11.72) v2(193.86,11.72) v2(194.45,11.72) v2(195.03,11.72)
+3VLCD_CON:
  vias: v1(62.14,102.27) v1(62.85,102.27) v1(77.79,98.16) v1(78.42,98.16) v1(78.4,97.5)
+3VLCD_CON_R:
  vias: v1(60.54,105.88) v1(61.15,105.55) v1(61.17,106.18)
+3VLCD_CON_R_C: length 3.5
  TOP w0.305: R25456.2 62.85,104.81 62.04,105.62 v1(62.04,105.65) v1(62.04,106.29)
  BOTTOM w0.305: CN29.37 61.85,105.84 v1(62.04,105.65)
+3VPCU: length 345.2
  TOP w0.203: v2(180.5,32.93) 182.73,32.93 183.01,32.64 R25323.2
  TOP w0.254: PR18.2 138.37,27.77 138.12,27.52 137.22,27.52 137.15,27.6 135.71,27.6 135.45,27.34 PR204.2
  TOP w0.381: v2(143.57,36.67) 143.2,36.67 141.03,34.5 141.03,33.58 140.21,32.75 140.21,32.46 139.67,31.93 139.24,31.93 138.85,31.53 138.85,30.31 138.31,29.78 138.31,28.82 ; v1(54.04,110.15) 53.86,109.97 R25370.1 53.41,109.05 R25368.2
  TOP w0.508: R25295.1 46.67,21.32 46.04,21.96 R978.1
  IN1 w0.508: v2(194.68,36.1) 194.68,35.42 195.18,34.91 196.07,34.91 196.58,34.4 196.58,33.82 197.04,33.36 197.04,29.78 198.19,28.63 198.19,28.48 198.57,28.1 201.06,28.1 201.29,27.87 204.62,27.87 204.94,28.18 204.94,28.37 205.69,29.12 207.45,29.12 207.78,28.79 207.78,28.69 208.39,28.08 208.39,26.35 209.61,25.13 210.83,25.13 211.64,25.94 211.64,27.88 211.87,28.1 212.58,28.1 213.07,28.59 213.07,29.15 214.59,30.67 v2(214.59,30.97)
  IN1 w0.762: 26.2,71.61 26.2,72.53 24.83,73.9 24.83,80.12 23.3,81.65 23.3,84.82 22.67,85.46 22.67,86.6 23.56,87.49 26.62,87.49 27.61,88.48 27.61,92.3 28.89,93.58 v1(28.89,97.14) ; 40.17,30.75 40.16,30.74 40.16,26.74 41.08,25.82 41.08,24.62 41.77,23.94 41.77,23.71 41.72,23.66 v3(41.72,23.61)
  IN2 w0.508: 153.83,28.03 155.49,28.03 156.83,26.68 161.71,26.68 161.73,26.66 163.13,26.66 163.53,27.06 165.5,27.06 166.28,27.84 168.37,27.84 168.46,27.93 170.04,27.93 170.42,28.31 173.04,28.31 173.11,28.38 176.49,28.38 177.3,27.57
  IN2 w0.762: 47.97,105.65 47.1,104.79 47.1,103.14 48.37,101.87 48.37,100.79 47.64,100.06 44.41,100.06 43.2,98.85 31.36,98.85 29.65,97.14 v1(28.89,97.14) ; 115.12,45.55 115.92,46.35 115.92,50.4 115.67,50.65 115.67,52.12 115.02,52.77 115.02,54.43 115.33,54.74 115.33,61.64 116.03,62.34 116.03,64.65 115.15,65.52 113.73,65.52 112.23,67.02 110.6,67.02 109.99,67.63 105.15,67.63 102.92,69.86 102.56,69.86 100.65,71.78 100.65,74.29 100.95,74.59 100.95,76.87 101.76,77.68 101.76,79.2 101.53,79.43 101.53,82.38 100.72,83.2 97.11,83.2 95.31,84.99 95.31,86.52 90.31,91.53 90.31,96.35 89.8,96.86 89.11,96.86 88.58,97.39 88.58,97.45 86.13,99.9 81.5,99.9 80.59,100.81 80.59,101.95 80.22,102.33 75.75,102.33 75.17,102.91 75.17,103.36 74.85,103.68 73.58,103.68 73.16,103.26 70.44,103.26 67.07,106.64 67.07,109.77 64.35,112.48 62.75,112.48 62.14,111.87 56.98,111.87 55.08,109.97 54.21,109.97 v1(54.04,110.15) ; 40.42,31.89 38.9,31.89 35.87,34.91 31.38,34.91 27.39,38.9 27.39,46.62 27.29,46.72 27.29,62.42 26.78,62.93 26.78,67.68
  BOTTOM w0.254: v2(180.5,32.93) 180.5,32.19 179.49,31.18 179.49,28.54 178.7,27.75 v2(178.7,27.57) ; R736.2 195.91,35.99 195.46,36.44 195.01,36.44 v2(194.68,36.1)
  BOTTOM w0.305: PR15.2 138.43,26.77 139.08,27.42 139.3,27.42 139.66,27.77 139.66,28.36 139.36,28.66 v1(138.82,28.66)
  BOTTOM w0.381: PR9.2 PR15.2 ; v2(143.57,36.67) 143.7,36.8 143.7,37.3 v1(143.8,37.4) 143.8,38.07 PR6003.1
  BOTTOM w0.508: R25500.2 192.06,34.76 192.7,35.39 193.97,35.39 v2(194.68,36.1) ; R25519.1 43.7,121.02 44.21,120.51 44.21,116.42 44.51,116.11 46.2,116.11 47.48,114.83 47.48,113.42 48.86,112.05 48.86,111.24 49.87,110.22 53.78,110.22 53.86,110.15 v1(54.04,110.15)
  vias: v1(27.01,69.73) v1(27.01,69.07) v1(40.16,31.24) v1(40.83,31.23) v1(42.4,22.8) v1(114.95,44.69) v1(115.58,44.72) v1(138.19,28.69) v2(152.59,28.82) v2(153.22,28.82) v2(214.59,31.56)
+3VPCU_EC: length 100
  TOP w0.152: U37.92 199.68,26.58 200.19,27.08 C6565.1
  TOP w0.203: C6578.1 182.11,18.22 182.15,18.18 U37.26 ; C6575.1 191.53,31.89 v2(191.53,31.48) 191.53,31.23 191.2,30.9 190.64,30.9 190.45,30.71 U37.114 ; v2(190.77,11.97) 191.65,12.86 U37.50 ; U37.121 187.65,30.69
  TOP w0.254: v2(190.77,11.97) 190.84,11.9 C6570.1 C6569.1 192.39,11.9 193.31,10.98 195.21,10.98 v1(195.9,11.67) 197.83,9.74 203.26,9.74 203.53,10.01 203.53,10.39 203.03,10.88 203.03,11.75 v2(202.96,11.82) ; L29.1 201.95,19.82 201.97,19.82 v1(202.25,19.54) ; C6565.1 200.67,27.08 201.51,26.25 v2(201.79,26.25) ; 187.65,30.69 187.65,31.12 v2(187.43,31.33) 187.29,31.48 187.29,31.82 C6574.1 186.82,32.07 186.65,32.24 L30.2 ; C6578.1 C6577.1 180.61,18.22 180.05,17.66 178.57,17.66 177.68,16.78 v2(177.68,16.42)
  IN1 w0.254: v2(190.77,11.97) 190.77,13.34 190.21,13.9 183.5,13.9 181.96,15.44 178.16,15.44 177.68,15.91 v2(177.68,16.42) ; v2(202.96,11.82) 202.96,11.67 203.16,11.47 203.82,11.47 204.15,11.8 204.15,15.99 203.26,16.88 203.26,18.53 v1(202.25,19.54)
  IN3 w0.254: 201.03,23.66 201.03,23.79 199.58,25.23 199.58,26.69 199.02,27.25 197.19,27.25 196.9,26.95 196.08,26.95 195.74,27.29 195.38,27.29 195.12,27.55 195.12,28.87 193.04,30.96 191.9,30.96 191.53,31.33 v2(191.53,31.48) 191.47,31.48 190.81,32.14 190.67,32.14 189.68,33.13 188.2,33.13 187.36,32.3 187.36,31.38 187.41,31.33 v2(187.43,31.33) ; 201.03,23.66 202.42,25.06 202.42,25.72 201.89,26.25 v2(201.79,26.25) ; 201.03,23.66 201.03,21.63 201.28,21.37 201.28,20.51 v1(202.25,19.54)
  BOTTOM w0.254: v2(174.74,22.11) 174.9,21.95 175.79,21.95 176.14,21.59 176.14,16.85 176.57,16.42 v2(177.68,16.42)
+3VPCU_ECPLL: length 2.6
  TOP w0.203: U37.127 185.25,30.89 185.33,30.97
  TOP w0.254: L30.1 184.89,32 185.33,31.56 C6573.1 185.33,30.97
+3VSPI: length 59.7
  TOP w0.203: v2(121.61,21.2) 121.61,21.44 121.47,21.58 R586.2 ; v2(115.33,23.66) 115.07,23.91 R222.1 ; R583.2 122.24,17.66 v1(122.39,17.51)
  TOP w0.254: v2(158.76,32.37) 158.38,31.99 C189.2 158.28,31.27 R112.2
  TOP w0.508: v2(152.44,17.11) 153.43,17.11 154.75,18.43 v1(154.75,20.12) 154.75,20.81 155.33,21.4 157.35,21.4 v2(157.49,21.54)
  IN3 w0.254: 122.69,18.6 122.69,18.17 122.39,17.87 v1(122.39,17.51)
  IN3 w0.508: v2(152.44,17.11) 151.73,17.82 149.46,17.82 148.65,17 146.18,17 143.13,20.05 137.07,20.05 136.28,20.84 132.07,20.84 v2(131.63,20.41) 128.36,20.41 126.55,18.6 122.69,18.6 122.21,19.09 121.58,19.09 121.17,19.49 120.66,19.49 120.15,20 120.15,21.6 ; 120.15,21.6 117.38,21.6 115.8,23.19 ; 120.15,21.6 120.58,22.03 121.1,22.03 121.61,21.52 v2(121.61,21.2)
  BOTTOM w0.508: R25343.2 114.74,22.85 115.33,23.43 v2(115.33,23.66)
  vias: v1(158.23,30.59) v2(162.45,32.45)
+5V: length 146.3
  TOP w0.508: v1(110.88,14.85) 110.88,19.47 111.31,19.9 111.31,22.97 113.02,24.67 118.62,24.67 118.97,25.03 120,25.03 120.51,25.54 123.35,25.54 123.81,26 127.98,26 128.36,26.38 v2(128.54,26.38)
  IN1 w1.016: 16.19,32.4 16.19,33.56 15.86,33.9 15.86,39.25 16.19,39.58 16.19,49.52 16.72,50.05 16.72,52.41 16.44,52.69 16.44,56.12 17.84,57.52 19.75,57.52 20.76,58.53 20.76,61.07 22.92,63.23 22.92,64.88 23.43,65.39 23.43,69.94 23.07,70.29 23.07,70.61 22.77,70.91 ; 60.07,100.47 59.99,100.39 58.1,100.39 56.5,101.99 51.57,101.99 49.52,99.94 44.89,99.94 43.8,98.84 37.78,98.84 36.05,100.57 31.94,100.57 31.3,99.94 27.37,99.94 24.06,96.63 22.41,96.63 20.51,94.73 20.51,93.33 18.44,91.26 18.44,89.53 17.71,88.81 15.99,88.81 15.17,88 15.17,85.2
  IN2 w0.762: 166.3,26.66 165.97,26.32 164.91,26.32 164.69,26.1 163.71,26.1 163.54,25.92 161.1,25.92 161.07,25.94 155.46,25.94 154.79,26.61 153.86,26.61
  BOTTOM w0.508: v1(16.93,28.79) 17.87,28.79 17.97,28.69 20.7,28.69 PR126.1
  vias: v1(13.65,85.33) v1(13.65,84.7) v1(16.93,31.99) v1(16.93,31.36) v1(16.93,30.69) v1(17.56,31.99) v1(17.56,31.36) v1(17.56,30.72) v1(18.22,31.99) v1(18.2,31.36) v1(18.2,30.69) v1(60.41,101.28) v1(61.05,101.28) v1(210.35,24.83) v1(212.36,29.5) v1(212.36,28.79) v1(215.73,15.07) v1(215.73,14.44) v1(215.73,13.8) v2(123.25,16.39) v2(123.84,16.39) v2(124.42,16.39) v2(125,16.39) v2(143.9,27.34) v2(144.49,27.37) v2(174.04,27.72) v2(174.64,27.75) v2(197.78,15.4)
+5V_FAN: length 2.5
  TOP w0.508: v1(178.09,27.52) 177.81,27.24 R575.2
  BOTTOM w0.508: v1(178.09,27.52) 176.76,27.52 FAN3.1
+5V_HDMIC: length 13.5
  TOP w0.508: D14.3 v1(23.94,71.46)
  IN1 w0.508: v1(19.14,81.9) 19.82,81.22 19.82,77.64 21.41,76.06 21.7,76.06 22.29,75.47 22.29,74.65 22.71,74.24 22.71,73.02 23.94,71.79 v1(23.94,71.46)
  vias: v1(17,83.35)
+5V_KB:
  vias: v1(198.89,13.88)
+5V_PVDD: length 2.6
  BOTTOM w0.203: U20.46 208.35,31.22 209.1,30.47 ; 208.71,33.22 U20.41
  vias: v1(209.43,30.47)
+5V_S5: length 318.5
  TOP w0.203: PR9013.1 73.09,107.42 v1(72.83,107.68)
  TOP w0.254: PR9091.2 140.21,67.93 139.71,68.43 139.71,69.4 v1(141.62,71.31)
  TOP w0.381: v1(23.18,17.61) 23.18,17.7 22.79,18.08 R6603.2
  TOP w0.508: PR9100.1 132.29,78.5 v1(132.01,78.5) ; PR7064.1 135.29,55 135.22,54.93 v1(134.55,54.93) ; v1(63.09,123.21) 62.75,123.56 PR256.2 ; v1(35.24,24.04) 35.24,23.49 PR9253.1 ; v2(141.11,47.66) 140.65,47.2 140.65,45.48 140.8,45.33 v2(140.8,44.69)
  IN1 w0.508: 136.26,53.68 136.26,52.64 135.47,51.85 132.57,51.85 132.5,51.78 v1(132.17,51.78) ; 136.26,53.68 135.01,54.93 v1(134.55,54.93) ; 136.26,53.68 141.44,53.68 141.64,53.88 141.64,55 142.86,56.22 142.86,56.53 143.88,57.54 143.88,58.15 143.47,58.56 143.06,58.56 142.76,58.86 142.45,58.86 141.74,59.57 141.74,61.2 141.46,61.48 141.46,62.65 141.74,62.93 141.74,67.8 141.24,68.31 141.24,69.12 140.73,69.63 140.73,70.45 141.59,71.31 v1(141.62,71.31) 141.82,71.51 141.82,73.49 141.26,74.05 136.46,74.05 v1(132.01,78.5) ; v1(59.07,108.32) 59.07,108.77 59.62,109.33 59.88,109.33 60.39,109.84 60.39,111.11 62.57,113.3 62.57,121.12 63.56,122.11 63.56,122.74 v1(63.09,123.21)
  IN2 w0.508: v1(134.43,47.41) 134.43,47.87 132.17,50.13 v1(132.17,51.78) ; v1(27.62,63.49) 27.52,63.59 27.52,68.68 27.62,68.78 27.62,73.37 26.33,74.66 26.33,80.85 26.62,81.14 27.24,81.14 27.65,81.55 27.65,82.43 28.85,83.63 28.85,91.39 31.39,93.93 31.39,95.19 32.54,96.34 44.35,96.34 44.88,96.87 49.26,96.87 49.99,97.6 49.99,98.19 50.93,99.13 50.93,100.49 54.44,104 55.56,104 56.86,105.29 57.36,105.29 57.85,105.78 57.85,106.26 59.07,107.48 v1(59.07,108.32) ; v1(63.09,123.21) 63.38,122.92 63.38,117.05 65.65,114.79 68.64,114.79 69.53,113.91 69.53,113.27 69.91,112.89 69.91,112 71.82,110.1 71.94,110.1 72.83,109.21 v1(72.83,107.68) 73.86,108.7 78.09,108.7 78.42,109.03 81.9,109.03 83.37,107.56 87.08,107.56 90.89,103.75 91.76,103.75 93.69,101.81 93.69,100.77 92.87,99.96 92.87,92.98 95.11,90.74 98.49,90.74 98.61,90.87 100.57,90.87 101.05,90.38 101.05,89.6 101.48,89.17 102.48,89.17 105.66,85.99 106.01,85.99 108.14,83.86 110.5,83.86 111.22,83.13 111.22,82.86 115.54,78.54 115.54,77.04 v1(116.01,76.57) 115.84,76.39 115.84,74.25 116.7,73.38 v1(116.7,71.13)
  IN3 w0.381: v1(134.43,47.41) 134.17,47.15 134.17,43.93 134.96,43.14 139.56,43.14 140.8,44.39 v2(140.8,44.69)
  IN3 w0.508: v1(116.01,76.57) 117.11,76.57 117.74,77.2 120.41,77.2 121.78,75.83 122.15,75.83 122.6,76.29 124.59,76.29 125.83,75.04 127.37,75.04 128.2,74.2 129.81,74.2 130.16,74.56 130.16,76.9 130.64,77.38 130.64,77.99 131.15,78.5 v1(132.01,78.5)
  BOTTOM w0.203: PR7103.2 132.62,52.23 v1(132.17,51.78)
  BOTTOM w0.254: PR7069.1 141.47,47.3 v2(141.11,47.66) ; PR7116.1 141.72,44.92 141.29,45.35 PR7065.1 140.94,44.83 v2(140.8,44.69) ; v1(141.62,71.31) 142.19,70.73 PR9087.1
  BOTTOM w0.508: PR7108.1 115.66,70.39 116.39,71.13 v1(116.7,71.13) ; PR9074.1 76.55,107.65 76.24,107.96 76.24,108.38 PR9001.1 75.02,108.31 75.02,107.73 74.79,107.5 73,107.5 v1(72.83,107.68) ; v1(134.43,47.41) 134.45,47.38 134.46,47.38 PR7080.1 ; v1(23.28,43.12) 23.35,43.04 23.38,43.06 23.43,43.01 25.06,43.01 26.99,44.94 26.99,62.85 v1(27.62,63.49) ; PR7112.1 131.14,77.52 132.01,78.4 v1(132.01,78.5)
  vias: v1(14.44,23.43) v1(14.69,24.01) v1(14.95,22.31) v1(15.07,23.43) v1(15.3,24.19) v1(15.71,23.43) v1(15.94,24.24) v1(16.32,23.66) v1(16.57,24.24) v1(19.87,43.55) v1(19.87,42.91) v1(21.3,42.56) v1(21.93,42.56) v1(22.01,43.22) v1(22.64,43.24) v1(26.99,16.88) v1(26.99,16.24) v1(26.99,15.61) v1(26.99,14.97) v1(27.99,17.02) v1(28,16.38) v1(28,15.75) v1(29.01,17.09) v1(29.01,16.45) v1(29.02,15.81) v1(29.58,16.17) v1(29.88,16.19) v2(202.42,22.08) v2(203.01,21.96) v2(203.57,22.26)
+5VA:
  vias: v1(201.03,36.51) v1(201.61,36.31) v1(202.12,36.71)
+5VPCU: length 145
  TOP w0.203: v1(28.03,27.29) 28,27.29 27.7,27.6 PR6023.2
  TOP w0.254: v2(137.3,42.56) 137.35,42.56 137.9,43.1 142.44,43.1 144.71,40.83 144.71,40.09 v2(148.78,36.03) 149.59,36.03 149.82,35.8 151.06,35.8 151.95,34.91 151.95,28.18 151.7,27.93 151.7,26.96 v2(151.6,26.86)
  TOP w0.508: v1(122.08,39.51) 122.06,39.48 119.87,39.48 118.55,38.16 117.17,38.16 116.43,38.9 PR104.1 ; R418.1 R417.1 24.33,50.09 23.89,50.53 v1(23.43,50.53) ; v1(23.66,86.35) 23.66,86.88 23.18,87.36 PR9069.1
  IN1 w0.381: v2(137.3,42.56) 136.35,42.56 133.52,39.73 125.26,39.73 124.47,40.51 123.39,40.51 123.05,40.17 122.41,40.17 122.08,39.84 v1(122.08,39.51)
  IN1 w0.508: v1(19.06,45.27) 19.52,44.82 19.85,44.82 20.81,43.85 23.48,43.85 24.27,44.64 24.27,49.69 v1(23.43,50.53)
  IN2 w0.508: v2(97.04,86.55) 97.04,85.54 97.77,84.81 101.95,84.81 103.82,82.94 104.4,82.94 104.94,82.4 109.25,82.4 114.18,77.46 114.18,73.8 115,72.99 115,69.2 116.14,68.06 116.95,68.06 117.71,67.3 117.71,66.04 119.78,63.97 123.51,63.97 126.91,60.57 126.91,49.72 125.28,48.09 125.28,47.69 124.93,47.33 124.93,45.5 124.17,44.74 120.92,44.74 120.51,44.33 120.51,42 121.63,40.88 121.63,40.35 122.08,39.89 v1(122.08,39.51)
  BOTTOM w0.203: PR98.2 121.83,39.76 v1(122.08,39.51) ; v2(151.6,26.86) 151.6,26.74 151.96,26.38 153,26.38 153.15,26.53 153.96,26.53 154.34,26.91 PR6013.1
  BOTTOM w0.254: R737.2 196.19,36.44 v2(196.19,36.6)
  vias: v1(18.1,45.83) v1(18.73,45.83) v1(19.37,45.83) v1(21.68,24.7) v1(21.65,23.99) v1(21.93,25.39) v1(22.31,24.67) v1(22.29,23.96) v1(22.62,25.39) v1(22.95,24.67) v1(22.92,23.96) v1(23,29.78) v1(23,29.15) v1(23.33,30.34) v1(23.35,25.39) v1(23.63,29.78) v1(23.66,29.15) v1(23.96,30.34) v1(24.04,28.56) v1(24.27,29.78) v1(24.29,29.15) v1(29.75,19.14) v1(30.34,20.03) v1(30.34,19.39) v1(30.34,18.76) v1(30.34,18.12) v1(30.34,17.49) v1(30.34,16.72) v1(73.62,101.41) v1(73.93,102.02) v1(74.26,101.41)
+A3VPCU: length 4.3
  TOP w0.203: v1(200.65,17.99) 200.52,18.12 200.52,18.66 200.65,18.78 C6566.1 ; C6566.1 200.58,19.15 200.24,19.49 199.83,19.49 199.72,19.38 U37.74 ; C6566.1 201.2,19.15 201.42,19.38 L29.2
+V3A_LX:
  vias: v1(147,27.9)
+V3A_LX_R:
  vias: v1(145.58,27.93)
+V3A_OUT: length 1
  BOTTOM w0.203: PR6008.1 159.24,36.21 159.33,36.12 PC6014.1
  vias: v1(153.66,35.8) v1(154.27,35.98) v1(154.57,34.23) v1(154.87,35.77) v1(155.05,36.38) v1(155.59,35.77) v1(155.69,36.51) v1(157.08,34.2) v1(157.72,34.2) v1(158.35,34.2)
+V5P5A_LX: length 2.7
  TOP w0.381: PC6035.2 39.42,19.54 39.42,20.52 PR6019.1
  TOP w0.508: v2(38.42,20.03) 38.95,20.56 PR6019.1
  vias: v1(41.84,22.06)
+V5P5A_LX_R: length 2.6
  TOP w0.102: PR6019.2 v1(40.67,21.68)
  TOP w0.508: PC6038.1 PR6019.2
+V5P5A_OUT: length 6.6
  BOTTOM w0.254: PR6026.2 37.15,13.7 37.04,13.6 36.59,13.6 35.96,12.97 35.41,12.97 35.11,13.26 35.11,13.96 35.28,14.12 PC6046.1
  vias: v1(32.24,17.03) v1(35.22,20.97) v1(35.75,20.18) v1(35.75,19.54) v1(35.75,18.91) v1(35.75,18.27) v1(36.38,19.93) v1(36.38,19.29) v1(36.38,18.66) v1(36.38,18.02)
+VCC_CORE: length 3.8
  BOTTOM w0.152: v2(95.87,52.31) 95.87,52.01 96.1,51.78 96.68,51.78 97.03,52.12 U1.BF2 ; U1.BB2 97.4,54.56 v2(97.54,54.7)
  BOTTOM w0.254: v2(97.55,57.19) 97.5,57.19 97.31,57 U1.AV2 ; U1.AP2 97.85,59.44 v1(97.96,59.34)
  vias: v1(83.04,53.81) v1(83.14,58.95) v1(83.14,58.31) v1(83.14,55.09) v1(83.14,54.45) v1(91.04,56.58) v1(91.12,57.85) v1(91.07,57.21) v1(107.53,65.39) v1(108.16,65.39) v1(108.8,65.39) v1(109.43,65.39) v1(110.04,64.76) v1(110.04,64.12) v1(110.68,64.76) v1(110.68,64.12) v1(110.68,63.49) v1(111.31,64.76) v1(111.31,64.12) v1(111.67,62.75) v1(112.13,57.29) v1(112.18,62.34) v1(112.23,61.71) v1(112.18,56.63) v1(112.28,55.99) v1(112.49,55.38) v1(112.81,62.34) v1(112.76,57.26) v1(112.81,56.63) v1(112.86,61.71) v1(112.91,55.99) v1(113.4,62.06) v1(113.4,56.98) v1(113.45,56.35) v1(114.46,55.66) v2(80.67,59.28) v2(80.67,58.37) v2(80.67,57.46) v2(80.67,56.54) v2(80.67,55.63) v2(80.67,54.72) v2(80.67,53.81) v2(80.83,52.9) v2(82.54,58.82) v2(82.54,57.91) v2(82.54,56.09) v2(82.52,55.18) v2(82.51,53.35) v2(82.54,52.44) v2(91.01,53.01) v2(91.67,59.31) v2(91.67,57.46) v2(91.67,56.54) v2(92.87,59.31) v2(92.87,58.39) v2(92.87,55.61) v2(93.05,56.45) v2(93.05,54.78) v2(93.68,58.41) v2(94.32,54.76) v2(94.32,53.8) v2(122.11,56.98) v2(123.18,57.03) v3(117,56.78) v3(117,56.04) v3(117.36,55.38) v3(117.36,54.65) v3(117.36,53.88) v3(117.51,52.74) v3(117.74,56.81) v3(117.74,56.04) v3(118.15,61.73) v3(118.12,60.97) v3(118.1,60.23) v3(118.45,62.57) v3(118.48,56.83) v3(118.48,56.07) v3(118.86,63.21) v3(118.86,60.97) v3(119.01,60.23) v3(119.06,61.73) v3(119.19,62.55) v3(119.21,56.81) v3(119.21,56.04) v3(119.59,63.23) v3(119.77,60.97) v3(119.85,60.23) v3(119.8,52.67) v3(119.92,62.55) v3(119.92,61.76) v3(119.95,56.81) v3(119.95,56.04) v3(120.33,63.21) v3(120.33,52.16) v3(120.61,61) v3(120.61,60.26) v3(120.69,62.55) v3(120.69,61.76) v3(120.69,56.81) v3(120.69,56.04) v3(120.84,52.69) v3(121.07,63.23) v3(121.12,59.57) v3(121.07,57.62) v3(121.12,55.33) v3(121.12,53.96) v3(121.42,62.57) v3(121.42,61.81) v3(121.4,61.05) v3(121.42,60.31) v3(121.42,56.78) v3(121.42,56.02) v3(121.42,54.65) v3(121.42,53.28) v3(121.83,57.59) v3(122.08,59.75) v3(122.59,57.44) v3(122.9,59.93) v3(123.18,59.22) v3(123.28,57.72)
+VCC_V3A: length 2.7
  BOTTOM w0.102: PC6022.1 144.9,34.57 v1(144.21,35.27)
  BOTTOM w0.203: PC6022.1 144.9,33.53 145.05,33.38 PU6000.9
+VCC_V5P5A: length 2
  BOTTOM w0.229: v1(43.19,17.49) 43.33,17.62 PU6003.11
  BOTTOM w0.254: PC6058.1 43,17.29 v1(43.19,17.49)
+VCCGT: length 2.6
  BOTTOM w0.127: U1.P2 97.43,71.27 97.77,71.27 97.79,71.24 v2(97.87,71.24)
  BOTTOM w0.254: v2(97.98,74.48) 97.93,74.48 97.83,74.38 97.35,74.38 U1.K2
  BOTTOM w0.305: 92.26,69.03 92.27,69.02 U1.W9
  vias: v1(80.76,88.35) v1(83.12,72.5) v1(83.22,68.62) v1(83.35,69.25) v1(83.41,70.54) v1(83.37,69.89) v1(83.5,73.01) v1(83.46,71.81) v1(83.46,71.18) v1(85.28,73.66) v1(85.28,73.03) v1(85.28,72.39) v1(87.04,72.8) v1(87.05,73.64) v1(87.76,71.74) v1(87.76,71.11) v1(87.76,70.47) v1(87.76,69.84) v1(87.76,69.2) v1(88.92,73.7) v1(88.92,73.07) v1(88.92,72.43) v1(90.04,73.62) v1(90.04,72.99) v1(90.04,72.35) v1(97.72,81.32) v1(98.31,80.66) v1(98.36,81.32) v1(98.99,81.32) v1(98.97,80.66) v1(98.97,80.02) v1(99.63,81.32) v1(99.63,80.66) v1(99.63,80) v1(102.32,81.65) v1(102.32,81.01) v1(102.27,80.38) v1(102.91,80.38) v1(102.96,81.65) v1(102.96,81.01) v1(103.14,79.77) v1(103.59,80.22) v1(103.82,84.14) v1(104.02,79.74) v1(104.15,83.58) v1(104.46,84.14) v1(104.79,83.53) v1(105.09,84.14) v1(105.42,83.5) v1(105.73,79.92) v1(105.73,79.28) v1(106.28,80.22) v1(106.28,79.59) v1(106.26,78.93) v1(106.28,78.29) v1(106.28,77.66) v1(106.61,81.67) v1(106.61,81.04) v1(106.92,80.28) v1(106.92,79.64) v1(106.89,79.01) v1(106.92,78.37) v1(106.92,77.68) v1(107.83,81.19) v1(108.11,81.77) v1(108.47,81.19) v1(108.77,81.75) v1(109.1,81.19) v1(109.08,76.67) v1(109.28,80.22) v1(109.76,76.69) v2(85.31,78.99) v2(85.31,77.69) v2(85.31,76.39) v2(85.31,75.09) v2(87.1,78.99) v2(87.1,77.69) v2(87.1,77.04) v2(87.1,75.74) v2(87.1,75.09) v2(88.86,80.81) v2(88.98,80.22) v2(88.98,79.64) v2(88.98,78.99) v2(88.98,77.69) v2(88.98,77.04) v2(88.98,75.74) v2(88.98,75.09) v2(90.84,80.48) v2(90.77,79.74) v2(90.86,78.99) v2(90.86,77.69) v2(90.86,77.04) v2(90.86,75.74) v2(90.86,75.09) v2(91.5,70.39) v2(91.54,69.42) v2(91.55,81.9) v2(91.55,81.32) v2(91.67,73.17) v2(91.67,72.24) v2(91.84,79) v2(91.84,78.39) v2(91.84,77.1) v2(91.84,76.42) v2(92.84,70.4) v2(92.87,75.94) v2(92.87,74.09) v2(92.87,73.17) v2(92.87,72.24) v2(92.87,71.32) v2(93.89,76.86) v2(93.89,75.94) v2(93.89,74.09) v2(94.54,75.94)
+VCCGT_+VCORE: length 5.6
  BOTTOM w0.152: U1.AK2 97.32,61.88 97.88,61.33 v2(97.88,61.1) ; U1.AB2 97.31,66.76 97.88,66.19 v2(97.88,65.9) 97.72,65.75 97.72,64.72 97.32,64.32 U1.AF2
  BOTTOM w0.203: U1.V2 97.31,68.95 v2(97.85,68.95)
  vias: v1(83.17,63.54) v1(83.17,62.88) v1(90.94,68.3) v1(90.94,67.67) v1(90.94,66.64) v1(90.94,64.91) v1(90.94,62.42) v1(90.99,61.4) v1(91.4,61.96) v1(95.67,60.84) v2(82.56,63.38) v2(91.55,67.68) v2(91.55,66.65) v2(91.67,64.85) v2(92.84,66.7) v2(92.84,65.78) v2(92.84,64.85) v2(92.84,63.93) v2(92.87,62.09) v2(92.93,61.13) v2(92.98,62.95)
+VCCIO: length 177.5
  TOP w0.203: C80.2 86.93,47.97 v2(87.39,47.51) ; R72.2 80.38,47.71 80.38,48.59 80.61,48.82 80.9,48.82 81.19,49.11 81.19,49.77 v2(80.78,50.18)
  IN1 w0.254: v1(136.51,61.68) 136.13,61.3 133.26,61.3 132.4,62.17 131.74,62.17 129.65,64.25 125.33,64.25 124.76,64.82 117.07,64.82 115.1,62.85 v1(115.1,62.72)
  IN1 w0.508: v1(26.48,34.28) 26.54,34.28 27.56,33.26 29.33,33.26 30.47,32.12 32.69,32.12 33.58,31.23 36.01,31.23 37.01,32.22 41.09,32.22 43.61,29.7 44.89,29.7 45.27,29.32 46.52,29.32 46.82,29.63 v1(46.82,30.16) ; v1(102.3,56.37) 101.95,56.72 101.95,58.81 101.23,59.53 v2(101.23,62.09)
  IN2 w0.254: v1(110.96,67.83) 110.96,68.26 110.7,68.52 107.05,68.52 106.36,69.2 106.36,70.78 107,71.41 v1(107.12,71.41)
  IN2 w0.508: 76.52,49.26 75.37,48.12 75.37,46.85 74.99,46.47 74.99,45.45 73.85,44.31 73.85,43.17 72.58,41.9 72.58,40.63 71.7,39.75 70.15,39.75 68.36,37.96 68.36,37.2 ; v1(46.82,30.16) 46.82,31.58 47.23,31.99 48.63,31.99 49.29,31.33 61.68,31.33 63.73,33.39 64.58,33.39
  IN3 w0.254: v1(115.1,62.72) 115.1,63.77 110.99,67.88 110.98,67.88 110.96,67.85 v1(110.96,67.83)
  IN3 w0.508: v1(113.85,49.64) 114.82,49.64 115.43,50.25 117.46,50.25 120.08,47.64 122.54,47.64 122.95,47.23 122.95,45.83 123.76,45.02 125.87,45.02 127.68,43.21 129.89,43.21 130.52,42.58 130.52,41.08 132.57,39.03 132.57,35.44 134.53,33.49 135.09,33.49 135.63,32.94 136.75,32.94 137.45,32.24 138.59,32.24 v1(139.48,31.35) ; v1(115.1,62.72) 115.1,62.6 114.62,62.11 114.62,61.78 112.46,59.63 112.46,59.13 108.62,55.29 108.28,55.29 107.71,54.72 107.71,53.67 108.15,53.23 108.15,52.61 109.89,50.87 110.39,50.87 111.19,50.07 v1(111.19,49.94)
  BOTTOM w0.203: PC756.1 138.27,30.9 PR22.2
  BOTTOM w0.254: v1(136.51,61.68) 136.77,61.43 PR7011.2 ; U1.BP16 88.15,47.57 v2(88.15,48.22) ; v2(87.39,47.51) 87.34,47.51 87.31,47.48 87.22,47.48 U1.BP18 ; 106.4,71.66 106.87,71.66 v1(107.12,71.41)
  BOTTOM w0.381: R69.1 101.88,56.79 v1(102.3,56.37)
  BOTTOM w0.508: v2(101.23,62.09) 101.67,62.53 R2.1 ; PR111.1 23.04,33.12 23.43,33.51 25.72,33.51 v1(26.48,34.28) ; v1(139.48,31.35) 139.39,31.27 PC756.1
  vias: v1(103.77,40.04) v1(103.77,39.41) v1(104.41,40.04) v1(104.41,39.41) v1(104.41,38.77) v1(105.01,40.25) v1(105.01,39.61) v1(105.01,38.98) v1(105.42,41.31) v1(105.95,41.9) v2(80.67,62.01) v2(80.67,61.1) v2(80.67,60.19) v2(82.54,61.56) v2(82.52,60.65) v5(80.83,51.07) v5(81.47,50.63)
+VCCLDOSRAM_1P24: length 2.9
  BOTTOM w0.254: U1.CA24 82.91,42.66 v2(83.24,42.34) 83.56,42.66 U1.CA23 ; U1.BY23 83.56,43.31 v2(83.24,42.99) 82.91,43.31 U1.BY24
  BOTTOM w0.381: v1(82.69,29.88) 82.7,29.89 R211.2
  vias: v1(82.64,34.07) v1(82.94,30.49)
+VCCPLL: length 1.5
  BOTTOM w0.254: U1.BR11 91.56,46.56 v2(91.78,46.34) 91.61,46.34 91.18,45.91 U1.BT11
  vias: v1(107.83,43.52)
+VCCPLL_OC: length 22.5
  TOP w0.508: 76.64,50.02 74.91,50.02 70.9,46.01 69.78,46.01 69.4,46.39 69.4,46.98 69.73,47.31 69.73,48.68 69.6,48.81 69.6,49.71 69.66,49.77 69.66,53.95 69.28,54.33 66.09,54.33 65.72,53.96
  BOTTOM w0.305: v2(80.63,49.31) 80.71,49.31 80.81,49.22 80.81,48.98 U1.BL27 81.15,48.8 81.45,48.49 U1.BM26
  vias: v1(77.48,50.61)
+VCCRTC: length 29.2
  TOP w0.508: 67.09,26.91 67.09,30.6 67.76,31.27 68.66,31.27 69.71,32.32 70.24,32.32 70.45,32.52 74.33,32.52 75.95,34.14 v1(75.99,34.14)
  IN2 w0.508: 81.72,44.94 81.44,44.66 81.44,39.1 80.48,38.14 80.48,36.97 79.56,36.05 78.19,36.05 77.71,35.57 76.54,35.57 75.99,35.02 v1(75.99,34.14)
  BOTTOM w0.254: v2(83.24,46.89) 83.56,46.56 U1.BR23
+VCCSA:
  vias: v1(107.76,49.92) v1(108.72,49.92) v1(109.82,49.92) v1(110.45,49.92) v1(115.45,47.23) v1(121.98,43.67) v1(122.08,42.15) v1(122.62,43.67) v1(122.72,42.15) v1(123.02,39.03) v1(123.25,43.8) v1(123.35,41.11) v1(123.68,39.74) v1(123.68,39.1) v1(123.76,43.29) v1(123.79,38.47) v1(124.32,39.74) v1(124.32,39.1) v1(124.42,38.47) v2(82.64,49.72) v2(82.66,50.66) v2(83.25,50.66) v2(83.17,50.02) v2(83.17,49.39) v2(90.92,51) v2(90.92,49.97) v2(91.5,51) v2(91.55,48.27) v2(92.98,50.02) v3(115.2,42.86) v3(115.94,42.86) v3(116.67,42.89) v3(117.99,42.86) v3(118.73,42.86)
+VCCST: length 114.9
  TOP w0.203: v1(107.12,74.33) 106.44,74.33 105.62,73.52 R11.1 105.19,73.87 105.6,74.28 105.6,74.54 105.03,75.11 104.14,75.11 104.05,75.2 R15.1 ; R12.1 104.05,76.82 104.3,77.08 v1(104.48,77.08) ; R19.1 101.89,72.55 101.68,72.76 v2(101.41,72.76) ; R14.1 105.95,71.64 106.46,71.13 R22.2 106.82,70.77 v1(107.12,70.47)
  TOP w0.508: v2(140.17,31.43) 140.9,32.17 Q85.3 142.07,33.35 R822.2
  IN1 w0.381: v1(108.62,46.77) 108.62,47.16 105.84,49.94 105.4,49.94 104.13,51.22 104.13,54.62 v1(103.54,55.21) 103.16,55.59 103.16,56.59 102.84,56.91 102.84,59 101.93,59.91 101.93,65.76 v1(101.2,66.48) 101.38,66.66 101.38,67.37 101.08,67.68 101.08,70.47 100.65,70.9 100.65,72.27 101.13,72.76 v2(101.41,72.76)
  IN2 w0.254: v1(104.58,71.49) 102.68,71.49 v2(101.41,72.76) 101.41,73.52 104.48,76.59 v1(104.48,77.08) 104.76,77.08 105.32,76.52 105.32,75.58 106.56,74.33 v1(107.12,74.33)
  IN2 w0.381: v2(109.87,29.78) 110.34,30.25 118.42,30.25 118.61,30.44 123.26,30.44 125.18,32.36 128.56,32.36 128.84,32.64 134,32.64 134.4,32.24 135.69,32.24 136.23,31.7 138.68,31.7 138.95,31.96 139.81,31.96 140.17,31.61 v2(140.17,31.43)
  IN3 w0.508: v2(109.87,29.78) 110.5,30.42 110.5,33.09 109.41,34.18 109.41,39.05 108.62,39.84 v1(108.62,46.77)
  BOTTOM w0.178: v2(98.36,46.9) 98.33,46.93 98,46.93 97.69,47.24 U1.BP2
  BOTTOM w0.203: v1(103.54,55.21) 103.06,54.72 R52.2 ; R13.1 v2(101.41,72.76) ; v1(101.2,66.48) 101.2,67.06 100.97,67.3 R10.1
  BOTTOM w0.254: U1.BP11 91.14,47.21 v2(90.8,47.56) ; R65.1 R63.2 106.73,70.47 v1(107.12,70.47) ; v1(104.58,71.49) 104.16,71.49 R67.1
  vias: v1(107.88,45.93)
+VCCSTG: length 6.8
  BOTTOM w0.203: U1.BG3 U1.BG2 U1.BG1 97.47,51.56 97.47,52.13 97.94,52.6
  BOTTOM w0.508: 100.47,55.31 100.47,54.57 99.66,53.76 99.66,53.61 98.89,52.84 98.18,52.84 97.94,52.6
+VDDQ: length 39
  TOP w0.508: v1(51.54,100.09) v1(50.81,100.09) 49.86,100.09 R263.1
  IN1 w0.508: v1(69.23,123.06) 68.07,121.91 67.12,121.91 66.44,121.23 64.57,121.23 63.91,120.57 63.91,112.06 64.06,111.9 64.06,107.35 v1(63.97,107.25)
  IN2 w0.508: v1(51.54,100.09) 51.75,100.09 54.75,103.08 55.79,103.08 57.24,104.53 58.25,104.53 60.56,106.84 63.61,106.84 63.97,107.2 v1(63.97,107.25)
  BOTTOM w0.508: PR254.2 PC280.1 v1(69.23,123.06)
+VDDQ_VTT: length 161.3
  TOP w0.254: R294.1 30.55,42.42 29.73,43.24 v1(28.05,43.24) 26.66,43.24 v1(25.92,42.51)
  TOP w0.508: v1(68.9,119.62) 68.37,120.14 PC299.1 ; R274.1 29.14,95.24 ; v1(48.58,30.14) 49.02,30.58 C261.1 C257.1 C253.1 C255.1 C251.1 C259.1 46.74,29.33 46.14,29.93 v1(46.14,30.47) ; v1(24.4,104.56) 28.64,100.32 28.64,98.54
  IN1 w0.508: v1(27.44,85.33) 27.44,85.03 26.73,84.31 26.73,83.04 27.58,82.2 27.58,81.48 27.24,81.14 26.71,81.14 26.33,80.76 26.33,74.65 27.07,73.9 27.75,73.9 28.38,73.27 28.38,68.31 26.83,66.76 26.83,65.36 26.01,64.53 26.01,42.59 v1(25.92,42.51) 25.16,41.74 25.16,39.15 27.37,36.94 27.37,34.53 27.87,34.02 29.64,34.02 30.79,32.88 34.86,32.88 34.97,32.99 41.41,32.99 43.8,30.59 45.59,30.59 45.72,30.47 v1(46.14,30.47)
  IN2 w0.508: v1(24.4,104.56) 25.84,106.01 37.65,106.01 41.18,109.54 41.18,111.95 41.69,112.46 41.69,115.18 42.99,116.47 v1(42.99,116.57)
  IN3 w0.508: v1(42.99,116.57) 46.92,120.51 48,120.51 50.9,123.4 56.35,123.4 56.83,123.89 63.59,123.89 63.97,124.27 66.03,124.27 68.01,122.29 68.01,120.51 v1(68.9,119.62)
  BOTTOM w0.254: JDIM1.258 48.76,29.95 v1(48.58,30.14)
+VIN: length 121.8
  TOP w0.152: PR2.1 52.08,114.18 52.08,116.06 52.34,116.32 PR3.2
  TOP w0.508: PR9102.1 118.87,125.69 95.79,125.69 95.18,125.08 95.18,122.18 94.84,121.84 94.84,121.23 94.24,120.63 94.24,117.97 93.7,117.42 87.08,117.42 86.04,116.38 81.15,116.38 80.45,117.08 80.45,118.22 79.56,119.11 72.96,119.11 72.46,119.61 PC9001.1 ; PR116.1 PR59.1 26.42,38.98 v1(26.22,38.98)
  IN3 w0.508: v2(112.58,42.53) 113.45,42.53 114.77,41.21 114.77,39.69 117.18,37.27 117.18,36.51 119.65,34.05 119.65,32.6 v2(119.67,32.57)
  BOTTOM w0.229: PU6003.5 46.09,19.88 46.18,19.79 PC6031.2
  BOTTOM w0.254: PU16.22 118.54,38.19 PU16.24 ; PU9004.24 138.56,66.79 PU9004.22
  BOTTOM w0.381: PR79.1 112.25,42.86 v2(112.58,42.53)
  BOTTOM w0.508: v1(26.22,38.98) 26.22,38.37 27.14,37.45 27.49,37.45 28.97,35.98 28.97,34 31.74,31.23 37.04,31.23 38.19,32.37 43.92,32.37 45.05,31.25 45.05,28.15 46.77,26.43 46.77,23.76 48.5,22.03 48.5,19.5 48.93,19.07
  vias: v1(54.8,117.54) v1(55.31,117.08) v1(55.43,117.72) v1(55.94,117.08) v1(56.07,118.35) v1(56.07,117.72) v1(56.58,117.08) v1(56.7,118.35) v1(56.7,117.72) v1(57.24,116.95) v1(64.58,117.03) v1(64.82,120.53) v1(64.82,119.9) v1(64.82,119.26) v1(65.21,117.03) v1(65.92,109.87) v1(66.33,109.36) v1(69.4,123.81) v1(70.04,123.81) v1(70.04,123.18) v1(70.67,123.81) v1(70.67,123.18) v1(76.19,14.36) v1(76.82,14.36) v1(77.46,14.36) v1(78.09,14.36) v1(78.73,14.36) v1(79.36,14.36) v1(79.82,105.04) v1(80.45,105.04) v1(81.1,105.04) v1(81.74,105.04) v1(82.38,105.04) v1(83.02,105.04) v1(120.11,32.13) v1(120.38,32.76) v1(120.74,32.13) v1(121.02,32.76) v1(121.27,73.85) v1(121.37,46.96) v1(121.38,32.13) v1(121.65,32.76) v1(121.78,74.31) v1(122.01,46.96) v1(122.01,32.14) v1(122.29,74.76) v1(122.29,32.76) v1(122.85,75.27) v1(124.24,46.96) v1(125.51,76.62) v1(125.56,46.75) v1(125.94,77.1) v1(126.2,46.75) v1(126.83,46.75) v1(127.47,46.75) v1(129.6,38.49) v1(132.04,73.9) v1(132.7,73.9) v1(132.7,73.24) v1(132.7,72.58) v1(132.7,71.92) v1(133.36,73.9) v1(133.36,73.24) v1(134.02,73.9) v1(134.02,73.24) v1(138.44,37.07) v1(138.8,63.41) v1(138.82,62.77) v1(139.08,37.07) v1(139.43,63.41) v1(139.46,62.75) v1(139.71,37.07) v1(140.35,37.07) v1(140.98,37.07) v1(141.62,37.07) v1(142.71,36.03)
