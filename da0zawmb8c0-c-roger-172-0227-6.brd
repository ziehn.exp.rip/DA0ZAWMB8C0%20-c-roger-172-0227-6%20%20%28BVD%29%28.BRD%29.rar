# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MY1: length 69.5
  TOP w0.102: v1(151.62,18.15) 152.16,18.68 v2(152.16,18.81) 151.57,19.39 C716.1 ; U37.37 186.45,14.87 186.45,14.87 186.45,16.24 186.04,16.65 186.04,16.84 186.02,16.86 v2(186.02,16.88)
  IN3 w0.089: v2(129.86,23.99) 130.45,23.4 130.45,22.77 131.59,21.62 142.97,21.62 145.41,19.18 151.78,19.18 v2(152.16,18.81) 152.53,18.43 152.85,18.43 153.58,17.7 158.32,17.7 160.06,15.96 181.81,15.96 182.41,16.55 185.01,16.55 185.38,16.92 185.96,16.92 186,16.88 v2(186.02,16.88)
  BOTTOM w0.102: v2(152.16,18.81) 151,19.96 CN18.25 ; v2(129.86,23.99) 129.4,24.45 CN19.25
MY2: length 68.9
  TOP w0.102: C717.1 v1(152.33,19.62) 152.33,19.21 v2(152.74,18.81) ; U37.38 186.85,15 186.7,15.15 186.7,16.49 186.65,16.54 186.65,16.62 v2(186.6,16.67)
  IN3 w0.089: v2(130.49,23.99) 130.64,23.84 130.64,22.84 131.67,21.81 143.05,21.81 145.47,19.39 152.16,19.39 v2(152.74,18.81) 153.66,17.89 158.4,17.89 160.14,16.15 176.88,16.15 177.55,16.82 183.19,16.82 184.2,17.84 185.59,17.84 186.61,16.81 186.61,16.68 v2(186.6,16.67)
  BOTTOM w0.102: v2(130.49,23.99) 130.4,24.08 CN19.24 ; CN18.24 152,19.55 v2(152.74,18.81)
MY3: length 70.1
  TOP w0.102: C708.1 153.1,19.04 v2(153.33,18.81) 152.97,18.45 v1(152.97,17.84) ; v2(186.47,17.49) 187.08,16.88 187.08,15.23 187.25,15.06 U37.39
  IN3 w0.089: v2(131.13,23.99) 130.83,23.69 130.83,22.92 131.75,22 143.13,22 145.55,19.58 152.55,19.58 v2(153.33,18.81) 154.06,18.08 158.48,18.08 160.22,16.34 176.8,16.34 177.48,17.01 183.11,17.01 184.12,18.03 185.67,18.03 186.21,17.49 v2(186.47,17.49)
  BOTTOM w0.102: v2(131.13,23.99) 131.4,24.26 CN19.23 ; CN18.23 153,19.13 v2(153.33,18.81)
MY4: length 68.6
  TOP w0.102: C718.1 153.86,18.86 v2(153.91,18.81) ; U37.40 187.65,14.99 187.31,15.32 187.31,17.23 v2(187.06,17.49)
  IN3 w0.089: v2(187.06,17.49) 186.68,17.86 186.1,17.86 185.74,18.22 184.04,18.22 183.03,17.2 177.4,17.2 177.29,17.1 176.27,17.1 175.7,17.67 174.2,17.67 173.05,16.53 160.3,16.53 158.56,18.27 154.53,18.27 153.94,18.86 153.93,18.86 153.91,18.83 ; v1(132.01,23.74) 132.32,23.43 132.32,22.75 132.88,22.19 143.21,22.19 145.63,19.77 152.63,19.77 152.91,19.49 153.3,19.49 153.91,18.88 153.91,18.83 ; 153.91,18.83 v2(153.91,18.81)
  BOTTOM w0.102: CN19.22 132.4,24.12 v1(132.01,23.74) ; CN18.22 154,18.97 153.91,18.88 v2(153.91,18.81)
MY5: length 70.1
  TOP w0.102: U37.41 188.05,15.38 188.71,16.04 188.71,16.88 188.48,17.11 v2(188.48,17.18) ; v2(156.22,19.21) 156.16,19.26 156.14,19.26 156.04,19.37 C707.1
  IN3 w0.089: v2(132.9,23.74) 132.52,23.35 132.52,22.81 132.95,22.38 143.29,22.38 145.71,19.96 153.36,19.96 154.26,19.06 155.47,19.06 155.64,19.24 156.19,19.24 v2(156.22,19.21) 156.22,18.71 156.47,18.46 158.64,18.46 160.38,16.72 172.97,16.72 174.12,17.86 175.79,17.86 176.36,17.29 177.12,17.29 177.22,17.39 182.95,17.39 183.96,18.41 185.82,18.41 186.18,18.05 187.04,18.05 187.44,17.66 187.44,17.44 187.77,17.11 188.45,17.11 188.48,17.13 v2(188.48,17.18)
  BOTTOM w0.102: v2(156.22,19.21) 156.19,19.23 155.57,19.23 155,19.8 CN18.21 ; CN19.21 133.4,24.74 133.08,24.42 133.08,23.91 v2(132.9,23.74)
MY6: length 69.4
  TOP w0.102: U37.42 188.45,15.45 188.94,15.94 188.94,17.37 188.71,17.59 188.05,17.59 v2(188.02,17.61) ; C706.1 156.75,19.59 156.81,19.54 v2(156.81,19.21)
  IN3 w0.089: v2(132.93,22.97) 133.33,22.57 143.37,22.57 145.79,20.15 155.9,20.15 156.7,19.35 156.7,19.33 156.81,19.23 v2(156.81,19.21) 156.81,18.93 157.09,18.65 158.72,18.65 160.46,16.91 172.89,16.91 174.04,18.05 175.87,18.05 176.45,17.48 176.89,17.48 176.99,17.58 182.87,17.58 183.89,18.6 185.9,18.6 186.26,18.24 187.12,18.24 187.75,17.61 v2(188.02,17.61)
  BOTTOM w0.102: CN18.20 156,20.07 156.77,19.3 156.77,19.24 v2(156.81,19.21) ; CN19.20 134.4,24.85 134.08,24.53 133.57,24.53 133.31,24.27 133.31,23.56 132.93,23.18 v2(132.93,22.97)
MY7: length 69
  TOP w0.102: v2(188.46,17.99) 188.63,17.99 189.16,17.46 189.16,15.85 188.85,15.53 U37.43 ; v2(157.4,19.21) 157.47,19.28 C709.1
  IN3 w0.089: v2(133.95,23.02) 134.13,22.84 143.37,22.84 145.87,20.34 155.98,20.34 156.69,19.63 156.97,19.63 v2(157.4,19.21) 157.4,18.97 157.52,18.84 158.8,18.84 158.97,18.66 160.54,17.1 172.82,17.1 173.96,18.24 175.96,18.24 176.43,17.77 182.79,17.77 183.81,18.79 185.98,18.79 186.34,18.43 187.2,18.43 187.58,18.05 188.41,18.05 v2(188.46,17.99)
  BOTTOM w0.102: v2(157.4,19.21) 157.29,19.32 157.29,19.67 157,19.96 CN18.19 ; v2(133.95,23.02) 133.54,23.43 133.54,24.17 133.66,24.3 134.38,24.3 134.58,24.5 134.94,24.5 135.4,24.96 CN19.19
MY8: length 70.4
  TOP w0.102: C711.1 158.18,19.39 v2(158,19.21) ; v2(189.6,17.99) 190.01,17.57 190.01,15.65 189.25,14.88 U37.44
  IN3 w0.089: v2(133.95,23.61) 134.52,23.03 143.45,23.03 145.95,20.53 156.06,20.53 156.77,19.82 157.9,19.82 158.18,19.54 158.18,19.39 v2(158,19.21) 158.69,19.21 160.62,17.29 172.74,17.29 173.88,18.43 176.03,18.43 176.5,17.96 182.71,17.96 183.73,18.98 186.06,18.98 186.42,18.62 187.28,18.62 187.66,18.24 187.99,18.24 188.15,18.4 189.18,18.4 v2(189.6,17.99)
  BOTTOM w0.102: CN18.18 v2(158,19.21) ; CN19.18 136.4,24.69 136.24,24.53 135.35,24.53 135.06,24.24 134.73,24.24 134.55,24.07 134.13,24.07 133.95,23.89 v2(133.95,23.61)
MY9: length 69
  TOP w0.102: v2(188.43,18.78) 188.78,19.14 189.88,19.14 190.24,18.77 190.24,15.51 189.65,14.91 U37.45 ; v2(159.8,19.24) 159.6,19.44 C713.1
  IN3 w0.089: v2(136.03,24.12) 136.67,23.48 143.54,23.48 146.1,20.91 156.21,20.91 156.92,20.2 158.18,20.2 158.55,19.84 159.21,19.84 v2(159.8,19.24) 159.8,18.64 160.52,17.93 163.17,17.93 163.59,18.35 164.03,18.35 164.71,17.67 168.15,17.67 168.79,18.31 172.99,18.31 173.49,18.81 176.19,18.81 176.66,18.34 182.55,18.34 183.57,19.36 186.22,19.36 186.58,19 188.21,19 v2(188.43,18.78)
  BOTTOM w0.102: CN18.17 159,19.86 159.17,19.7 159.68,19.7 159.8,19.57 v2(159.8,19.24) ; v2(136.03,24.12) 136.26,24.12 136.47,24.33 137.06,24.33 137.4,24.67 CN19.17
MY10: length 71.9
  TOP w0.102: C714.1 158.89,19.57 v2(159.19,19.26) ; U37.46 190.05,14.93 190.47,15.35 190.47,18.92 190.03,19.37 188.3,19.37 187.82,18.88 v2(187.82,18.62)
  IN3 w0.089: v2(187.82,18.62) 187.62,18.81 186.5,18.81 186.14,19.17 183.65,19.17 182.63,18.15 176.58,18.15 176.11,18.62 173.57,18.62 173.07,18.12 168.87,18.12 168.23,17.48 160.7,17.48 159.19,18.98 v2(159.19,19.26) 158.81,19.65 158.47,19.65 158.1,20.01 156.84,20.01 156.13,20.72 146.03,20.72 143.52,23.23 136.16,23.23 v2(135.82,23.56)
  BOTTOM w0.102: CN19.16 138.4,24.43 138.07,24.1 136.63,24.1 136.08,23.56 v2(135.82,23.56) ; v2(159.19,19.26) 159.19,19.09 159.5,18.78 160.03,18.78 160.29,19.04 160.29,19.59 160,19.88 CN18.16
MY11: length 65.5
  TOP w0.102: v2(192.04,15.99) 192.04,15.99 192.04,15.89 192.05,15.88 U37.51 ; v2(160.77,19.26) 160.31,19.72 C715.1
  IN3 w0.089: v2(192.04,15.99) 192.04,16.19 191.53,16.7 191.53,16.84 191.12,17.25 191.12,18.16 189.71,19.58 187.61,19.58 187.03,20.15 186.42,20.15 186.2,19.93 183.33,19.93 182.99,19.59 173.46,19.59 172.75,18.88 168.56,18.88 167.91,18.24 164.94,18.24 164.26,18.92 163.35,18.92 162.93,18.5 161.53,18.5 v2(160.77,19.26) 160.77,19.54 159.9,20.41 158.79,20.41 158.42,20.78 157.18,20.78 155.79,22.17 153.22,22.17 153.2,22.15 145.68,22.15 142.02,25.81 141.11,25.81 v2(139.97,26.95)
  BOTTOM w0.102: v2(139.97,26.95) 139.97,26.35 139.4,25.79 CN19.15 ; v2(160.77,19.26) 161,19.5 CN18.15
MY12: length 65.4
  TOP w0.102: C728.1 161.02,19.62 v2(161.36,19.28) ; U37.52 192.45,16.16 191.98,16.62 v2(191.98,16.8)
  IN3 w0.089: v2(140.56,26.99) 141.55,26 142.1,26 145.76,22.34 153.12,22.34 153.14,22.36 155.86,22.36 157.25,20.97 158.5,20.97 158.87,20.6 159.98,20.6 160.91,19.67 161.1,19.67 161.36,19.4 v2(161.36,19.28) 161.36,19.03 161.7,18.69 162.85,18.69 163.27,19.11 164.34,19.11 165.02,18.43 167.43,18.43 168.78,19.78 182.91,19.78 183.25,20.12 186.12,20.12 186.34,20.34 187.11,20.34 187.68,19.77 189.79,19.77 191.31,18.24 191.31,17.32 191.84,16.8 v2(191.98,16.8)
  BOTTOM w0.102: v2(161.36,19.28) 161.36,19.4 161.65,19.69 161.73,19.69 162,19.96 CN18.14 ; CN19.14 140.4,26.82 v2(140.56,26.99)
MY13: length 66.9
  TOP w0.102: v1(192.49,12.64) 192.85,12.99 U37.53 192.85,15.06 192.67,15.23 192.67,16.55 v2(192.57,16.65) ; v2(161.95,19.28) 161.73,19.49 C729.1
  IN3 w0.089: v2(192.57,16.65) 192.55,16.65 192.39,16.8 192.39,16.95 192.17,17.18 191.98,17.18 191.5,17.66 191.5,18.32 189.87,19.96 187.76,19.96 187.19,20.53 186.27,20.53 186.04,20.31 183.17,20.31 182.83,19.97 168.67,19.97 167.32,18.62 165.1,18.62 164.42,19.3 163.19,19.3 162.77,18.88 162.34,18.88 v2(161.95,19.28) 160.82,20.41 160.44,20.41 160.06,20.79 158.95,20.79 158.58,21.16 157.33,21.16 155.94,22.55 153.06,22.55 153.04,22.53 145.84,22.53 142.17,26.19 141.91,26.19 v2(141.16,26.95)
  BOTTOM w0.102: CN19.13 141.4,26.7 v2(141.16,26.95) ; v2(161.95,19.28) 162.39,19.72 162.88,19.72 163,19.85 CN18.13
MY14: length 66.9
  TOP w0.102: C730.1 162.44,19.37 v2(162.55,19.26) ; v2(193.1,15.99) 193.25,15.84 U37.54 193.25,13.15 v1(193.76,12.64)
  IN3 w0.089: v2(193.1,15.99) 192.95,16.14 192.95,16.8 192.38,17.37 192.06,17.37 191.69,17.74 191.69,18.4 189.95,20.15 187.84,20.15 187.27,20.73 186.19,20.73 185.96,20.5 180.66,20.5 180.26,20.9 177.32,20.9 176.58,20.16 168.59,20.16 167.24,18.81 165.18,18.81 164.5,19.49 162.77,19.49 v2(162.55,19.26) 161.21,20.6 160.52,20.6 160.12,20.99 159.01,20.99 157.27,22.74 152.98,22.74 152.96,22.72 145.92,22.72 142.35,26.29 142.35,26.38 v2(141.97,26.76)
  BOTTOM w0.102: v2(141.97,26.76) 141.97,26.38 142.4,25.95 CN19.12 ; v2(162.55,19.26) 163.35,19.26 164,19.92 CN18.12
MY15: length 66.7
  TOP w0.102: v2(166.3,19.37) 166.3,19.42 166.74,19.85 C731.1 ; U37.55 193.65,15.28 193.51,15.42 193.51,15.85 193.66,16 v2(193.66,16.22)
  IN3 w0.089: v2(193.66,16.22) 193.73,16.29 193.73,16.88 193.05,17.56 192.32,17.56 191.88,17.99 191.88,18.48 190.02,20.34 187.92,20.34 187.34,20.92 186.11,20.92 185.88,20.69 180.74,20.69 180.34,21.09 177.24,21.09 176.5,20.35 168.51,20.35 167.17,19 166.54,19 166.3,19.24 v2(166.3,19.37) 166.3,19.42 165.47,20.25 164.21,20.25 162.47,21.99 158.28,21.99 157.34,22.93 152.9,22.93 152.88,22.91 146,22.91 142.56,26.35 v2(142.56,26.76)
  BOTTOM w0.102: v2(142.56,26.76) 142.56,26.48 143.4,25.63 CN19.11 ; v2(166.3,19.37) 166.3,19.04 166.2,18.93 165.14,18.93 165,19.07 CN18.11
MY16: length 83.5
  TOP w0.102: v2(148.98,21.53) 148.98,21.3 149.34,20.94 C732.1 ; v1(195.03,12.64) 194.68,12.64 194.05,13.27 U37.56 194.05,14.95 194.5,15.4 v2(194.5,15.58)
  IN3 w0.089: v2(194.5,15.58) 194.23,15.31 192.17,15.31 191.34,16.14 191.34,16.76 190.93,17.17 190.93,18.08 189.63,19.39 186.73,19.39 186.38,19.74 183.41,19.74 182.4,18.72 176.82,18.72 176.35,19.19 173.34,19.19 172.83,18.69 168.63,18.69 167.99,18.05 164.87,18.05 164.19,18.73 163.43,18.73 163.01,18.31 161.02,18.31 160.37,18.96 160.37,19.67 159.82,20.22 158.71,20.22 158.34,20.59 157.1,20.59 155.71,21.98 153.37,21.98 153.35,21.96 149.42,21.96 148.99,21.53 v2(148.98,21.53) 148.58,21.93 145.63,21.93 143.68,23.87 137.08,23.87 136.27,24.68 135.51,24.68 135.46,24.64 128.7,24.64 v2(127.95,23.89)
  BOTTOM w0.102: v2(148.98,21.53) 148.8,21.53 148,20.72 CN18.28 ; v2(127.95,23.89) 127.95,23.91 127.34,24.53 126.52,24.53 126.4,24.65 CN19.28
MY17: length 81.8
  TOP w0.102: v2(194.56,16.17) 194.91,15.82 194.91,15.4 194.45,14.94 U37.57 ; v2(149.57,21.53) 149.67,21.63 C733.1
  IN3 w0.089: v2(128.54,23.89) 129.09,24.45 135.54,24.45 135.58,24.49 136.19,24.49 137,23.68 143.6,23.68 146.16,21.13 149.13,21.13 149.53,21.53 v2(149.57,21.53) 149.99,21.11 156.29,21.11 157,20.39 158.26,20.39 158.63,20.03 159.74,20.03 160.18,19.59 160.18,18.76 160.81,18.12 163.09,18.12 163.51,18.54 164.11,18.54 164.79,17.86 168.07,17.86 168.71,18.5 172.91,18.5 173.41,19 176.27,19 176.74,18.53 182.47,18.53 183.49,19.55 186.3,19.55 186.65,19.19 189.54,19.19 190.56,18.17 190.56,17.27 191.15,16.68 191.15,16.06 192.09,15.12 194.57,15.12 194.9,15.45 194.9,15.82 v2(194.56,16.17)
  BOTTOM w0.102: v2(149.57,21.53) 149,20.96 CN18.27 ; CN19.27 127.4,24.79 127.7,24.5 128.19,24.5 128.54,24.15 v2(128.54,23.89)
N12E_SCL: length 10.1
  BOTTOM w0.102: R367.1 95.31,90.05 96.53,90.05 97.03,90.55 98.62,90.55 99.68,91.61 100.11,91.61 100.47,91.96 100.47,92.63 100.31,92.78 100.31,93.51 100.51,93.7 100.51,93.95 100.91,94.35 U8.C9
N12E_SDA: length 10.1
  BOTTOM w0.102: U8.C8 100.07,94.35 99.63,93.91 99.63,91.88 98.52,90.78 96.94,90.78 96.44,90.28 94.57,90.28 R368.1
NBSWON#: length 68.6
  TOP w0.102: R25314.1 193.15,31.64 v2(193.15,31.4) 193.15,30.68 193.25,30.58 U37.107 ; v2(152.33,24.24) 152.33,24.22 151.09,22.97 149.85,22.97 148.58,21.69 148.58,21.02 148.88,20.71 R720.2 v1(149.64,20.18) 149.72,20.1 149.72,19.66 D34.2
  IN2 w0.089: v2(152.33,24.24) 153.03,23.55 158.14,23.55 158.5,23.2 164.88,23.2 165.17,23.48 167.68,23.48 168.4,24.19 168.87,24.19 v2(168.95,24.27)
  IN3 w0.089: v2(170.72,32.37) 170.85,32.5 174.18,32.5 174.64,32.04 175.83,32.04 176.08,31.79 182.72,31.79 183.63,32.71 187.14,32.71 187.99,33.56 189.91,33.56 190.45,33.02 191.87,33.02 193.15,31.74 v2(193.15,31.4)
  BOTTOM w0.102: C6615.2 171.52,23.22 171.05,23.68 170.17,23.68 169.58,24.27 v2(168.95,24.27) 168.95,25.97 168.4,26.52 SW1.1 168.4,27.63 168.84,28.08 168.84,29.89 SW1.2 169.18,30.34 170.52,31.69 170.52,32.12 170.72,32.32 v2(170.72,32.37) ; v2(152.33,24.24) 153,24.24 153.4,24.65 CN19.1
NGFF_SATA_DET: length 94.9
  TOP w0.102: R653.1 28.2,5.35 v1(28.36,5.35)
  IN3 w0.089: v1(28.36,5.35) 28.33,5.32 28.33,5.32 28.37,5.28 32.36,5.28 32.84,4.8 36.93,4.8 41.45,9.32 43.61,9.32 46.99,12.71 46.99,12.85 49.24,15.1 49.54,15.1 49.87,15.42 71.44,15.42 72.73,16.72 78.07,16.72 83.5,22.15 89.69,22.15 90.75,21.08 95.07,21.08 96.07,22.08 96.07,23.66 95.39,24.34 95.39,25.42 94.92,25.89 94.02,25.89 92.9,27.01 v2(92.82,27.01)
  BOTTOM w0.079: U1.CP10 92.01,34.83 92.01,34.35 91.87,34.21 91.87,33.71 92.09,33.49 92.09,33.08 92.92,32.24
  BOTTOM w0.102: 92.92,32.24 93.23,31.94 93.23,29.24 92.64,28.66 v1(92.64,28.59) 92.64,27.19 v2(92.82,27.01) 93.17,26.66 R134.1
NV_PLLVDD: length 13.2
  TOP w0.254: L7.2 88.72,106.03 C457.2 89.46,106.28 89.72,106.54 91.5,106.54 93.71,104.33 94.7,104.33 96.81,102.22 v1(97.29,102.22) 97.4,102.22 v2(97.95,101.67) 98.09,101.67 C458.2
  BOTTOM w0.254: U8.L6 v2(97.95,101.67)
ODD_PRSNT#: length 80.7
  TOP w0.102: v2(92.39,25.87) 92.72,25.54 92.72,24.88 92.62,24.78 91.74,24.78 91.56,24.96 91.4,24.96 90.89,25.46 R25475.2
  IN2 w0.089: v2(100.82,20.15) 100.82,21.1 96.73,25.19 95.38,25.19 94.98,25.59 92.67,25.59 v2(92.39,25.87)
  IN3 w0.089: v2(100.82,20.15) 100.82,18.66 97.47,15.3 v2(97.47,14.78)
  BOTTOM w0.079: U1.CP14 89.5,34.96 89.5,33.81 89.22,33.53 89.22,33.18 89.48,32.93 90.01,32.93 90.95,32 90.95,31.94
  BOTTOM w0.102: v2(97.47,14.78) 97.47,14.49 97.62,14.34 113.5,14.34 114.14,14.97 118.4,14.97 119.04,14.34 125.05,14.34 125.32,14.6 125.32,15.74 125.87,16.29 127.43,16.29 127.74,15.99 137.17,15.99 139.52,18.34 C780.1 140.05,19.7 R640.2 ; v2(92.39,25.87) 91.93,26.33 91.5,26.33 91.15,26.68 91.15,27.1 90.97,27.28 90.97,28.1 90.87,28.2 90.87,30.94 90.95,31.02 90.95,31.94
ODD_PRSNT#_C: length 10.8
  BOTTOM w0.102: R640.1 140.15,20.15 140,20.3 R641.1 C779.1 138.49,19.7 138.28,19.48 138.28,19.02 137.18,17.93 137.18,16.96 136.71,16.5 133.79,16.5 133.35,16.94 CN15.8
PBA_FP_PWREN#: length 162.3
  TOP w0.102: U37.76 198.18,20.18 197.76,19.77 v2(197.75,19.77) ; R609.1 52.64,16.75 51.95,16.06 v2(51.95,15.8)
  IN2 w0.089: v2(51.95,15.8) 51.99,15.76 56.45,15.76 57.15,16.46 58.01,16.46 58.95,15.53 72.04,15.53 72.98,16.47 79.4,16.47 84.17,21.25 88.42,21.25 93.65,16.01 94.65,16.01 95.12,15.55 95.75,15.55 96.05,15.25 96.43,15.25 96.7,15.52 99.64,15.52 100.32,14.84 107.56,14.84 108.78,16.06 113.03,16.06 114.3,17.33 118.69,17.33 119.15,17.8 120.64,17.8 121.47,18.62 123.73,18.62 124.22,18.13 128.5,18.13 129.17,17.47 136.86,17.47 137.68,18.29 143.1,18.29 143.93,17.46 149.01,17.46 149.6,18.05 163.08,18.05 163.66,18.63 164.56,18.63 164.99,18.2 170.06,18.2 170.31,18.45 172.71,18.45 173.49,19.23 178.21,19.23 178.57,19.59 179.53,19.59 179.62,19.67 180.27,19.67 180.4,19.55 180.95,19.55 181.53,18.98 184.05,18.98 184.28,19.21 187.11,19.21 187.44,19.54 190.21,19.54 192.16,17.59 196.14,17.59 196.6,18.05 197.06,18.05 197.34,18.33 197.34,19.37 197.74,19.77 v2(197.75,19.77)
PBA_PWR:
  vias: v1(49.01,21.58)
PBA_PWR_R: length 10.2
  TOP w0.508: v1(53.4,19.8) 53.4,19.39 53.76,19.04 v1(53.76,15.73) 53.76,15 53.52,14.77 51.12,14.77 50.73,15.15 50.73,16.52 50.3,16.95
PCBEEP_EC: length 68.7
  TOP w0.102: U37.34 185.25,13.38 185.66,12.97 186.73,12.97 186.98,12.71 186.98,11.04 187.03,10.98 v2(187.03,10.96)
  IN1 w0.089: v1(211.24,9.94) 211.24,9.8 211.33,9.71 212.94,9.71 213.19,9.97 213.19,10.37 213.65,10.83 213.65,14.72 213.17,15.2 213.17,18.66 212.66,19.16 212.66,22.97 211.75,23.88 209.48,23.88 208.33,25.03 206.99,25.03 206.36,25.65 205.97,25.65 205.52,26.1 205.52,26.51 204.57,27.47 201.13,27.47 200.91,27.68 198.42,27.68 197.79,28.32 197.79,28.47 197.57,28.69 v2(197.22,28.69)
  BOTTOM w0.102: v2(197.22,28.69) 196.71,29.2 195.59,29.2 195.39,29.4 195.39,30.82 195.13,31.08 v1(195.13,31.38) 195.13,31.48 194.7,31.91 D6543.2 ; v1(211.24,9.94) 210.94,9.64 188.35,9.64 v2(187.03,10.96)
PCBEEP_EC_C: length 14.4
  IN3 w0.089: v2(197.29,33.97) 197.29,33.95 197.23,33.88 197.23,29.89 198.38,28.74 198.38,28.56 198.63,28.31 199.1,28.31 199.4,28.61 v2(199.4,28.71)
  BOTTOM w0.102: v2(199.4,28.71) 199.4,28.54 200.16,27.77 C846.2 ; v2(197.29,33.97) 197.42,33.84 v1(197.42,33.34) 197.42,33.09 197.16,32.83 C843.2 196.69,31.85 R25371.1 196,31.83 196,30.64 195.87,30.52 R734.2 196.67,30.23 C844.2
PCH_AZ_CODEC_BITCLK: length 213.2
  TOP w0.102: v1(61.83,46.24) 61.81,46.21 61.43,46.21 60.16,44.94 60.16,31.94 58.79,30.57 58.79,30.11 58.28,29.61 58.28,28.34 57.92,27.98 57.39,27.98 v2(57.34,27.93)
  IN1 w0.089: v2(57.34,27.93) 57.54,27.72 57.54,25.34 57.64,25.25 57.64,20.14 60.03,17.75 60.03,16.06 60.89,15.2 74.19,15.2 75.16,16.17 78.87,16.17 83.86,21.16 88.54,21.16 94.12,15.58 95.36,15.58 95.79,15.15 96.48,15.15 96.68,15.35 99.61,15.35 100.27,14.69 109,14.69 109.61,15.3 118.57,15.3 119.19,14.69 181.93,14.69 183.27,13.35 189.39,13.35 190,12.74 190,11.92 190.41,11.52 192.44,11.52 193.2,10.76 204.15,10.76 204.71,11.31 204.71,16.55 203.87,17.38 203.87,20 203.31,20.56 202.8,20.56 201.38,21.98 201.38,22.9 202.41,23.93 202.41,24.1 202.73,24.42 203.21,24.42 203.72,23.91 204.15,23.91 v2(205.01,23.05)
  BOTTOM w0.102: v1(61.83,46.24) 62.55,46.24 R187.1 ; U20.6 204.86,28.1 204.61,27.85 C587.2 205.04,27.27 205.04,25.74 205.47,25.31 205.47,23.33 205.37,23.23 205.19,23.23 v2(205.01,23.05)
PCH_AZ_CODEC_RST#: length 225
  TOP w0.102: v2(55.94,28.69) 55.92,28.71 55.92,29.5 56.96,30.54 56.96,31.51 58.2,32.75 58.2,47.15 59.27,48.21 59.27,49.52 59.53,49.78 60.89,49.78 62.16,51.05 62.16,51.68 C216.2 63.04,51.55 R194.1
  IN1 w0.089: v2(206.64,19.75) 206.54,19.65 206.54,19.18 207.19,18.53 207.19,16.88 207.45,16.62 207.45,15.76 207.88,15.33 207.88,13.47 207.02,12.61 207.02,11.31 206.82,11.11 206.54,11.11 205.07,9.64 185.39,9.64 181.46,13.57 118.51,13.57 117.9,14.18 113.96,14.18 113.35,13.58 91.76,13.58 91.4,13.93 91.4,16.72 88.08,20.04 84.32,20.04 81.32,17.04 81.32,15.4 80.97,15.05 75.62,15.05 74.65,14.08 59.62,14.08 58.1,15.6 58.1,17.74 56.52,19.32 56.52,23.3 55.45,24.37 55.45,26.31 56.01,26.87 56.01,27.55 55.94,27.62 v2(55.94,28.69)
  BOTTOM w0.102: v2(206.64,19.75) 206.28,19.39 v1(205.01,19.39) 204.2,19.39 203.54,18.73 201.48,18.73 200.26,19.95 200.16,19.95 199.21,20.9 Q21.1 199.21,22.53 198.64,23.1 R738.2
PCH_AZ_CODEC_SDIN0: length 209.3
  TOP w0.102: v1(61.83,45.33) 61.81,45.3 61.81,44.87 60.89,43.96 60.89,31.64 60.39,31.14 60.39,29.2 60.4,29.19 60.4,28.83 60.01,28.43 59.76,28.43 v2(59.17,27.84)
  IN1 w0.089: v2(203.85,22.8) 204.84,21.8 204.84,17.16 205.2,16.79 205.2,10.99 204.49,10.29 185.66,10.29 181.73,14.22 118.78,14.22 118.17,14.83 113.41,14.83 112.8,14.22 96.01,14.22 95.21,15.02 94.02,15.02 88.35,20.69 84.05,20.69 79.06,15.7 75.35,15.7 74.38,14.73 59.88,14.73 59.47,15.14 59.47,17.28 57.17,19.59 57.17,25.05 56.78,25.44 56.78,26.26 56.93,26.41 56.93,28.15 57.08,28.31 58.23,28.31 58.7,27.84 v2(59.17,27.84)
  IN3 w0.089: v2(204.16,28.56) 204.37,28.35 204.37,23.55 204.05,23.23 204.05,23 v2(203.85,22.8)
  BOTTOM w0.102: v2(204.16,28.56) 204.06,28.66 U20.8 ; v1(61.83,45.33) 62.5,45.33 R191.1
PCH_AZ_CODEC_SDOUT: length 212
  TOP w0.102: R25374.1 59.65,46.24 59.42,46.01 59.42,32.25 58.05,30.88 58.05,30.06 57.8,29.81 57.8,28.54 57.72,28.46 57.08,28.46 v2(56.55,27.93)
  IN1 w0.089: v2(207.02,22.08) 206.67,22.08 205.94,21.36 205.94,17.47 206.73,16.68 206.73,15.77 207.45,15.05 207.45,13.7 205.9,12.15 205.9,11.67 205.45,11.21 205.45,10.73 204.79,10.07 185.57,10.07 181.64,14 118.69,14 118.08,14.62 113.5,14.62 112.89,14.01 92.11,14.01 91.83,14.29 91.83,16.9 88.26,20.47 84.14,20.47 79.15,15.49 75.44,15.49 74.47,14.51 59.79,14.51 59.14,15.17 59.14,17.31 56.95,19.5 56.95,23.48 55.88,24.55 55.88,26.13 56.44,26.69 56.44,27.82 v2(56.55,27.93)
  BOTTOM w0.102: U20.5 205.26,28.42 205.34,28.33 205.34,26.12 v1(205.5,25.97) 205.95,25.51 205.95,23.66 206.56,23.05 206.56,22.59 207.02,22.13 v2(207.02,22.08)
PCH_AZ_CODEC_SYNC: length 221.3
  TOP w0.102: v2(56.32,29.15) 56.45,29.27 56.45,29.38 57.57,30.5 57.57,31.26 58.81,32.5 58.81,46.8 59.88,47.86 59.88,48.75 60.13,49.01 R188.1
  IN1 w0.089: v2(206.64,20.33) 206.27,19.96 206.27,17.45 206.94,16.77 206.94,15.86 207.67,15.14 207.67,13.6 206.13,12.06 206.13,11.57 205.67,11.11 205.67,10.63 204.9,9.85 185.48,9.85 181.55,13.78 118.6,13.78 117.99,14.4 113.84,14.4 113.23,13.79 91.85,13.79 91.62,14.02 91.62,16.81 88.17,20.26 84.23,20.26 79.24,15.27 75.53,15.27 74.56,14.3 59.71,14.3 58.32,15.69 58.32,17.83 56.74,19.41 56.74,23.39 55.66,24.46 55.66,26.22 56.23,26.78 56.23,27.64 56.16,27.71 56.16,28.37 56.32,28.54 v2(56.32,29.15)
  BOTTOM w0.102: U20.10 203.26,28.96 203.11,28.82 203.11,28.66 202.88,28.43 202.45,28.43 201.79,27.77 201.79,26.83 202.35,26.28 202.35,25.28 201.71,24.65 201.71,23.99 201.18,23.46 201.18,22.08 v1(202.04,21.22) 202.29,20.97 202.68,20.97 203.29,20.36 203.96,20.36 204.17,20.57 204.17,20.62 204.36,20.8 205.65,20.8 206.12,20.33 v2(206.64,20.33)
PCH_BLON_C: length 9.3
  TOP w0.102: Q6521.5 56.58,103.62 57,104.04 57.45,104.04 v1(57.59,104.18) 57.59,106.23 57.29,106.53 57.29,107.38 57.48,107.56 R25366.2 57.72,108.49 R25365.2 57.78,108.56 58.17,108.95 R25369.1 58.86,109.21 58.86,109.84 59.02,109.99 R440.2
PCH_BLON_EC: length 219.9
  TOP w0.102: U37.88 198.18,24.98 197.97,25.19 197.97,25.51 v2(197.76,25.72) ; v2(59.12,101.33) 58.79,101.66 58.15,101.66 58.02,101.79 58.02,106.48 R25366.1
  IN2 w0.089: v2(197.76,25.72) 197.76,26.12 197.29,26.58 197.29,27.95 196.84,28.41 196.84,29.02 195.9,29.96 192.64,29.96 191.96,30.64 188.12,30.64 188,30.76 187.2,30.76 186.75,31.21 186.75,31.69 186.51,31.94 185.28,31.94 184.84,32.37 183.17,32.37 182.21,31.41 180.75,31.41 180.4,31.76 176.24,31.76 175.64,32.36 174.13,32.36 173.65,32.83 167.77,32.83 167.5,32.56 165.18,32.56 164.66,33.08 163.84,33.08 163.18,33.74 163.18,33.74 162.5,34.42 159.36,34.42 158.59,35.18 156.94,35.18 156.11,34.35 148.58,34.35 147.99,34.94 147.36,34.94 147.29,35 147.04,35 146.12,35.92 145.77,35.92 145.42,36.27 145.42,37.04 144.01,38.44 136.61,38.44 135.81,37.64 128.29,37.64 126.07,35.43 124.55,35.43 123.56,36.42 121.82,36.42 119.97,38.26 119.97,38.78 118.45,40.31 118.19,40.31 117.84,40.67 117.84,41.3 117.11,42.03 114.76,42.03 113.35,43.44 111.93,43.44 111.76,43.6 111.76,44.24 112.61,45.08 112.61,46.34 114.63,48.36 114.63,49.78 113.73,50.68 113.73,54.97 114.04,55.28 114.04,63.38 111.69,65.73 110.07,65.73 109.66,66.14 102.86,66.14 102.42,66.58 102.42,67.01 100.65,68.78 100.65,69.7 99.9,70.45 97.71,70.45 97.22,70.93 97.22,75.68 97.65,76.11 98.37,76.11 99.73,77.48 99.73,79.14 100.25,79.66 100.25,81.67 100,81.91 96.57,81.91 93.98,84.49 93.98,85.97 91.89,88.06 87.44,88.06 87.03,87.65 87.03,85.99 86.34,85.3 84.49,85.3 82.92,86.88 82.92,89.13 80.83,91.21 80.83,94.47 78.17,97.14 74.03,97.14 72.14,99.04 65.98,99.04 65.59,99.43 64.45,99.43 64.2,99.17 61.28,99.17 v2(59.12,101.33)
PCH_DISP_ON: length 68.3
  IN1 w0.089: v2(91.07,38.91) 89.67,38.91 89.24,39.34 88.49,39.34 88.4,39.43 88.4,39.79 88.1,40.09 87.54,40.09 87.39,39.94 86.47,39.94 86.04,40.37 86.04,42.68 85.69,43.04 85.48,43.04 85.27,43.25 85.27,49.15 86.24,50.13 86.24,65.8 84.77,67.27 84.77,79.04 85.16,79.43 85.16,79.71 85.6,80.14 85.6,84.82 86.21,85.43 86.21,93.6 85.55,94.25 83.22,94.25 v1(82.1,95.36)
  BOTTOM w0.079: v2(91.07,38.91) 91.4,39.24 U1.CG11
  BOTTOM w0.102: v1(82.1,95.36) 82.31,95.16 v1(82.84,95.16) 83,95.32 R445.2
PCH_DPST_PWM: length 113.9
  TOP w0.102: C2.2 92.34,37.4 91.48,38.26 v2(91.07,38.26) ; R443.1 53.33,106.67 54.55,105.44 54.55,104 53.83,103.29 51.32,103.29 51.07,103.04 51.07,102.68 51.32,102.42 52.75,102.42 54.14,101.04 v2(54.14,100.29)
  IN1 w0.089: v1(84.52,86.35) 84.52,85.71 85.19,85.04 85.19,80.29 84.77,79.87 84.77,79.59 84.38,79.2 84.38,66.8 85.84,65.34 85.84,50.28 84.39,48.83 84.39,42.71 85.18,41.92 85.18,40.78 85.61,40.35 85.81,40.35 86.4,39.76 87.46,39.76 87.62,39.91 88.02,39.91 88.23,39.71 88.23,39.35 88.43,39.14 88.43,38.68 88.52,38.59 89.1,38.59 89.43,38.26 v2(91.07,38.26)
  IN2 w0.089: v1(84.52,86.35) 84.03,86.35 83.32,87.05 83.32,89.28 81.34,91.26 81.34,94.55 78.93,96.96 78.93,98.79 77.5,100.22 73.13,100.22 72.35,101 69.38,101 68.28,102.1 66.94,102.1 65.37,103.67 60.89,103.67 60.27,103.04 57.86,103.04 56.3,101.48 56.3,100.42 55.7,99.82 54.61,99.82 v2(54.14,100.29)
  BOTTOM w0.079: U1.CH11 91.1,38.26 v2(91.07,38.26)
PCH_LVDS_BLON: length 101
  TOP w0.102: R25365.1 57.81,109.34 58.05,109.59 v1(58.38,109.59) ; v2(90.99,36.82) 91.29,36.82 C1.2
  IN1 w0.089: v2(90.99,36.82) 90.97,36.79 89.47,36.79 89.35,36.67 88.65,36.67 88.43,36.89 88.43,38.43 88.25,38.61 88.25,38.98 88.12,39.1 87.51,39.1 87.37,39.24 87.37,39.37 87.18,39.56 86.35,39.56 85.83,40.08 85.32,40.08 84.77,40.63 84.77,41.77 83.98,42.56 83.98,48.98 85.01,50.01 85.01,65.61 83.98,66.64 83.98,79.36 84.38,79.76 84.38,80.03 84.8,80.45 84.8,84.8 83.88,85.71 v1(83.88,87.24)
  IN2 w0.089: v1(83.88,87.24) 83.88,89.28 81.85,91.31 81.85,94.73 79.44,97.14 79.44,98.97 77.79,100.61 73.29,100.61 72.51,101.4 69.54,101.4 68.31,102.63 67.09,102.63 66.27,103.45 66.27,105.31 64.6,106.98 64.6,107.66 64.29,107.97 63.64,107.97 63.22,107.56 60.74,107.56 60.29,108 60.29,108.35 59.71,108.94 59.03,108.94 v1(58.38,109.59)
  BOTTOM w0.079: v2(90.99,36.82) 90.99,36.82 91.07,36.89 91.07,36.96 91.4,37.29 U1.CK11
PCH_OPI_RCOMP: length 5.2
  TOP w0.102: v2(82.28,43.64) 82.28,43.65 82.48,43.85 82.48,45.58 82.82,45.91 82.82,47.04 83.13,47.36 R18.2
  BOTTOM w0.079: U1.BW25 82.23,43.65
  BOTTOM w0.089: 82.23,43.65 82.26,43.65 82.27,43.64 v2(82.28,43.64)
PCH_PWROK: length 167.5
  TOP w0.102: U37.78 198.18,20.98 197.97,20.77 197.97,20.4 197.75,20.18 197.58,20.18 197.27,19.87 196.66,19.87 196.15,20.38 196.15,22.21 196.33,22.39 196.33,22.79 195.03,24.08 195.03,25.31 194.27,26.07 193.08,26.07 v2(191.93,27.21)
  IN2 w0.089: v2(191.93,27.21) 190.79,27.21 189.91,28.1 189.07,28.1 188.67,28.5 187.61,28.5 187.16,28.95 186.44,28.95 185.91,29.48 185.42,29.48 185.07,29.84 183.48,29.84 183.21,29.57 179.83,29.57 179.47,29.93 177.48,29.93 177.29,29.74 174.18,29.74 173.43,30.49 164.68,30.49 164.09,31.08 161.83,31.08 161.29,31.62 156.71,31.62 156.18,32.14 147.31,32.14 146.49,32.96 145.21,32.96 144.59,33.59 144.59,34.13 144.38,34.34 143.65,34.34 143.46,34.15 142.68,34.15 142.54,34.29 136.85,34.29 136.66,34.48 133.92,34.48 133.17,35.23 128.45,35.23 126.83,33.61 123.96,33.61 123.81,33.46 119.86,33.46 117.9,31.5 109.77,31.5 109.13,30.86 107.9,30.86 107.64,31.13 103.61,31.13 103.01,30.52 102.47,30.52 101.92,31.08 97.88,31.08 97.7,31.27 94.78,31.27 94.31,31.74 93.68,31.74 92.95,32.47 88.94,32.47 88.34,33.07 87.76,33.07 87.37,33.46 85.48,33.46 85.28,33.26 82.99,33.26 82.68,32.94 81.94,32.94 80.84,31.84 78.95,31.84 78.32,32.47 73.16,32.47 72.9,32.73 70.22,32.73 70.04,32.55 68.82,32.55 68.64,32.73 67.5,32.73 66.67,31.89 63.66,31.89 61.61,29.84 v2(61.61,29.81)
  BOTTOM w0.102: R25357.2 61.98,43.8 61.61,43.43 v2(61.61,29.81)
PCH_PWROK_R: length 18.4
  BOTTOM w0.079: U1.BP31 78.17,46.97 77.79,46.6 76.31,46.6 76.09,46.82 76.09,46.96 75.86,47.19 75.61,47.19 75.56,47.16 75.22,47.16 75.17,47.19 74.95,47.19 74.8,47.12 74.08,47.12 71.45,44.49 71.11,44.49
  BOTTOM w0.102: R25357.1 63.16,43.8 63.36,43.6 v1(63.82,43.6) 63.97,43.75 65.29,43.75 65.49,43.95 65.49,44.31 66.05,44.87 66.64,44.87 R25501.1 67.28,44.23 68.95,44.23 69.2,44.49 71.11,44.49
PCH_SLP_S0_N: length 131.4
  TOP w0.102: v2(125.59,16.88) 125.47,16.75 R592.1
  IN2 w0.089: v2(95.18,14.39) 95.72,13.85 98.74,13.85 98.79,13.91 111.95,13.91 114.52,16.48 122.52,16.48 123.02,16.98 123.02,17.54 123.12,17.64 123.63,17.64 124.01,17.26 125.21,17.26 v2(125.59,16.88) ; v2(59.99,29.05) 59.99,28.83 61.15,27.67 61.15,24.37 60.82,24.04 60.82,23.56 61.23,23.15 61.96,23.15 62.34,22.77 62.34,22.54 63.66,21.23 68.24,21.23 68.71,20.76 70.3,20.76 70.79,20.28 70.79,20 71.43,19.36 75.29,19.36 76.39,20.46 77.15,20.46 77.91,19.69 78.97,19.69 83.15,23.86 89.57,23.86 94.32,19.11 v2(94.68,19.11)
  BOTTOM w0.079: 71.33,46.16 71.46,46.16 73.58,48.29 73.58,48.64 74.74,49.8 U1.BJ37
  BOTTOM w0.102: v2(94.68,19.11) 94.91,18.88 94.91,15.76 95.18,15.48 v2(95.18,14.39) ; v2(59.99,29.05) 59.5,29.54 59.5,49.18 61.28,50.95 61.28,51.94 R38.1 61.29,52.57 62.05,53.33 v1(62.06,53.33) 64.58,53.33 65.64,52.26 65.64,50.1 65.8,49.95 65.8,47.98 66.34,47.43 67.09,47.43 67.88,46.65 69.1,46.65 69.58,46.16 71.33,46.16
PCH_SPI1_CLK: length 171.7
  TOP w0.102: R111.2 162.72,31.02 163.33,30.4 163.33,26.83 164.76,25.41 164.76,24.83 164.32,24.4 164.32,23.31 164.91,22.72 164.91,20.58 164.6,20.28 164.6,17.69 163.69,16.78 159.04,16.78 158.34,17.47 157.17,17.47 156.9,17.21 156.9,16.74 156.53,16.37 150.91,16.37 v2(150.23,17.05) ; v2(123.4,17.26) 123.4,17.18 122.69,16.47 120.69,16.47 120.1,17.05 120.1,18.93 120.37,19.2 120.37,22.07 v1(120.31,22.13) 120.18,22.26 R596.1
  IN1 w0.089: v2(150.23,17.05) 150.06,16.88 143.6,16.88 142.78,17.7 139.09,17.7 138.53,17.14 138.27,16.88 128.76,16.88 128.28,17.36 123.51,17.36 v2(123.4,17.26) 122.74,17.26 122.39,16.9 121.52,16.9 120.93,17.5 109.89,17.5 109.27,18.12 104.49,18.12 104.44,18.07 99.08,18.07 98.92,18.22 94.59,18.22 89.46,23.36 82.94,23.36 78.32,18.73 76.36,18.73 76.03,18.4 74.28,18.4 73.28,17.4 63.66,17.4 59.83,21.22 59.83,24.67 62.05,26.89 62.05,27.8 62.55,28.31 62.55,30.24 67.18,34.87 67.96,34.87 68.13,35.04 68.82,35.04 v2(69,35.22)
  BOTTOM w0.079: 72.32,37.25 72.33,37.25 73.52,38.44 74.26,38.44 74.55,38.73 U1.CH37
  BOTTOM w0.102: R88.2 66.35,33.39 66.6,33.64 67.88,33.64 69,34.76 v2(69,35.22) 70.09,35.22 72.12,37.25 72.32,37.25
PCH_SPI1_CLK_R: length 44.8
  TOP w0.102: R111.1 159.95,32.3 v2(159.95,32.45) 159.95,32.78 160.31,33.13 160.31,33.83 TP15.1 161.5,34.34 161.68,34.17 C191.1 ; U37.105 194.04,29.83 v2(194.04,31.53)
  IN1 w0.089: v2(159.95,32.45) 159.95,31.8 160.48,31.28 162.7,31.28 163.32,30.66 164.1,30.66 164.3,30.46 168.82,30.46 168.91,30.37 172.2,30.37 172.25,30.42 173.54,30.42 174.22,29.74 177.19,29.74 177.51,30.07 182.69,30.07 182.91,29.84 189.2,29.84 189.49,30.12 191.74,30.12 192.75,31.13 192.75,31.66 192.87,31.79 193.81,31.79 194.02,31.58 194.02,31.56 v2(194.04,31.53)
  BOTTOM w0.102: v2(159.95,32.45) 160.29,32.45 160.72,32.88 U2.6
PCH_SPI1_SI: length 164.7
  TOP w0.102: R597.1 121.28,20.65 120.97,20.33 v2(120.97,20.1) ; v2(113.22,18.99) 113.24,19.01 113.24,19.24 114.03,20.03 114.03,20.59 114.08,20.64 114.08,21.04 114.82,21.78 114.82,22.59 114.51,22.9 R221.2 ; v2(156.42,17.04) 156.42,17.41 157.1,18.1 162.98,18.1 163.64,18.75 163.64,21.12 163.37,21.39 163.37,22.53 162.83,23.08 162.83,24.6 162.14,25.29 162.14,28.36 162.85,29.07 162.85,30.2 162.54,30.52 159.95,30.52 R113.2
  IN1 w0.089: v2(72.86,39.71) 72.86,38.29 72.3,37.74 72.03,37.74 71.17,36.87 71.17,35.38 70.88,35.09 70.88,34.86 69.54,33.52 69.54,30.45 68.59,29.5 64.88,29.5 64.22,28.83 63.76,28.83 63.67,28.75 63.67,26.93 60.95,24.21 60.95,22.53 62.29,21.2 63.69,21.2 66.34,18.54 69.92,18.54 70.21,18.84 72.66,18.84 74.41,20.59 76.41,20.59 76.5,20.67 76.5,21.28 76.59,21.37 76.77,21.37 76.85,21.28 76.85,20.67 76.94,20.59 77.16,20.59 80.09,23.52 81.53,23.52 82.48,24.47 89.92,24.47 90.4,23.99 91.18,23.99 91.5,23.67 91.5,22.89 94.11,20.28 95.1,20.28 96.04,19.34 99.39,19.34 99.54,19.19 103.68,19.19 103.96,19.47 110.14,19.47 110.42,19.19 113.02,19.19 v2(113.22,18.99) 113.8,18.99 114.17,18.62 119.38,18.62 119.98,19.21 119.98,19.48 120.19,19.7 120.56,19.7 v2(120.97,20.1) 121.35,19.72 121.35,19.59 121.5,19.44 121.88,19.44 122.6,18.72 129.34,18.72 130.06,18 137,18 137.86,18.86 144.2,18.86 145.06,18 149.05,18 149.27,18.22 152.77,18.22 153.14,17.85 155.05,17.85 155.48,17.42 156.04,17.42 v2(156.42,17.04)
  BOTTOM w0.079: U1.CF36 75.18,40.03 74.97,40.25 74.79,40.31 74.6,40.31 74.39,40.1 73.7,40.1 73.39,39.79 72.93,39.79 v2(72.86,39.71)
PCH_SPI1_SI_R: length 46.6
  TOP w0.102: R25303.1 194.96,31.4 195.08,31.27 195.08,30.82 195.25,30.66 U37.102 195.25,29.09 194.82,28.66 194.46,28.66 v2(193.91,28.12) ; R113.1 159.45,32.12 159.35,32.22 v2(159.35,32.45) 159.35,33.16 158.99,33.51 TP16.1
  IN1 w0.089: v2(193.91,28.12) 194.39,28.59 194.39,29.05 194.15,29.29 189.21,29.29 189.09,29.17 187.42,29.17 187.22,29.37 182.72,29.37 182.49,29.6 178.01,29.6 177.68,29.27 174.02,29.27 173.34,29.95 172.44,29.95 172.39,29.9 168.61,29.9 168.52,29.99 164,29.99 163.8,30.19 163.12,30.19 162.51,30.81 160.28,30.81 159.35,31.74 v2(159.35,32.45)
  BOTTOM w0.102: U2.5 159.45,32.65 159.35,32.55 v2(159.35,32.45)
PCH_SPI1_SO: length 151.3
  TOP w0.102: R108.2 160.72,26.98 161.19,26.51 161.19,25.6 162.37,24.41 162.37,22.89 162.91,22.34 162.91,21.2 163.18,20.93 163.18,18.94 162.79,18.55 156.7,18.55 155.18,17.04 v2(155.02,17.04) ; R598.1 R583.1 120.64,18.23 v2(120.64,18.88)
  IN1 w0.089: v2(72.43,39.31) 72.43,38.8 72.15,38.52 71.72,38.52 71.41,38.22 71.41,37.73 70.74,37.05 70.74,35.56 70.45,35.27 70.45,35.03 69.11,33.7 69.11,30.63 68.41,29.93 64.7,29.93 64.6,29.83 63.45,29.83 63.24,29.62 63.24,27.1 60.52,24.39 60.52,22.36 63.79,19.09 64.53,19.09 65.5,18.11 70.09,18.11 70.39,18.41 72.84,18.41 73.52,19.09 75.75,19.09 76.08,19.42 78.04,19.42 82.66,24.04 89.74,24.04 93.93,19.85 94.92,19.85 95.86,18.91 99.21,18.91 99.36,18.76 104.02,18.76 104.23,18.96 110.04,18.96 110.24,18.76 112.61,18.76 113.18,18.19 119.91,18.19 120.61,18.88 v2(120.64,18.88) 120.64,18.88 120.64,18.86 120.86,18.63 121.83,18.63 122.18,18.28 123.92,18.28 124.15,18.05 128.56,18.05 129.04,17.57 137.18,17.57 137.99,18.38 143.07,18.38 143.88,17.57 149.23,17.57 149.45,17.79 152.59,17.79 152.96,17.42 154.65,17.42 v2(155.02,17.04)
  BOTTOM w0.079: v2(72.43,39.31) 73.15,39.31 73.78,39.93 74.64,39.93 U1.CF37
PCH_SPI1_SO_R: length 45.3
  TOP w0.102: R108.1 160.72,28.48 160.41,28.79 TP17.1 160.6,29.34 160.73,29.34 161.5,30.11 v2(161.78,30.11) ; R25316.1 194.52,31.74 194.52,31.51 arc(194.52,31.51) 194.53,31.51 194.85,31.18 194.85,30.66 arc(194.85,30.66) 194.85,30.66 194.85,30.65 U37.103 194.85,29.06 194.68,28.89 194.1,28.89 v2(193.91,28.7)
  IN1 w0.089: v2(193.91,28.7) 193.09,28.7 192.71,29.08 189.3,29.08 189.03,28.81 187.47,28.81 187.13,29.15 183.81,29.15 183.37,28.71 177.84,28.71 177.49,29.06 172.49,29.06 171.86,29.68 168.52,29.68 168.43,29.77 163.91,29.77 163.71,29.98 163.03,29.98 162.42,30.59 162.11,30.59 161.78,30.26 v2(161.78,30.11)
  BOTTOM w0.102: v2(161.78,30.11) 161.63,29.96 161.63,28.54 161.86,28.31 161.86,27.27 161.99,27.14 161.99,26.06
PCH_SPI_CS0#: length 148.2
  TOP w0.102: v2(155.84,17.04) 156.02,17.23 156.02,17.33 157.01,18.32 162.89,18.32 163.41,18.85 163.41,21.03 163.14,21.3 163.14,22.44 162.6,22.98 162.6,24.51 161.68,25.42 v1(161.68,26.28) R106.2
  IN1 w0.089: v2(155.84,17.04) 155.73,17.15 155.45,17.15 154.96,17.63 153.05,17.63 152.68,18 149.36,18 149.14,17.78 144.97,17.78 144.11,18.65 137.95,18.65 137.09,17.78 129.13,17.78 128.65,18.27 124.25,18.27 124.01,18.51 122.31,18.51 121.63,19.19 121.27,19.19 121.02,19.44 120.46,19.44 120.25,19.24 120.25,19.16 119.49,18.4 113.27,18.4 112.7,18.97 110.33,18.97 110.07,19.24 104.2,19.24 103.93,18.97 99.45,18.97 99.3,19.12 95.95,19.12 95.01,20.06 94.02,20.06 89.83,24.26 82.57,24.26 81.62,23.3 80.19,23.3 77.26,20.37 74.5,20.37 72.75,18.62 70.3,18.62 70,18.32 65.59,18.32 64.62,19.3 63.88,19.3 60.74,22.45 60.74,24.3 63.46,27.02 63.46,28.95 63.56,29.05 64.13,29.05 64.79,29.72 68.5,29.72 69.33,30.54 69.33,33.61 70.67,34.95 70.67,35.18 70.95,35.47 70.95,36.96 72.1,38.11 v2(72.15,38.11)
  BOTTOM w0.079: v2(72.15,38.11) 72.47,38.11 73.3,38.95 74.05,38.95 74.48,39.38 U1.CG36
PCH_SPI_CS0#_R: length 44.4
  TOP w0.102: R106.1 161.68,28.66 TP14.1 162.37,29.35 v2(162.37,30.11) ; v2(193.9,27.52) 194.28,27.14 194.82,27.14 194.92,27.24 194.92,28.43 195.38,28.9 195.5,28.9 195.65,29.05 U37.101
  IN1 w0.089: v2(193.9,27.52) 193.9,27.53 192.63,28.8 191.44,28.8 190.82,28.18 188.91,28.18 188.5,28.59 187.38,28.59 187.04,28.93 183.97,28.93 183.48,28.44 181.03,28.44 180.99,28.48 177.76,28.48 177.4,28.84 172.38,28.84 171.75,29.47 168.43,29.47 168.34,29.56 163.82,29.56 163.62,29.76 162.72,29.76 v2(162.37,30.11)
  BOTTOM w0.102: v2(162.37,30.11) 163.26,29.22 U2.1
PCH_SPI_IO2: length 154.9
  TOP w0.102: v2(112.69,18.02) 112.69,19.29 113.6,20.2 R220.1 ; R110.2 160.28,26.78 160.59,26.78 160.96,26.41 160.96,25.5 162.14,24.32 162.14,22.79 162.69,22.25 162.69,21.11 162.95,20.84 162.95,19.04 162.7,18.78 156.53,18.78 155.26,17.51 154.91,17.51 v2(154.44,17.04)
  IN1 w0.089: v2(73.24,40.17) 72.58,40.17 71.2,38.78 71.2,37.82 70.52,37.14 70.52,35.65 70.24,35.36 70.24,35.12 68.9,33.78 68.9,30.72 68.32,30.15 64.61,30.15 64.52,30.06 63.37,30.06 63.02,29.71 63.02,27.19 60.3,24.47 60.3,22.27 63.05,19.52 63.05,18.71 63.87,17.89 70.18,17.89 70.48,18.19 72.93,18.19 73.61,18.87 75.84,18.87 76.17,19.2 78.13,19.2 82.75,23.82 89.65,23.82 93.84,19.63 94.83,19.63 95.77,18.69 99.12,18.69 99.27,18.54 104.11,18.54 104.16,18.59 109.43,18.59 109.48,18.54 112.19,18.54 112.69,18.05 v2(112.69,18.02) 112.71,18.02 112.76,17.97 121.19,17.97 121.35,17.82 121.85,17.82 121.96,17.92 123.76,17.92 123.84,17.84 128.47,17.84 128.95,17.35 137.3,17.35 138.11,18.17 142.98,18.17 143.79,17.35 149.32,17.35 149.54,17.57 152.5,17.57 152.94,17.14 154.34,17.14 v2(154.44,17.04)
  BOTTOM w0.079: v2(73.24,40.17) 73.34,40.27 74.32,40.27 74.53,40.48 74.83,40.48 75.08,40.38 75.15,40.31 76.41,40.31 U1.CF34
PCH_SPI_IO3: length 156.4
  TOP w0.102: R109.1 162.83,31.61 163.82,30.62 163.82,27.03 165.24,25.61 165.24,24.63 164.93,24.33 164.93,23.38 165.42,22.9 165.42,20.41 165.09,20.08 165.09,17.49 163.89,16.29 v1(158.84,16.29) 157.62,16.29 157.52,16.39 v2(157.52,16.83)
  IN1 w0.089: v2(73.93,39.33) 73.37,38.77 73.37,38.34 72.12,37.1 72.12,34.94 71.36,34.17 70.51,34.17 69.76,33.43 69.76,30.36 68.69,29.28 64.97,29.28 64.5,28.81 64.5,28.23 64.08,27.81 64.08,26.21 65.67,24.62 65.67,23.94 65.25,23.52 65.25,19.94 66.43,18.76 69.83,18.76 70.12,19.06 72.57,19.06 74.32,20.8 75.42,20.8 76.21,21.59 77.86,21.59 80,23.74 81.44,23.74 82.39,24.69 84.18,24.69 84.77,25.28 87.06,25.28 87.65,24.69 90.01,24.69 90.49,24.2 91.27,24.2 91.72,23.76 91.72,22.98 94.2,20.5 95.19,20.5 96.13,19.56 99.48,19.56 99.63,19.4 103.13,19.4 103.41,19.68 110.23,19.68 110.51,19.4 113.69,19.4 114.26,18.83 119.26,18.83 119.75,19.32 119.75,19.55 120.1,19.91 120.25,19.91 120.81,20.48 121.76,20.48 122.11,20.13 122.11,19.97 123.14,18.94 129.43,18.94 130.15,18.22 132.66,18.22 133.3,18.85 137.54,18.85 137.77,19.08 144.29,19.08 145.15,18.22 148.96,18.22 149.18,18.43 152.86,18.43 153.23,18.06 155.14,18.06 155.57,17.63 156.72,17.63 v2(157.52,16.83)
  BOTTOM w0.079: v2(73.93,39.33) 74.19,39.59 74.87,39.59 74.96,39.63 74.98,39.64 75.2,39.64 75.3,39.58 75.5,39.58 75.67,39.66 76.09,39.66 U1.CG34
PCH_SUSPWRDNACK: length 137.1
  TOP w0.102: U37.15 182.37,22.58 181.95,23 181.6,23 181.16,22.57 179.95,22.57 178.65,21.27 177.46,21.27 177.38,21.2 176.77,21.2 v2(176.69,21.12)
  IN2 w0.089: v2(65.75,26.53) 65.75,26.89 66.29,27.44 66.29,29.88 67.45,31.04 68.21,31.04 68.85,31.67 70.47,31.67 70.66,31.86 72.63,31.86 72.83,31.66 78.13,31.66 78.73,31.05 84.51,31.05 84.85,31.39 88.37,31.39 88.5,31.53 92.72,31.53 93.23,31.02 93.23,30.76 93.73,30.26 95.69,30.26 95.93,30.5 97.38,30.5 97.57,30.32 101.6,30.32 102.75,29.17 104.4,29.17 105.33,30.1 109.48,30.1 110.11,30.74 118.21,30.74 118.41,30.93 123.06,30.93 124.97,32.85 127.41,32.85 127.82,33.26 132.28,33.26 132.4,33.13 133.36,33.13 133.56,33.34 140.59,33.34 140.73,33.2 142.96,33.2 143.52,32.63 144.2,32.63 145.73,31.09 155.41,31.09 156.05,30.45 159.95,30.45 161.06,29.34 164.33,29.34 164.53,29.53 171.18,29.53 171.56,29.15 v2(171.56,29.09)
  BOTTOM w0.102: v2(176.69,21.12) 176.69,21.65 175.98,22.36 175.98,23.47 173.99,25.46 173.99,26.22 173.67,26.54 172.95,26.54 172.38,27.11 172.38,28.28 v2(171.56,29.09) ; v2(65.75,26.53) 65.75,27.09 65.97,27.32 v1(65.97,27.57) 65.97,28.71 65.87,28.82 65.87,29.35 66.35,29.82 R39.2
PCH_TYPEC_UPFB#: length 134.6
  IN3 w0.089: v2(96.02,26.73) 95.97,26.73 95.77,26.53 95.77,24.5 96.45,23.82 96.45,21.93 95.23,20.7 90.59,20.7 89.53,21.77 83.66,21.77 78.23,16.34 72.89,16.34 71.59,15.04 50.02,15.04 49.7,14.72 49.4,14.72 47.37,12.69 47.37,12.54 43.78,8.94 41.61,8.94 37.09,4.42 32.18,4.42 31.94,4.18 31.29,4.18 30.62,4.84 25.36,4.84 24.68,5.52 23.18,5.52 22.41,6.29 22.41,7.29 19.53,10.17 19.53,13.2 17.54,15.19 17.54,24.92 16.44,26.02 16.44,27.16 v1(17.08,27.8)
  BOTTOM w0.079: U1.CP7 93.82,34.82 93.82,33.74 94.91,32.65
  BOTTOM w0.102: 94.91,32.65 94.91,28.42 95.03,28.3 v1(95.03,27.6) 95.03,27.52 95.54,27.01 95.74,27.01 v2(96.02,26.73) 96.02,26.55 95.82,26.35 R202.1 95.44,25.87 R25480.1 ; Q6505.1 9.82,22.45 10.48,23.1 10.48,23.86 10.98,24.37 12.99,24.37 14.24,25.62 14.24,26.33 15.71,27.8 v1(17.08,27.8)
PCIE_CLKREQ_LAN#: length 150.8
  TOP w0.102: R155.1 66.57,36.82 67.83,36.82 v2(68.34,36.3) 68.67,36.63 68.83,36.63 69.41,37.21 71.83,37.21 72.68,38.07 72.68,38.75 73.69,39.75 75.52,39.75 75.6,39.84 78.95,39.84 v2(79.29,40.17) ; v2(55.79,97.01) 55.79,97.18 R25444.1 57.34,98.72 R25446.1 58.36,99.42 Q6531.3
  IN1 w0.089: v2(55.79,97.01) 55.79,97.59 54.93,98.45 53.84,98.45 52.28,96.89 51.14,96.89 50.3,96.04 32.19,96.04 30.94,94.8 30.94,93.86 28.86,91.78 28.86,81.18 28.36,80.68 28.36,77.55 29.32,76.6 29.32,68.82 29.53,68.61 29.53,65.01 29.34,64.83 29.34,56.7 28.52,55.87 28.52,40.51 28.74,40.29 28.74,39.32 31.8,36.26 36.05,36.26 36.82,35.5 45.45,35.5 47.81,33.14 47.81,32.57 48.16,32.22 48.5,32.22 49.84,30.89 51.15,30.89 51.39,31.13 61.85,31.13 67.42,36.69 67.96,36.69 v2(68.34,36.3)
  BOTTOM w0.079: v2(79.29,40.17) 79.04,40.42 U1.CE30
PCIE_CLKREQ_SSD#: length 93.4
  TOP w0.102: v2(25.46,6.92) 25.46,7.45 24.85,8.06 24.85,11.57 24.83,11.59 24.83,12.18 24.7,12.31 24.7,13.07 26.05,14.41 26.05,18.63 26.78,19.37 27.97,19.37 28.61,20.01 28.61,20.36 28,20.97 28,21.3 v1(27.87,21.42) ; v2(77.33,40.22) 77.18,40.37 74.86,40.37 74.66,40.16 73.83,40.16 73.42,40.58 71.87,40.58 71.31,41.13 69.91,41.13 68.51,39.74 68.51,38.49 68.95,38.06 v2(68.95,37.71) 68.82,37.58 68.26,37.58 68.01,37.83 67.24,37.83 66.99,37.58 R159.1
  IN1 w0.089: v1(45.88,33.01) 46.5,33.01 47.28,32.22 47.6,32.22 47.99,31.83 48.33,31.83 49.67,30.49 50.99,30.49 51.25,30.23 52.71,30.23 53.21,30.73 54.63,30.73 55.22,30.14 55.57,30.14 56.16,30.73 62.02,30.73 67.09,35.8 68.41,35.8 68.77,36.16 68.77,37.53 v2(68.95,37.71)
  IN3 w0.089: v1(45.88,33.01) 45.86,33.01 44.97,33.9 38.44,33.9 35.95,31.41 34.12,31.41 33.62,30.9 33.62,30.01 31.91,28.31 31.16,28.31 30.31,27.45 30.31,26.7 28.54,24.93 28.54,24.14 27.87,23.48 v1(27.87,21.42)
  BOTTOM w0.079: U1.CE32 77.7,40.6 v2(77.33,40.22)
  BOTTOM w0.102: CN16.52 27.1,3.1 25.33,4.86 25.33,6.79 v2(25.46,6.92)
PCIE_CLKREQ_VGA#: length 78.5
  TOP w0.102: v2(78.14,39.23) 78.14,39.3 77.83,39.61 76.72,39.61 76.38,39.27 74.7,39.27 73.98,38.54 73.57,38.54 73.16,38.13 73.16,37.97 71.99,36.81 69.58,36.81 69,36.22 68.84,36.22 68.31,35.7 66.94,35.7 66.89,35.65 R25493.1
  IN1 w0.089: v2(78.14,39.23) 78.09,39.28 78.09,39.44 77.8,39.74 77.15,39.74 76.77,40.12 76.77,40.93 76.64,41.06 76.64,43.04 76.77,43.17 76.77,43.5 76.64,43.62 76.64,44.82 76.74,44.92 76.74,46.15 77.06,46.47 78.04,46.47 78.52,46.94 79.15,46.94 80.07,47.87 81.09,47.87 82.26,49.04 82.26,50.94 82.61,51.29 83.25,51.29 83.79,51.84 83.79,63.57 81.9,65.47 81.9,80.1 82.61,80.81 82.61,83.4 82.89,83.68 82.89,84.82 82.73,84.99 82.73,90.27 83.7,91.25 v1(83.7,92.7)
  BOTTOM w0.079: U1.CF32 77.75,39.68 78.09,39.34 78.09,39.28 v2(78.14,39.23)
  BOTTOM w0.102: R25487.1 85.66,93.95 85.66,93.32 85.37,93.03 85.24,93.03 Q9.3 84.88,92.7 v1(83.7,92.7)
PCIE_CLKREQ_WLAN#: length 121.3
  TOP w0.079: 76.92,38.84 76.92,38.84 78.57,38.84 78.76,39.03 v2(78.76,39.26)
  TOP w0.102: R154.1 66.86,34.68 67.02,34.83 68.18,34.83 68.39,35.04 68.39,35.2 69.01,35.82 69.17,35.82 69.75,36.4 72.16,36.4 73.31,37.55 73.74,37.55 75.03,38.84 76.92,38.84 ; v2(173.37,23.33) 173.77,22.93 173.77,21.92 173.9,21.79 173.9,21.45 Q63.3
  IN1 w0.089: v2(173.37,23.33) 173.34,23.37 171.16,23.37 171.11,23.42 165.97,23.42 164.77,24.63 161.22,24.63 160.19,25.66 154.4,25.66 153.81,26.25 147.48,26.25 146.31,27.42 146.05,27.42 144.85,28.62 139.81,28.62 139.32,29.1 138.74,29.1 138.42,29.42 132.95,29.42 132.8,29.58 129.35,29.58 128.9,29.12 124.7,29.12 124.21,28.64 119.59,28.64 119.04,28.08 110.95,28.08 110.76,27.89 107.25,27.89 105.88,29.27 102.42,29.27 101.59,30.11 99.93,30.11 98.98,31.06 96.84,31.06 95.88,32.02 95.78,32.02 94.15,33.65 93.51,33.65 92.53,34.63 86.73,34.63 85.72,35.64 84.75,35.64 82.55,37.84 81.68,37.84 81.1,38.43 81.1,39.51 80.97,39.64 79.51,39.64 79.14,39.26 v2(78.76,39.26)
  BOTTOM w0.079: v2(78.76,39.26) 78.66,39.36 78.66,39.42 U1.CF31
PCIE_RCOMP: length 3.5
  TOP w0.102: v2(93.7,39.98) 93.7,39.95 94.25,39.41 95.08,39.41 95.73,38.76 95.73,38.4 R139.2
  BOTTOM w0.079: v2(93.7,39.98) 93.73,40 93.73,40.07 U1.CE6
PCIE_RCOMP_P: length 3.6
  TOP w0.102: R139.1 95.95,38.57 95.95,38.85 95.2,39.6 94.31,39.6 94.17,39.74 94.17,39.87 v2(94.27,39.97)
  BOTTOM w0.079: U1.CE5 94.32,40.02 94.32,39.99 94.3,39.97 v2(94.27,39.97)
PCIE_REQ_LAN#_R: length 23
  TOP w0.102: U24.12 44.44,101.91 44.72,101.64 44.72,100.57 45.02,100.27 v1(48.09,100.27) 48.27,100.27 49.21,101.21 53.02,101.21 53.5,100.72 53.5,99.96 53.81,99.66 55.63,99.66 56.17,100.2 R25446.2 57.73,100.2 58.04,100.5 Q6531.1 60.5,99.57 61.32,98.75 R25445.1
PCIE_RXN9_LAN: length 104.4
  TOP w0.102: C637.2 48.97,102.39 49.07,102.28 49.73,102.28 49.88,102.44 49.88,102.72 49.83,102.77 v1(49.61,102.77)
  IN3 w0.089: v2(94.99,46.35) 94.84,46.35 94.7,46.21 94.7,45.96 94.85,45.81 95.87,45.81 97.62,47.56 98.94,47.56 99.54,48.17 99.54,50.11 100.14,50.71 100.14,51.28 101.1,52.24 101.1,53.45 100.92,53.64 100.92,55.38 100.27,56.03 100.27,57.83 98,60.11 97.7,60.11 97.27,60.54 97.27,72.08 97.39,72.21 97.39,74.83 95.9,76.33 95.9,77.63 94.5,79.03 94.5,80.18 93.33,81.35 93.33,82 92.57,82.76 92.57,85.12 92.19,85.5 92.19,87.97 89.37,90.78 88.78,90.78 85.47,94.09 82.41,94.09 80.28,96.23 77.68,96.23 76.72,97.19 61.86,97.19 60.77,98.28 59.75,98.28 57.82,100.22 57.82,101.45 55.98,103.29 51.25,103.29 51.04,103.08 51.04,102.63 50.79,102.37 50.27,102.37 49.96,102.68 49.96,102.68 49.87,102.77 v1(49.61,102.77)
  BOTTOM w0.079: U1.BP5 94.74,46.9 95.03,46.9 95.11,46.82 95.11,46.47 v2(94.99,46.35)
PCIE_RXN10_WLAN: length 132
  IN1 w0.089: v2(187.03,33.26) 186.9,33.13 186.9,32.87 186.5,32.47 182.13,32.47 181.95,32.64 181.05,32.64 180.71,32.3 175.7,32.3 175.64,32.25 174.09,32.25 174.03,32.3 171.67,32.3 171.16,31.79 170.39,31.79 169.85,32.33 168.65,32.33 168.23,31.91 164.85,31.91 164.7,32.06 163.97,32.06 163.08,32.95 161.8,32.95 160.84,33.91 159.56,33.91 158.8,34.67 156.83,34.67 156.23,34.07 148.57,34.07 148.12,34.52 147.8,34.52 147.69,34.63 147.53,34.63 147.25,34.91 146.96,34.91 146.06,35.81 145.77,35.81 145.32,36.26 145.32,36.6 140.91,41.01 140.27,41.01 139.94,41.34 139.94,42.83 139.73,43.04 138.27,43.04 137.93,42.7 137.93,41.97 137.48,41.52 136.59,41.52 133.84,38.77 125.64,38.77 124.45,37.58 121.6,37.58 120.24,38.94 117.94,38.94 117.48,39.39 115.02,39.39 114.27,40.14 113.69,40.14 112.32,41.52 106.64,41.52 105.83,40.7 102.32,40.7 100.01,43.01 96.28,43.01 96.07,43.22 93.07,43.22 92.5,43.79 91.64,43.79 91.17,44.26 91.17,44.67 91.81,45.31 91.81,45.79 92.43,46.42 92.94,46.42 93.45,46.93 93.88,46.93 v2(94.27,47.31)
  BOTTOM w0.079: v2(94.27,47.31) 94.27,47.52 U1.BN6
  BOTTOM w0.102: CN17.43 184.6,20.63 184.69,20.53 185.76,20.53 186.23,21 186.23,22.21 186.82,22.79 186.82,24.76 187.22,25.17 187.22,25.69 186.69,26.23 186.69,27.05 186.46,27.28 186.46,29.39 185.74,30.11 185.74,31.45 186.09,31.8 186.09,32.26 187.03,33.21 v2(187.03,33.26)
PCIE_RXN13_SSD: length 99.7
  IN3 w0.089: v1(36.31,12.19) 36.31,12.09 36.04,11.82 35.8,11.82 35.49,12.13 35.49,12.47 34.69,13.27 33.95,13.27 31.56,15.67 31.56,22.13 31.94,22.52 31.94,23.49 32.92,24.47 40.55,24.47 41.59,25.51 47.1,25.51 47.93,26.35 51.56,26.35 52.03,26.82 53.62,26.82 54.01,27.22 54.98,27.22 55.56,27.8 55.56,28.94 56.25,29.63 58.96,29.63 59.35,30.01 59.81,30.01 61.34,31.53 64.62,31.53 64.8,31.36 66.26,31.36 67.2,32.29 69.59,32.29 69.87,32.58 73.17,32.58 73.57,32.98 73.57,34.12 74.21,34.75 74.96,34.75 75.45,35.24 77.28,35.24 77.56,35.52 78.86,35.52 79.38,36.04 80.31,36.04 80.72,36.45 82.99,36.45 83.81,37.27 84.97,37.27 85.41,37.71 85.41,39.11 85.25,39.26 85.25,42.51 85.66,42.91 85.79,42.91 86.22,43.35 86.22,47.79 89.01,50.58 90.44,50.58 90.62,50.4 93.25,50.4 93.3,50.35 93.66,50.35 93.74,50.28 93.74,50.1 v2(93.66,50.02)
  BOTTOM w0.079: U1.BK6 93.99,49.65 93.99,49.93 93.88,50.05 93.69,50.05 v2(93.66,50.02)
  BOTTOM w0.102: R2652.1 38.78,11.77 38.7,11.85 38.7,12.18 38.44,12.43 37.86,12.43 37.2,11.77 36.69,11.77 36.31,12.15 v1(36.31,12.19)
PCIE_RXN13_SSD_C: length 1.9
  BOTTOM w0.102: R2652.2 39.05,11.16 38.78,10.89 38.78,10.68 38.71,10.61 38.71,10.46 38.85,10.32 CN16.5
PCIE_RXN14_SSD: length 97.5
  IN3 w0.089: v2(93.66,50.96) 93.66,51.12 93.4,51.38 87.81,51.38 85.4,48.97 85.4,48.59 84.47,47.66 84.47,42.41 84.62,42.26 84.62,40.82 84.21,40.42 84.21,39.73 83.84,39.35 83.84,38.16 83.15,37.48 82.46,37.48 82.4,37.41 80.83,37.41 80.05,36.64 79.13,36.64 78.61,36.11 78.08,36.11 77.51,36.69 77.05,36.69 76.87,36.51 76.87,36.18 76.54,35.85 74.97,35.85 74.47,35.35 73.16,35.35 72.56,34.75 72.16,34.75 71.49,34.07 70.45,34.07 69.28,32.9 66.84,32.9 66.05,32.12 65.47,32.12 65.34,32.24 61.2,32.24 59.61,30.65 58.43,30.65 58.12,30.34 56.07,30.34 55.13,29.4 48.88,29.4 48.32,28.84 45.62,28.84 44.45,27.67 42.86,27.67 42.38,27.19 42.38,26.68 41.87,26.17 41.36,26.17 40.27,25.08 32.69,25.08 31.33,23.72 31.33,22.79 30.95,22.41 30.95,15.43 33.67,12.71 33.67,12.46 33.92,12.2 34.15,12.2 34.33,12.38 34.33,12.48 v1(34.22,12.59)
  BOTTOM w0.079: U1.BJ6 93.98,50.58 93.98,50.9 93.91,50.96 v2(93.66,50.96)
  BOTTOM w0.102: R2654.1 35.52,11.77 35.42,11.87 35.42,12.25 35.24,12.43 34.71,12.43 34.51,12.23 34.35,12.23 34.17,12.41 34.17,12.53 v1(34.22,12.59)
