# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V on IN1 (solid shape): 54.74,103.62 58.38,103.62 59.62,102.38 59.62,101.97 59.5,101.84 58.61,101.84 57.85,102.6 56.97,102.6 56.81,102.75 52.61,102.75 51.62,103.75 51.62,105.68 51.82,105.88 52.49,105.88
+3V on IN1 (solid shape): outline of 261 points within 22.92,28.05 34.22,39.74
+3V on IN1 (solid shape): outline of 799 points within 64.72,19.92 82.28,28.64
+3V on IN2 (solid shape): outline of 83 points within 77.15,22.29 94.65,27.11
+3V on IN2 (solid shape): outline of 9350 points within 16.83,4.87 61.07,115.53
+3V on SVCC (solid shape): outline of 129 points within 29.53,24.37 65.97,32.37
+3V on SVCC (solid shape): outline of 419 points within 48.7,23.61 217.28,126.48
+3V3_TPM on TOP (solid shape): 129.42,23.4 129.42,23.3 129.31,23.17 129.27,23 129.38,22.73 129.76,22.63 129.85,22.67 129.87,22.68 129.95,22.68 130.01,22.66 130.03,22.66 130.17,22.66 130.36,22.47 131.18,22.47 131.19,22.43 131.24,22.36 131.32,22.33 131.7,22.33 131.76,22.35 131.8,22.39 131.87,22.43 131.95,22.4 132.01,22.34 132.01,21.83 132.12,21.73 132.12,21.54 132.15,21.45 132.24,21.41 132.94,21.41 133.4,20.95 133.4,19.02 133.31,18.93 132.5,18.93 132.42,19.01 132.42,20.38 131.86,20.94 131.12,20.94 131.12,20.94 129.09,20.94 128.91,21.12 128.91,21.86 128.89,21.94 128.82,21.98 128.81,21.99 128.79,22.01 128.79,22.06 128.74,22.06 128.71,22.08 127.7,22.08 127.7,22.49 127.72,22.53 127.72,22.56 127.72,22.62 127.96,22.86 127.99,22.87 128.11,22.88 128.19,22.91 128.27,22.98 128.32,23.03 128.89,23.61 129.22,23.61
+3V3_TPM on IN3 (solid shape): outline of 236 points within 121.4,19.67 129.9,23.74
+3V3_TPM_VSB on TOP (solid shape): 128.59,18.53 128.46,18.4 128.46,17.89 128.71,17.64 129.09,17.64 129.22,17.51 133.71,17.51 133.72,17.47 133.76,17.38 133.84,17.35 134.66,17.35 134.69,17.35 134.77,17.33 134.81,17.25 134.81,16.5 134.56,16.24 128.46,16.24 128.23,16.47 128.23,16.75 128.23,16.8 128.13,17.05 127.87,17.16 127.83,17.15 127.75,17.18 127.72,17.26 127.72,18.79 127.79,18.86 128.59,18.86
+3V_DEEP_SUS on TOP (solid shape): 64.07,40.93 64.07,39.89 63.91,39.89 63.75,39.73 63.67,39.73 63.51,39.67 63.44,39.51 63.44,38.44 63.51,38.28 63.67,38.22 63.75,38.22 64.7,37.26 64.7,36.05 63.82,35.17 63.82,31.52 63.79,31.48 63.78,31.47 63.64,31.34 63.59,31.16 63.62,31 63.72,30.88 63.76,30.82 63.75,30.75 63.72,30.67 63.71,30.59 63.74,30.45 63.82,30.34 63.82,30.09 63.69,29.96 63.33,29.96 63.3,29.97 63.28,30.01 63.28,30.03 63.18,30.14 63.18,30.59 63.26,30.67 63.26,31.38 62.98,31.66 62.98,40.83 63.26,41.11 63.89,41.11
+3V_DEEP_SUS on TOP (solid shape): outline of 232 points within 81.75,25.61 93.41,31.23
+3V_DEEP_SUS on BOTTOM (solid shape): 92.57,22.9 92.57,22.69 92.16,22.29 92.16,21.78 92.26,21.68 92.26,20.86 91.76,20.86 91.76,21.22 90.84,22.13 90.33,22.13 90.03,22.44 90.03,22.64 90.08,22.69 90.18,22.69 90.38,22.49 91.86,22.49 92.31,22.95 92.52,22.95
+3V_DEEP_SUS on BOTTOM (solid shape): 89.34,27.47 89.34,27.06 89.33,27.03 89.29,27.01 88.96,26.79 89.04,26.4 89.07,26.33 89.04,26.26 88.66,25.87 88.64,25.87 88.34,25.72 88.3,25.39 88.3,25.35 88.29,25.31 85.81,25.31 85.79,25.34 85.79,26.17 85.84,26.22 85.84,26.52 87.13,26.52 87.18,26.53 87.29,26.53 87.34,26.58 87.34,26.73 87.51,26.91 88.58,26.91 88.58,27.06 88.66,27.14 88.66,27.42 88.76,27.52 89.29,27.52
+3V_DEEP_SUS on BOTTOM (solid shape): 63.56,25.03 63.56,24.77 63.5,24.68 63.4,24.69 63.28,24.75 63.16,24.78 62.77,24.4 63.16,24.01 63.28,24.04 63.4,24.1 63.5,24.11 63.56,24.02 63.56,22.49 63.16,22.08 62.61,22.08 62.57,22.1 62.56,22.14 62.56,23.25 62.15,23.66 61.21,23.66 60.48,24.39 60.47,24.39 60.44,24.42 60.44,24.45 60.46,24.48 60.52,24.55 60.54,24.65 60.54,24.93 60.53,24.99 60.5,25.05 60.49,25.07 60.49,25.11 60.77,25.39 63.2,25.39
+3V_DEEP_SUS on IN2 (solid shape): outline of 1061 points within 61.12,22.31 84.31,31.48
+3V_DEEP_SUS on IN3 (solid shape): outline of 96 points within 87.18,25.89 91.12,27.38
+3V_DMIC on BOTTOM (solid shape): 39.43,116.72 39.43,115.84 39.13,115.54 39.13,115.35 39.11,115.32 39.08,115.3 36.26,115.3 36,115.56 36,116.57 36.23,116.8 39.36,116.8
+3V_LAN on TOP (solid shape): 44.14,103.79 44.14,102.78 44.22,102.7 44.22,101.99 44.16,101.93 43.7,101.93 43.61,102.01 43.61,102.31 43.94,102.64 43.94,103.79 43.94,103.8 44.13,103.8
+3V_LAN on TOP (solid shape): 51.26,111.33 51.26,109.94 49.77,108.44 48.64,108.44 48.39,108.2 48.39,106.84 47.85,106.3 46.26,106.3 46.25,106.31 46.25,106.48 46.27,106.5 47.57,106.5 47.98,106.9 47.98,108.78 48.39,109.19 48.39,109.65 48.21,109.83 48.21,111.33 48.37,111.49 51.1,111.49
+3V_LAN on TOP (solid shape): 41.67,111.49 41.67,110.91 41.77,110.81 41.77,110.78 41.99,110.56 41.99,108.68 42.35,108.32 43.11,108.32 43.34,108.09 43.34,107.03 43.06,107.03 43.04,107.05 43.04,107.76 42.89,107.91 42.33,107.91 42.07,108.16 41.41,108.16 41.33,108.24 41.33,109.7 41.16,109.87 39.99,109.87 39.53,110.32 39.53,111.62 39.61,111.7 41.46,111.7
+3V_LAN on IN1 (solid shape): 52.08,111.31 52.08,109.61 51.95,109.49 50.1,109.49 49.87,109.71 49.87,111.34 50.15,111.62 51.78,111.62
+3V_LAN on IN3 (solid shape): outline of 504 points within 40.19,109.87 51.26,115.86
+3V_LDO_EC on TOP (solid shape): 193.72,33.88 193.72,33.13 193.71,33.08 193.71,33.03 193.71,32.99 193.72,32.94 193.72,32.43 193.66,32.37 192.09,32.37 191.96,32.5 191.96,33.79 192.26,34.1 193.51,34.1
+3V_RTC on TOP (solid shape): 47.1,28.03 47.1,27.7 47.26,27.55 48.58,27.55 48.83,27.29 48.83,26.45 48.8,26.43 48.8,24.17 48.81,24.16 48.57,23.91 48.4,23.91 48.09,24.22 48.09,24.78 47.64,25.23 46.65,25.23 46.42,25.46 46.42,26.43 46.42,26.53 46.11,26.84 46.11,27.63 46.04,27.7 46.04,27.97 46.25,28.18 46.95,28.18
+3V_RTC on TOP (solid shape): 66.86,24.62 66.86,23.91 66.85,23.87 66.67,23.78 66.61,23.63 66.61,23.35 66.63,23.25 66.69,23.18 66.73,23.1 66.69,23.02 66.63,22.95 66.61,22.85 66.61,22.72 66.61,22.72 66.21,22.72 65.85,23.08 65.85,24.37 66.23,24.75 66.74,24.75
+3V_RTC on IN1 (solid shape): outline of 195 points within 45.02,11.92 47.43,16.75
+3V_RTC on IN2 (solid shape): outline of 754 points within 44.61,21.88 62.03,30.24
+3V_RTC_1 on TOP (solid shape): 47.69,24.8 47.69,24.14 47.51,23.96 47.51,23.48 48.3,22.69 48.3,22.26 48.19,22.16 47.86,22.16 47.79,22.24 47.79,22.87 47.74,22.93 47.74,22.95 47.59,23.1 47.03,23.1 46.92,23.2 46.92,24.85 47.01,24.94 47.55,24.94
+3V_RTC_2 on TOP (solid shape): 46.59,24.85 46.59,23.3 46.42,23.13 44.84,23.13 44.84,23.53 45.5,24.19 45.5,24.67 45.32,24.85 44.89,24.85 44.79,24.95 44.79,25.22 44.87,25.29 45.3,25.29 45.45,25.44 46.01,25.44
+3V_S5 on TOP (solid shape): 50.23,112.25 49.97,112 48.58,112 48.32,112.25 48.32,113.4 48.58,113.65 50.23,113.65
+3V_S5 on TOP (solid shape): 86.27,30.77 86.27,29.3 85.25,28.28 85,28.28 84.8,28.48 84.8,30.87 84.85,30.92 86.12,30.92
+3V_S5 on TOP (solid shape): 33.95,23.53 33.74,23.33 32.8,23.33 32.71,23.42 32.71,23.85 32.7,23.86 32.7,24.24 33.08,24.62 33.08,24.85 33.39,25.16 33.95,25.16
+3V_S5 on TOP (solid shape): 161.71,24.14 161.71,22.62 162.25,22.07 162.25,21.2 159.52,21.2 159.32,21.4 159.32,22.11 159.8,22.59 159.83,22.59 159.98,22.74 160.17,22.74 160.26,22.78 160.29,22.87 160.29,24.2 160.49,24.4 161.45,24.4
+3V_S5 on TOP (solid shape): 62.67,28.79 62.95,28.51 64.22,28.51 64.22,28.08 64.2,28.05 62.93,28.05 62.8,28.18 62.55,28.18 62.36,27.99 62.33,27.97 62.3,27.94 62.16,27.8 62.16,27.47 61.77,27.47 61.66,27.59 61.66,28.05 62.16,28.56 62.17,28.95 62.39,29.18 62.39,29.2 62.67,29.2
+3V_S5 on TOP (solid shape): 65.59,24.57 65.59,22.97 66.18,22.39 66.56,22.39 66.84,22.11 66.84,21.86 66.89,21.67 67.04,21.54 67.05,21.53 67.25,21.32 67.27,21.32 67.35,21.25 68.9,21.25 68.95,21.2 70.37,21.2 70.39,21.17 70.39,20.66 70.29,20.56 69.72,20.56 69.69,20.53 67.27,20.53 66.95,20.85 66.78,20.85 65.67,21.96 65.67,22.19 64.25,23.61 64.2,23.61 63.69,24.12 63.69,24.57 63.94,24.83 65.34,24.83
+3V_S5 on TOP (solid shape): 191.07,33.09 191.07,32.42 191.06,32.39 191.02,32.37 190.97,32.37 190.96,32.38 190.83,32.45 190.69,32.48 190.58,32.46 190.47,32.42 190.45,32.41 190.42,32.42 190.32,32.46 190.2,32.48 189.98,32.48 189.86,32.46 189.75,32.41 189.43,32.41 189.19,32.65 189.19,33.16 189.55,33.51 190.64,33.51
+3V_S5 on TOP (solid shape): 44.31,29.94 44.31,29.42 44.38,29.34 44.38,27.67 44.51,27.55 44.64,27.55 45.05,27.14 45.05,26.17 44.88,26.01 43.54,26.01 43.53,26.01 42.85,26.01 42.68,26.17 42.68,27.39 42.84,27.55 42.94,27.54 43.18,27.63 43.31,27.86 43.32,29.22 42.98,29.56 42.91,29.56 42.86,29.61 42.39,29.61 42.35,29.61 42.31,29.6 42,29.6 41.94,29.66 41.94,29.85 41.99,29.9 42.83,29.9 42.83,29.96 42.96,29.96 43.1,30.1 44.15,30.1
+3V_S5 on TOP (solid shape): 74.86,22.34 74.86,22.08 74.93,22.02 74.93,21.03 75.07,20.89 75.65,20.89 75.9,20.65 75.9,19.9 76.08,19.71 76.08,19.11 75.93,18.96 75.53,18.96 75.29,18.96 74.66,18.34 74.53,18.21 74.53,18.01 74.53,16.88 74.03,16.37 71.28,16.37 71.21,16.45 71.21,16.72 73.65,16.72 73.85,16.93 73.85,17.59 73.49,17.94 73.49,18.63 73.79,18.92 74.5,18.92 74.69,19.12 74.76,19.12 74.83,19.13 74.89,19.15 74.9,19.16 74.99,19.16 75.36,19.54 75.37,19.54 75.5,19.67 75.55,19.85 75.54,19.94 75.51,20.02 75.5,20.03 75.5,20.05 75.25,20.31 74.66,20.31 74.46,20.1 74.05,20.1 73.85,20.31 73.85,20.86 74.23,21.25 74.23,22.34 74.43,22.54 74.66,22.54
+3V_S5 on BOTTOM (solid shape): 64.79,124.67 64.79,124.01 64.67,123.88 64.67,123.01 64.63,122.97 64.3,122.97 63.78,123.49 63.78,124.3 63.86,124.45 63.89,124.62 63.89,124.65 63.87,124.8 63.8,124.93 63.8,124.97 63.81,125 63.84,125.03 64.44,125.03
+3V_S5 on BOTTOM (solid shape): 195.08,27.16 195.15,27.16 195.26,27.06 195.26,27.03 194.9,26.67 194.9,25.87 194.78,25.75 194.78,24.84 194.68,24.75 193.64,24.75 193.57,24.82 193.57,25.17 194.08,25.68 194.08,27.21 194.21,27.34 194.26,27.52 194.25,27.6 194.22,27.68 194.21,27.71 194.27,27.77 194.47,27.77
+3V_S5 on BOTTOM (solid shape): 160.09,22.97 160.13,22.96 160.19,22.85 160.27,22.82 161.36,22.82 161.44,22.85 161.49,22.93 161.49,22.95 161.52,22.97 162.37,22.97 162.62,22.72 162.62,21.48 162.46,21.32 159.19,21.32 159.07,21.45 159.07,22.92 159.08,22.96 159.12,22.97
+3V_S5 on BOTTOM (solid shape): 68.5,23.79 68.57,23.75 68.72,23.61 68.72,22.89 68.67,22.71 68.72,22.53 68.72,21.22 68.7,21.18 68.67,21.17 66.46,21.17 66.36,21.27 66.36,21.99 66.42,22.06 66.81,22.06 66.83,22.08 66.87,22.1 66.9,22.08 66.91,22.07 66.92,22.05 66.92,22.04 67.48,21.72 67.35,22.35 67.28,22.43 67.3,22.52 67.47,22.69 67.47,22.73 67.52,22.78 67.52,23.63 67.68,23.79
+3V_S5 on BOTTOM (solid shape): outline of 118 points within 63.05,22.13 65.72,39.23
+3V_S5 on BOTTOM (solid shape): outline of 277 points within 29.91,22.97 46.04,27.16
+3V_S5 on IN1 (solid shape): outline of 765 points within 18.6,5.7 34.66,24.24
+3V_S5 on IN2 (solid shape): 20,9.13 20,7.1 19.62,6.72 18.86,6.72 18.6,6.97 18.6,7.52 18.73,7.65 18.73,9.26 18.86,9.38 19.75,9.38
+3V_S5 on IN2 (solid shape): 20.32,19.87 20.41,19.83 20.42,19.74 20.41,19.69 20.41,19.65 20.5,19.41 20.74,19.31 20.84,19.33 20.93,19.38 21.02,19.39 21.08,19.34 21.17,19.25 21.17,18.96 20.33,18.12 19.54,18.12 19.12,18.54 19.12,19.73 19.26,19.87
+3V_S5 on IN2 (solid shape): 14.42,46.11 14.51,46.05 14.5,45.95 14.43,45.83 14.41,45.71 14.79,45.32 15.18,45.71 15.15,45.83 15.09,45.95 15.08,46.05 15.17,46.11 15.58,46.11 15.63,46.06 15.63,43.98 15.56,43.9 14.21,43.9 14.13,43.99 14.1,44.02 14.06,44.05 13.59,44.53 13.47,44.51 13.29,44.59 13.22,44.77 13.25,44.88 13.32,44.97 13.37,45.01 13.37,45.58 13.9,46.11
+3V_S5 on IN2 (solid shape): outline of 203 points within 66.31,20.81 78.04,22.72
+3V_S5 on IN2 (solid shape): outline of 1325 points within 15.17,89.22 50,115.73
+3V_S5 on SVCC (solid shape): outline of 749 points within 3.02,34.02 24.83,93.46
+3V_S5 on SVCC (solid shape): outline of 259 points within 31.94,20.43 195.13,32.88
+3V_S5 on IN3 (solid shape): 50.43,113.42 50.43,112.79 50.25,112.61 48.5,112.61 47.61,113.5 47.81,113.7 50.15,113.7
+3V_S5 on IN3 (solid shape): 64.78,123.28 64.78,122.64 63.97,121.83 63.84,121.83 63.23,122.44 63.23,122.54 64.2,123.51 64.55,123.51
+3V_SSD on TOP (solid shape): 22.16,8.5 22.16,6.46 22.41,6.21 22.41,5.7 23.05,5.07 23.05,4.18 23.3,3.92 24.45,3.92 24.57,3.8 24.57,2.4 24.45,2.27 23.44,2.27 23.44,2.28 22.28,2.28 22.27,2.29 21.93,2.29 21.58,2.63 21.58,3.61 21.78,4.7 21.02,5.5 21.02,8.24 21.4,8.62 22.03,8.62
+3V_SSD on TOP (solid shape): 36.07,4.43 36.45,4.43 36.48,4.43 37.04,4.43 37.12,4.4 37.15,4.33 37.15,4.3 37.16,4.18 37.22,4.07 37.22,3.52 37.22,3.32 37.22,3.26 37.6,2.88 37.98,3.26 37.94,3.43 37.83,3.57 37.83,4.07 37.89,4.18 37.91,4.3 37.91,4.33 37.94,4.4 38.01,4.43 38.7,4.43 38.73,4.43 39.11,4.43 39.18,4.43 39.43,4.18 39.43,2.27 39.3,2.15 35.62,2.15 35.49,2.27 35.49,4.3 35.62,4.43 36.04,4.43
+3V_SSD on BOTTOM (solid shape): 22.73,4.42 23.16,4.42 23.56,4.02 23.56,3.24 23.47,3.15 23.01,3.15 22.79,2.93 22.79,2.91 22.79,2.91 22.77,2.89 22.77,2.85 22.75,2.85 22.75,1.52 22.45,1.52 22.45,2.85 22.25,2.85 22.25,1.52 21.95,1.52 21.95,2.85 21.75,2.85 21.75,1.52 21.28,1.52 21.28,2.83 21.29,2.83 21.29,3.24 21.67,3.65 21.82,4.18 21.82,4.19 22.06,4.43 22.72,4.43
+3V_SSD on BOTTOM (solid shape): 39.65,4.06 39.65,4.05 39.71,3.86 39.81,3.68 39.81,1.67 39.8,1.64 39.76,1.62 39.5,1.62 39.46,1.64 39.45,1.67 39.45,2.75 39.45,2.85 39.25,2.85 39.25,1.67 39.24,1.64 39.2,1.62 39,1.62 38.96,1.64 38.95,1.67 38.95,2.75 38.95,2.91 38.85,3.01 38.09,3.01 37.98,3.12 37.98,3.26 37.6,3.64 37.22,3.26 37.22,3.16 37.24,3.04 37.29,2.93 37.29,2.85 37.25,2.85 37.25,1.67 37.24,1.64 37.2,1.62 37,1.62 36.96,1.64 36.95,1.67 36.95,2.75 36.95,2.85 36.75,2.85 36.75,1.67 36.74,1.64 36.7,1.62 36.5,1.62 36.46,1.64 36.45,1.67 36.45,2.75 36.45,2.85 36.25,2.85 36.25,1.67 36.24,1.64 36.2,1.62 36,1.62 35.96,1.64 35.95,1.67 35.95,2.75 35.95,2.85 35.75,2.85 35.75,1.67 35.74,1.64 35.7,1.62 35.5,1.62 35.46,1.64 35.45,1.67 35.45,2.75 35.45,2.85 35.44,2.85 35.44,2.93 35.37,3.01 35.37,4.02 35.75,4.4 39.3,4.4
+3V_SSD on IN2 (solid shape): outline of 263 points within 21.57,2.06 39.81,4.56
+3V_WLAN_P on BOTTOM (solid shape): 192.47,12.56 194.96,12.56 195.9,11.62 195.9,11.24 195.69,11.04 194.85,11.04 194.82,11.04 194.44,11.04 194.41,11.04 194.08,11.04 194.05,11.04 193.67,11.04 193.64,11.04 193.32,11.04 193.29,11.04 192.91,11.04 192.88,11.04 192.43,11.04 192.4,11.04 192.21,11.04 190.94,12.31 190.94,12.43 190.82,12.56 190.05,12.56 189.93,12.69 189.93,12.98 189.94,13.02 189.98,13.03 191.55,13.03 191.55,13.23 189.98,13.23 189.94,13.24 189.93,13.28 189.93,13.45 190.01,13.53 191.49,13.53
+3V_WLAN_P on BOTTOM (solid shape): outline of 85 points within 190.06,24.14 194.37,31.08
+3V_WLAN_P on IN1 (solid shape): outline of 738 points within 190.51,11.38 198.31,24.86
+3VLCD_CON on TOP (solid shape): 63.14,103.87 63.18,103.86 63.19,103.82 63.19,103.5 63.43,103.26 63.43,102.22 63.18,101.97 62.82,101.97 62.8,101.97 62.78,101.99 62.5,102.13 62.21,101.99 62.2,101.98 62.18,101.97 62.14,101.97 61.78,102.33 61.78,102.48 62.06,102.75 62.37,102.75 62.55,102.93 62.55,103.8 62.62,103.87
+3VLCD_CON on BOTTOM (solid shape): 78.74,98.22 78.74,97.89 78.75,97.83 78.79,97.78 79.06,97.52 80.07,97.52 80.2,97.4 80.2,96.53 79.54,95.87 77.25,95.87 77.22,95.89 77.2,95.92 77.2,96.51 77.61,96.91 77.61,98.37 77.78,98.54 78.42,98.54
+3VLCD_CON on IN2 (solid shape): outline of 518 points within 61.53,97.78 78.58,102.91
+3VLCD_CON_R on TOP (solid shape): 61.63,106.13 61.63,105.66 61.63,105.46 62.16,104.92 62.16,103.85 62.04,103.72 62.04,103.09 61.93,102.98 61.28,102.98 61.02,103.24 61.02,103.98 60.9,104.1 60.9,105.15 60.77,105.27 60.77,105.89 60.78,105.94 60.79,105.98 60.79,106.18 61.02,106.41 61.35,106.41
+3VLCD_CON_R on BOTTOM (solid shape): 61.51,107.57 61.5,107.54 61.5,107.34 61.49,107.31 61.47,107.26 61.45,107.21 61.44,107.15 61.44,107.13 61.44,105.67 61.66,105.46 61.66,104.63 61.53,104.51 60.26,104.51 60.13,104.63 60.13,105.46 60.26,105.58 60.26,106.71 61.2,106.71 61.2,107.54 61,107.54 61,106.71 60.7,106.71 60.7,107.54 60.5,107.54 60.5,106.71 60.26,106.71 60.26,107.68 60.26,107.68 61.4,107.68
+3VPCU on TOP (solid shape): 43.24,22.85 46.42,22.85 46.42,21.83 46.29,21.7 46.04,21.7 45.32,22.41 42.02,22.41 41.21,23.23 41.21,23.74 41.46,23.99 42.1,23.99
+3VPCU on TOP (solid shape): 138.78,29.2 138.85,29.15 138.93,29.13 138.95,29.12 139,29.07 139,28.12 138.71,27.82 138.19,27.82 138.14,27.88 138.14,28.23 137.98,28.38 137.98,29.02 138.16,29.2
+3VPCU on TOP (solid shape): 157.85,29.68 157.85,28.06 157.72,27.93 156.9,27.93 156.83,27.93 156.77,27.92 156.72,27.9 156.67,27.87 156.62,27.84 156.58,27.8 156.55,27.76 156.53,27.71 156.51,27.65 156.5,27.6 156.5,27.52 156.34,27.37 155.57,27.37 155.56,27.38 155.95,27.38 155.95,28.09 155.75,28.09 155.75,27.38 155.56,27.38 155.55,27.38 155.55,28.29 155.58,28.3 155.62,28.32 155.66,28.36 155.69,28.4 155.72,28.44 155.74,28.49 155.76,28.54 155.76,28.59 155.76,28.64 155.76,28.69 155.74,28.75 155.71,28.8 155.68,28.84 155.66,28.87 155.54,28.99 153.99,28.99 153.88,28.88 153.88,28.39 153.93,28.34 153.94,28.3 153.98,28.26 154.02,28.22 154.06,28.19 154.09,28.17 154.15,28.11 154.15,27.38 154.14,27.37 153.96,27.37 153.95,27.39 153.95,28.09 153.75,28.09 153.75,27.4 153.72,27.37 153.42,27.37 152.85,27.94 152.84,27.93 152.46,27.93 152.37,28.02 152.37,30.37 152.77,30.77 156.75,30.77
+3VPCU on BOTTOM (solid shape): 214.23,32.5 214.48,32.5 214.95,32.04 214.95,30.85 214.82,30.72 214.44,30.72 214.36,30.8 214.36,32.08 214.2,32.25 212.89,32.25 212.89,32.55 214.18,32.55
+3VPCU on IN1 (solid shape): 41.21,31.39 41.21,30.57 41.06,30.42 39.74,30.42 39.48,30.67 39.48,31.56 39.64,31.72 40.88,31.72
+3VPCU on IN1 (solid shape): 214.79,31.89 214.79,30.72 214.69,30.62 214.16,30.62 213.98,30.8 213.98,31.99 214.06,32.07 214.62,32.07
+3VPCU on IN1 (solid shape): 26.6,72.76 26.6,72.62 26.6,72.61 26.58,72.48 26.6,72.35 26.6,72.34 26.6,71.98 26.6,71.97 26.58,71.84 26.6,71.71 26.6,71.7 26.6,71.35 26.6,71.34 26.58,71.21 26.6,71.08 26.6,71.07 26.6,70.49 26.6,70.34 26.64,70.31 26.64,70.3 26.72,70.2 26.82,70.13 26.82,70.13 27.24,69.71 27.24,68.82 26.74,68.31 25.97,68.31 25.82,68.46 25.82,71.83 25.82,71.83 25.82,73.06 25.97,73.21 26.15,73.21
+3VPCU on IN2 (solid shape): 41.54,31.56 41.54,31.1 41.36,30.92 40.09,30.92 39.71,31.3 39.71,32.04 39.97,32.29 40.8,32.29
+3VPCU on IN2 (solid shape): 116.09,45.78 116.09,44.39 115.96,44.26 114.64,44.26 114.36,44.54 114.36,45.71 114.62,45.96 115.91,45.96
+3VPCU on IN2 (solid shape): 27.11,70.09 27.24,69.96 27.24,68.9 27.16,68.83 27.16,67.45 27.02,67.31 26.44,67.31 26.4,67.35 26.4,70.01 26.48,70.09 26.97,70.09
+3VPCU on IN2 (solid shape): 179.06,27.95 179.06,27.82 179.04,27.8 179.01,27.75 178.98,27.7 178.96,27.65 178.95,27.6 178.95,27.54 178.96,27.49 178.98,27.44 179.01,27.39 179.04,27.34 179.06,27.33 179.06,27.02 178.8,26.76 177.32,26.76 176.9,27.18 176.9,27.55 177.73,27.55 177.73,27.49 177.74,27.44 177.76,27.39 177.78,27.34 177.81,27.3 177.85,27.26 177.89,27.22 177.94,27.2 177.99,27.18 178.04,27.17 178.09,27.16 178.14,27.17 178.2,27.18 178.25,27.2 178.29,27.22 178.33,27.26 178.37,27.3 178.4,27.34 178.42,27.39 178.44,27.44 178.45,27.49 178.45,27.55 178.44,27.6 178.42,27.65 178.4,27.7 178.37,27.74 178.33,27.78 178.29,27.81 178.25,27.84 178.2,27.86 178.14,27.87 178.09,27.88 178.04,27.87 177.99,27.86 177.94,27.84 177.89,27.81 177.85,27.78 177.81,27.74 177.78,27.7 177.76,27.65 177.74,27.6 177.73,27.55 176.9,27.55 176.9,28 177.15,28.25 178.77,28.25
+3VPCU on IN2 (solid shape): 195.05,36.25 195.05,35.71 192.59,33.25 191.13,33.25 190.78,33.61 190.63,33.61 190.63,33.69 190.68,33.73 190.75,33.75 190.82,33.72 190.93,33.64 191.07,33.61 191.43,33.97 191.07,34.33 190.94,34.3 190.83,34.23 190.76,34.21 190.69,34.23 190.59,34.29 190.47,34.31 190.35,34.29 190.25,34.23 190.18,34.2 190.11,34.23 190,34.31 189.86,34.34 189.63,34.24 189.53,34.01 189.56,33.89 189.62,33.78 189.64,33.67 189.55,33.61 187.74,33.61 187.52,33.39 187.43,33.36 187.35,33.41 187.22,33.56 187.03,33.62 186.91,33.59 186.8,33.53 186.73,33.51 186.66,33.55 186.37,33.67 186.09,33.5 186.03,33.45 185.96,33.46 185.86,33.5 185.76,33.51 185.55,33.45 185.41,33.28 185.34,33.23 185.25,33.25 185.22,33.28 182.76,33.28 182.43,32.95 180.87,32.95 180.63,32.7 180.41,32.7 180.27,32.84 180.27,33.35 180.17,33.44 180.17,33.53 180.22,33.58 180.65,33.58 181.05,33.59 181.32,33.59 181.33,33.6 183.76,33.76 186.18,34.07 190.55,35.02 194.79,36.44 194.8,36.44 194.85,36.44
+3VPCU on IN2 (solid shape): outline of 88 points within 137.91,27.65 153.88,30.25
+3VPCU on IN2 (solid shape): outline of 239 points within 47.61,104.74 54.54,110.6
+3VPCU on IN3 (solid shape): outline of 1137 points within 113.55,27.04 139.1,45.45
+3VSPI on TOP (solid shape): 132.17,20.28 132.17,18.86 132.42,18.6 132.42,17.84 132.35,17.77 131.3,17.77 131.08,17.99 131.08,20.53 131.23,20.69 131.76,20.69
+3VSPI on TOP (solid shape): 163.82,33.31 163.82,32.35 163.64,32.17 162.27,32.17 162.05,32.38 162.05,33.1 162.21,33.25 162.4,33.25 162.56,33.41 163.71,33.41
+3VSPI on BOTTOM (solid shape): outline of 97 points within 157.16,21.2 163.51,34.66
+3VSPI on IN3 (solid shape): 116.27,23.1 116.27,22.82 116.22,22.77 115.89,22.77 115.2,23.46 115.2,23.71 115.28,23.79 115.58,23.79
+5V on TOP (solid shape): 18.48,32.24 18.48,28.69 18.06,28.27 15.75,28.27 15.66,28.36 15.66,31.86 16.29,32.5 18.22,32.5
+5V on TOP (solid shape): 176.38,28.17 176.25,28.04 176.24,28.04 176.19,27.99 176.18,27.93 176.18,26.55 175.98,26.35 174.56,26.35 173.75,27.16 173.75,27.59 173.79,27.68 173.8,27.77 173.8,27.8 174,28 174.18,28 174.97,28.79 175.17,28.79 175.58,29.2 176.38,29.2
+5V on TOP (solid shape): 215.49,15.53 215.53,15.53 215.58,15.48 215.71,15.48 216.03,15.16 216.03,13.74 215.8,13.52 215.73,13.52 215.48,13.42 215.38,13.17 215.39,13.07 215.43,12.98 215.43,12.84 215.28,12.69 214.69,12.69 214.69,15.51 214.76,15.57 215.44,15.57
+5V on TOP (solid shape): 62.04,101.71 62.04,101.21 62.09,101.16 62.09,100.98 62.15,100.82 62.31,100.75 62.37,100.75 62.4,100.74 62.42,100.7 62.42,99.55 62.29,99.43 61.4,99.43 61.02,99.81 61.02,100.82 60.77,101.08 60.23,101.08 60.15,101.12 60.14,101.21 60.15,101.27 60.16,101.33 60.05,101.58 59.77,101.7 59.75,101.74 59.75,102.6 60.01,102.86 60.89,102.86
+5V on TOP (solid shape): outline of 565 points within 203.11,23.84 214.67,32.65
+5V on BOTTOM (solid shape): 215.99,15.84 215.99,13.7 215.83,13.55 215.43,13.55 214.65,14.33 214.65,14.49 214.65,14.54 214.63,14.58 214.61,14.62 214.58,14.65 214.56,14.67 213.56,14.67 213.29,14.67 213.17,14.79 213.17,14.97 214.4,14.97 214.4,15.17 213.56,15.17 213.56,14.97 213.17,14.97 213.17,15.47 214.4,15.47 214.4,15.67 213.56,15.67 213.56,15.47 213.17,15.47 213.17,15.88 213.26,15.97 215.86,15.97
+5V on BOTTOM (solid shape): 212.08,30.45 212.12,30.46 212.15,30.45 212.25,30.41 212.36,30.39 212.42,30.39 212.47,30.41 212.57,30.4 212.61,30.31 212.61,27.93 212.57,27.85 212.48,27.83 212.42,27.85 212.36,27.85 212.18,27.81 212.05,27.7 211.9,27.55 211.26,27.55 211.18,27.63 211.18,27.67 211.19,27.67 211.19,28.74 211.43,28.98 211.46,28.98 211.56,28.93 211.67,28.92 211.94,29.03 212.05,29.3 212.03,29.43 211.96,29.54 211.95,29.56 211.95,29.67 211.96,29.69 212.03,29.8 212.05,29.93 212.03,30.06 211.96,30.18 211.95,30.19 211.95,30.31
+5V on BOTTOM (solid shape): 196.49,19.04 196.51,19.03 196.53,19.02 196.58,18.97 196.64,18.93 196.69,18.83 196.63,18.75 196.49,18.61 196.43,18.42 196.79,18.07 197.14,18.42 197.09,18.61 196.96,18.74 196.91,18.83 196.96,18.92 196.99,18.93 197.02,18.94 197.05,18.92 197.29,18.68 197.29,18.14 197.33,18.05 197.42,18.01 197.96,18.01 198.18,17.79 198.18,15.89 198.08,15.79 198.08,15.3 198.05,15.23 197.75,15.09 197.65,14.85 197.69,14.68 197.8,14.56 197.84,14.48 197.81,14.4 197.75,14.34 197.09,14.34 196.68,14.74 196.68,14.97 196.91,15.2 196.91,16.09 196.9,16.18 196.96,16.25 197.13,16.38 197.19,16.59 197.18,16.66 197.16,16.73 197.16,16.8 197.2,16.85 197.31,16.98 197.35,17.15 197.25,17.4 196.99,17.5 196.87,17.48 196.77,17.42 196.71,17.41 196.68,17.46 196.68,17.51 196.35,17.85 196.33,17.87 196.33,17.89 196.34,17.93 196.34,17.97 196.24,18.22 195.98,18.32 195.9,18.31 195.82,18.28 195.81,18.27 195.77,18.27 195.69,18.35 195.69,18.61 196.07,18.98 196.27,18.98 196.35,18.99 196.41,19.03 196.42,19.04
+5V on BOTTOM (solid shape): outline of 254 points within 12.38,81.14 22.29,86.85
+5V on BOTTOM (solid shape): outline of 325 points within 118.43,14.51 126.05,20.9
+5V on IN1 (solid shape): 18.53,32.03 18.53,28.69 18.38,28.54 16.14,28.54 15.51,29.17 15.51,32.65 15.71,32.85 17.71,32.85
+5V on IN1 (solid shape): outline of 460 points within 13.27,70.65 23.38,86.09
+5V on IN1 (solid shape): outline of 493 points within 128.15,25.91 145.1,28.74
+5V on IN2 (solid shape): outline of 182 points within 165.95,26.21 175.45,28.03
+5V on IN2 (solid shape): outline of 231 points within 143.57,25.85 154.37,28.21
+5V on SVCC (solid shape): outline of 1269 points within 1.52,1.52 218.28,33.51
+5V_HDMIC on BOTTOM (solid shape): 15.96,83.93 18.1,83.93 19.06,82.96 19.07,82.93 19.06,82.91 19,82.81 18.98,82.69 19.07,82.44 19.3,82.31 19.32,82.31 19.44,82.19 19.44,81.67 19.35,81.58 18.35,81.58 18.33,81.58 17.92,81.98 17.84,81.98 16.65,83.17 16.24,83.17 15.99,82.92 14.26,82.92 13.96,82.61 13.7,82.51 13.6,82.26 13.57,82.23 13.57,81.19 12.13,79.74 11.24,79.74 10.98,80 10.98,81.06 13.85,83.93 15.92,83.93
+5V_KB on BOTTOM (solid shape): outline of 96 points within 195.79,11.72 205.24,15.99
+5V_PVDD on BOTTOM (solid shape): 210.88,33.26 210.88,30.76 210.87,30.74 210.86,30.73 210.78,30.65 210.75,30.54 210.75,30.24 210.78,30.13 210.86,30.05 210.87,30.04 210.88,30.02 210.88,29.72 210.87,29.69 210.72,29.59 210.68,29.45 210.68,29.15 210.72,29.01 210.84,28.93 210.86,28.92 210.88,28.9 210.88,27.8 210.75,27.67 210.02,27.67 209.92,27.77 209.92,28.48 210.12,28.69 210.12,29.91 209.84,30.19 208.98,30.19 208.58,30.58 208.58,30.94 208.61,30.96 208.68,30.96 208.93,30.72 210.05,30.72 210.25,31.08 210.13,31.35 210.12,31.36 210.12,31.38 210.12,32.89 210.12,32.9 210.12,33.23 210.04,33.31 208.95,33.31 208.77,33.13 208.42,33.13 208.37,33.18 208.37,33.29 208.42,33.34 208.65,33.34 208.82,33.51 210.63,33.51
+5V_S5 on TOP (solid shape): 17.89,24.24 17.89,22.74 17.61,22.47 17.61,21.98 17.44,21.8 15.07,21.8 13.68,23.2 13.68,24.01 13.7,24.01 14.18,24.5 17.64,24.5
+5V_S5 on TOP (solid shape): 29.27,17.64 29.27,16.87 30.16,15.99 30.16,14.85 29.65,14.34 27.36,14.34 27.34,14.35 27.33,14.37 27.2,14.53 27,14.59 26.98,14.59 26.73,14.85 26.73,17.64 26.99,17.89 29.02,17.89
+5V_S5 on BOTTOM (solid shape): 21.73,44.31 21.86,44.14 22.06,44.08 22.12,44.09 22.19,44.1 22.62,44.1 23.43,43.29 23.43,42.91 22.74,42.23 21.32,42.23 21.12,42.43 19.7,42.43 19.54,42.58 19.54,43.67 20.18,44.31
+5V_S5 on BOTTOM (solid shape): 203.42,23.06 203.46,23.04 203.51,22.98 203.51,22.91 203.49,22.85 203.49,22.8 203.59,22.54 203.85,22.44 204.03,22.49 204.16,22.63 204.22,22.67 204.29,22.67 204.36,22.65 204.43,22.64 204.55,22.66 204.66,22.73 204.69,22.74 204.73,22.73 204.86,22.65 205.01,22.62 205.18,22.65 205.32,22.74 205.36,22.78 205.61,22.78 205.77,22.94 205.8,22.95 205.84,22.94 205.93,22.85 205.93,21.54 205.91,21.51 205.88,21.49 204.07,21.49 203.9,21.32 203.43,21.32 203.41,21.33 203.28,21.42 203.15,21.45 203.13,21.45 203.11,21.47 202.4,21.47 202.09,21.78 202.09,21.85 202.1,21.86 202.16,21.97 202.18,22.08 202.16,22.21 202.09,22.32 202.09,22.49 202.19,22.59 202.66,22.59 202.75,22.63 202.79,22.72 202.79,22.8 202.8,22.83 202.84,22.85 202.88,22.85 203.04,23.01 203.06,23.02 203.19,23.04 203.29,23.09 203.31,23.1 203.37,23.1
+5V_S5 on BOTTOM (solid shape): 29.96,18.73 29.99,18.61 30.05,18.51 30.08,18.44 30.05,18.37 29.98,18.26 29.96,18.12 29.98,17.99 30.05,17.87 30.08,17.8 30.05,17.74 29.96,17.45 30.1,17.19 30.14,17.11 30.1,17.03 30.01,16.53 30.5,16.38 30.57,16.4 30.64,16.44 30.74,16.45 30.8,16.36 30.8,14.85 30.68,14.73 30.64,14.69 30.41,14.46 27.27,14.46 27.14,14.56 26.99,14.59 26.92,14.59 26.46,14.59 26.42,14.6 26.41,14.64 26.41,14.76 25.81,14.76 25.8,14.93 25.83,14.96 26.41,14.96 26.41,15.26 25.8,15.26 25.8,15.43 25.83,15.46 26.41,15.46 26.41,15.76 25.8,15.76 25.8,15.93 25.83,15.96 26.41,15.96 26.41,16.26 25.8,16.26 25.8,16.43 25.83,16.46 26.41,16.46 26.41,16.62 26.44,16.63 26.51,16.68 26.53,16.76 26.53,16.86 26.88,17.21 26.94,17.21 27.03,17.22 27.13,17.26 28.15,17.26 28.26,17.36 28.26,18.27 28.76,18.78 29.95,18.78
+5V_S5 on IN1 (solid shape): outline of 3825 points within 13.93,11.29 35.67,44.44
+5V_S5 on SVCC (solid shape): outline of 146 points within 20.38,10.27 207.83,25.51
+5VA on TOP (solid shape): outline of 208 points within 199.17,30.45 203.39,38.24
+5VA on BOTTOM (solid shape): 201.66,37.55 202.68,37.55 202.7,37.53 202.7,36.99 202.96,36.74 202.96,35.73 202.86,35.62 202.76,35.73 202.76,36.23 202.6,36.38 202.14,36.38 201.89,36.13 201.46,36.13 201.31,36.28 199.91,36.28 199.68,36.51 199.68,36.84 199.72,36.95 199.74,37.07 199.74,37.3 199.88,37.45 200.09,37.45 200.13,37.49 200.14,37.5 200.22,37.54 200.3,37.6 200.98,37.6 201.04,37.6 201.61,37.6
+5VODD on BOTTOM (solid shape): outline of 287 points within 123.38,16.37 133.03,21.58
+5VPCU on TOP (solid shape): 32.07,16.5 31.94,16.37 30.29,16.37 29.64,17.01 29.64,18.83 29.48,19 29.48,19.62 30.26,20.41 32.07,20.41
+5VPCU on TOP (solid shape): 19.52,47.46 19.52,47.28 19.45,47.21 19.45,46.29 19.52,46.21 19.52,45.93 19.57,45.88 19.57,44.64 19.49,44.56 17.46,44.56 17.21,44.82 17.21,46.7 18.05,47.53 19.44,47.53
+5VPCU on TOP (solid shape): 24.57,30.69 24.57,28.94 24.32,28.69 24.32,28.56 23.88,28.12 23.26,28.12 23.2,28.12 22.9,28.12 22.9,28.32 23.62,28.32 23.62,28.52 22.9,28.52 22.9,28.79 22.85,28.84 22.01,28.84 21.86,28.99 21.86,30.26 22.21,30.62 22.74,30.62 23,30.87 24.4,30.87
+5VPCU on TOP (solid shape): 24.13,26.59 24.13,26.58 24.5,26.21 24.5,26.17 24.52,26.15 24.95,26.15 25.11,26 25.11,25.18 25.01,25.08 24.67,25.08 24.36,24.78 23.67,24.78 23.52,24.62 23.48,24.62 23.25,24.4 23.25,24.09 23.3,24.03 23.3,23.89 23.2,23.79 22.97,23.79 22.87,23.68 21.42,23.68 21.35,23.76 21.35,25.15 21.91,25.71 21.91,25.77 21.99,25.86 22.76,25.86 22.9,26 22.9,26.32 23.62,26.32 23.62,26.52 22.95,26.52 22.91,26.56 22.91,26.68 22.94,26.72 23.62,26.72 23.62,26.73 24,26.73
+5VPCU on BOTTOM (solid shape): 74.25,102.6 74.34,102.56 74.43,102.55 74.53,102.56 74.62,102.6 74.86,102.6 75.12,102.35 75.12,100.16 75.1,100.13 75.07,100.11 74.66,100.11 73.54,101.23 73.54,102.12 73.72,102.3 73.85,102.3 74.15,102.6
+5VPCU on SVCC (solid shape): 157.79,38.96 157.93,38.82 158.08,38.71 162.95,35.85 168.2,33.76 168.43,33.71 168.66,33.69 178.73,33.59 188.15,34.44 197.11,37.45 197.57,37.45 197.98,37.04 197.98,34.43 197.61,34.06 197.49,34.24 197.29,34.3 197.08,34.22 196.97,34.02 194.98,34.02 194.86,34.17 194.68,34.23 194.49,34.17 194.37,34.02 192.39,34.02 192.29,34 192.21,33.95 190.51,32.24 189.4,32.24 188.5,32.85 187.6,32.24 183.12,32.24 183.02,32.22 182.94,32.17 182.18,31.41 179.8,31.41 179.03,32.17 178.95,32.22 178.85,32.24 167.55,32.24 166.99,32.8 166.91,32.86 166.81,32.88 163.59,32.88 161.66,34.81 161.58,34.87 161.48,34.89 149.42,34.89 148.4,35.91 148.4,36.84 148.5,36.94 148.9,36.94 152.33,36.47 155.54,37.76 157.17,38.97 157.78,38.97
+5VPCU on SVCC (solid shape): outline of 190 points within 17.72,16.12 98.61,103.36
+V3.3DX_1.5DX_ADO on TOP (solid shape): 89.8,32.57 90.33,32.57 90.44,32.47 90.44,32.12 90.36,32.04 89.93,32.04 89.55,31.66 89.55,31.46 89.42,31.33 89.04,31.33 88.94,31.43 88.94,32.12 89.01,32.19 89.01,32.78 89.11,32.88 89.5,32.88
+V3A_LX on BOTTOM (solid shape): 151.62,35.22 151.62,31.17 150.77,30.32 147.84,30.32 147.27,29.74 147.27,27.76 147.1,27.6 146.67,27.6 146.34,27.93 146.34,29.71 145.81,30.24 145.81,31.42 145.85,31.46 147.34,31.46 147.99,32.11 147.99,34.03 148.01,34.09 148.02,34.16 147.95,34.36 147.78,34.5 147.78,35.19 147.76,35.21 147.84,35.29 148.39,35.29 148.78,35.67 151.17,35.67
+V3A_LX_R on BOTTOM (solid shape): 145.98,29.2 145.98,27.82 145.81,27.65 145.25,27.65 145.15,27.75 145.15,28.31 145.02,28.43 143.95,28.43 143.83,28.56 143.83,29.2 143.95,29.32 145.86,29.32
+V3A_OUT on TOP (solid shape): 155.9,36.68 155.9,36.19 156.07,36.03 159.49,36.03 159.59,35.93 159.59,34.96 159.25,34.62 159.09,34.62 158.41,33.95 157.64,33.95 157.55,33.86 157.55,33.38 157.48,33.31 156.68,33.31 156.4,33.03 156.4,31.61 156.27,31.48 152.72,31.48 152.59,31.61 152.59,36.05 152.84,36.31 153.35,36.31 153.6,36.56 153.99,36.56 154.11,36.69 154.24,36.69 154.49,36.94 155.64,36.94
+V3A_OUT on BOTTOM (solid shape): 155.89,36.64 155.89,36.13 156.04,35.98 159.61,35.98 159.72,35.88 159.72,35.12 159.58,34.98 159.58,34.97 159.39,34.78 159.19,34.78 158.2,33.79 156.83,33.79 156.56,33.53 156.56,30.7 156.59,30.67 156.59,30.55 156.27,30.23 153.15,30.23 151.93,31.45 151.93,35.03 151.95,35.04 151.95,35.67 152.59,36.31 153.6,36.31 154.11,36.82 155.71,36.82
+V5P5A_LX on BOTTOM (solid shape): 42.12,22.19 42.12,21.96 42.02,21.86 42.02,21.47 42.23,21.27 43.34,21.27 43.45,21.17 43.45,20.05 42.07,20.05 41.31,19.29 41.31,17.72 41.21,17.61 38.31,17.61 38.16,17.77 38.16,20.69 38.75,21.27 40.17,21.27 41.21,22.31 42,22.31
+V5P5A_OUT on TOP (solid shape): 36.64,20.69 36.64,18.27 37.4,17.51 40.96,17.51 41.46,17 41.46,16.37 41.21,16.12 40.57,16.12 40.46,16.19 40.32,16.22 40.19,16.19 40.07,16.12 39.22,16.12 39.2,16.12 39.05,16.25 38.87,16.29 38.7,16.25 38.55,16.12 38.52,16.12 36.06,16.12 36.04,16.12 36.02,16.13 35.75,16.24 35.48,16.13 35.46,16.12 35.44,16.12 33.72,16.12 32.83,17 32.83,20.69 33.57,21.43 35.89,21.43
+V5P5A_OUT on BOTTOM (solid shape): 36.89,20.69 36.89,17.64 35.75,16.5 35.75,16.27 35.72,16.24 35.7,16.24 35.37,15.86 35.7,15.48 35.72,15.48 35.75,15.45 35.75,14.85 35.62,14.72 33.72,14.72 33.46,14.97 33.46,15.99 32.98,16.47 32.42,16.47 31.96,16.93 31.96,17.13 32.45,17.61 32.45,21.07 32.95,21.58 36,21.58
+VCC_CORE on TOP (solid shape): outline of 2154 points within 80.28,51.42 123.48,67.55
+VCC_CORE on BOTTOM (solid shape): outline of 335 points within 100.51,50.15 124.14,67.8
+VCC_CORE on BOTTOM (solid shape): outline of 387 points within 80.5,51.37 83.51,60.39
+VCC_CORE on BOTTOM (solid shape): outline of 599 points within 90.84,51.77 94.88,60.42
+VCC_CORE on IN2 (solid shape): outline of 3242 points within 80.33,52.31 113.55,69.33
+VCC_CORE on SVCC (solid shape): outline of 94 points within 80.45,51.04 126.3,67.3
+VCC_CORE on IN3 (solid shape): outline of 774 points within 82.17,52.17 94.68,60.82
+VCCGT on TOP (solid shape): outline of 2121 points within 82.1,66.79 110.6,85.33
+VCCGT on BOTTOM (solid shape): outline of 2095 points within 77.79,68.87 110.09,94.6
+VCCGT on IN2 (solid shape): outline of 2902 points within 82.84,68.31 99.88,85.08
+VCCGT on SVCC (solid shape): 106.12,84.82 106.11,84.77 106.11,84.72 106.2,84.49 106.44,84.39 106.54,84.41 106.63,84.45 110.42,80.65 110.42,75.15 110.03,74.76 107.79,74.76 107.79,70 110.02,70 110.42,69.6 110.42,68.29 109.94,67.8 94.14,67.8 93.86,67.96 93.59,67.8 91.86,67.8 91.74,67.95 91.55,68.01 91.38,67.96 91.26,67.83 91.13,67.97 90.94,68.02 90.74,67.96 90.61,67.8 83.8,67.8 83.32,68.28 83.51,68.4 83.58,68.62 83.48,68.86 83.25,68.97 83.25,69.33 83.23,69.43 83.17,69.51 82.61,70.07 82.61,73.03 82.97,73.39 83.23,73.39 83.35,73.3 83.5,73.27 83.75,73.37 83.86,73.62 83.85,73.69 83.83,73.75 85.2,75.12 85.26,75.2 85.28,75.3 85.28,80.4 85.84,80.96 85.89,81.04 85.91,81.14 85.91,84.27 86.46,84.82
+VCCGT_+VCORE on TOP (solid shape): outline of 671 points within 82.31,60.56 98.14,68.54
+VCCGT_+VCORE on BOTTOM (solid shape): outline of 156 points within 90.68,60.56 93.19,68.57
+VCCGT_+VCORE on IN1 (solid shape): outline of 153 points within 97.14,60.79 99.5,69.4
+VCCGT_+VCORE on IN3 (solid shape): 90.18,62.7 90.38,62.7 90.5,62.58 91.14,62.58 91.68,62.04 91.68,61.68 91.1,61.1 83.09,61.1 82.81,61.38 82.83,61.42 82.85,61.48 82.86,61.56 82.77,61.78 82.54,61.88 82.47,61.87 82.4,61.84 82.37,61.83 82.28,61.91 82.28,62.08 82.33,62.16 82.42,62.17 82.48,62.16 82.54,62.15 82.86,62.47 82.54,62.79 82.48,62.78 82.42,62.76 82.33,62.77 82.28,62.86 82.28,63.23 82.92,63.87 89.01,63.87
+VCCIO on TOP (solid shape): 81.86,51.99 81.86,51.56 81.7,51.4 81.7,50.53 81.77,50.46 82.14,50.46 82.24,50.36 82.24,50.13 82.05,49.95 80.68,49.95 80.48,50.15 80.48,51.78 80.78,52.08 81.77,52.08
+VCCIO on TOP (solid shape): 106.41,42.12 106.41,41.54 106.11,41.24 106.11,39.23 105.34,39.23 105.09,38.98 105.09,38.75 104.76,38.75 104.66,38.64 104.66,38.26 104.61,38.21 104.25,38.21 104.2,38.26 104.2,38.37 104.02,38.54 102.83,38.54 102.8,38.57 102.8,38.8 103.16,39.15 103.16,39.89 103.29,40.02 103.31,40.02 103.39,40.09 103.39,41.39 103.59,41.59 105.09,41.59 105.73,42.23 106.31,42.23
+VCCIO on TOP (solid shape): 81.41,61.78 83.22,61.78 83.26,61.74 83.26,60.81 83.41,60.66 83.41,60.39 83.26,60.24 81.27,60.24 80.86,59.83 80.49,59.83 80.32,60 80.33,60.03 80.36,60.11 80.37,60.19 80.35,60.31 80.3,60.41 80.3,60.88 80.35,60.99 80.37,61.1 80.35,61.22 80.3,61.32 80.3,61.8 80.35,61.9 80.37,62.01 80.37,62.08 80.35,62.14 80.34,62.17 80.48,62.3 80.88,62.3
+VCCIO on BOTTOM (solid shape): 105.26,40.38 105.26,38.78 105.17,38.7 105.11,38.72 105.04,38.72 104.89,38.69 104.77,38.59 104.25,38.59 103.62,39.23 103.62,40.25 103.87,40.5 105.14,40.5
+VCCIO on BOTTOM (solid shape): 80.86,51.27 82.36,51.27 82.41,51.24 82.48,51.22 82.56,51.14 82.56,51.05 82.43,50.92 82.42,50.92 82.38,50.92 82.23,50.76 82.22,50.62 82.23,50.48 82.41,50.31 82.48,50.31 82.56,50.23 82.56,50.13 82.43,50 80.86,50 80.78,49.93 80.6,49.93 80.48,50.05 80.48,50.11 80.48,50.2 80.48,50.27 80.6,50.39 80.6,50.87 80.5,50.97 80.5,51.22 80.6,51.32 80.81,51.32
+VCCIO on BOTTOM (solid shape): 80.86,62.26 80.99,62.23 81.12,62.26 81.13,62.27 81.78,62.27 81.79,62.26 81.92,62.23 82.04,62.26 82.06,62.27 82.27,62.27 82.29,62.27 82.31,62.25 82.47,62.16 82.69,62.18 82.72,62.16 82.77,62.12 82.77,60.56 82.66,60.45 82.48,60.45 82.45,60.48 81.2,60.48 80.71,59.98 80.56,59.98 80.45,60.09 80.45,60.41 80.46,60.43 80.47,60.44 80.58,60.65 80.47,60.85 80.46,60.86 80.45,60.88 80.45,61.32 80.46,61.35 80.47,61.35 80.58,61.56 80.47,61.76 80.46,61.77 80.45,61.79 80.45,62.09 80.63,62.27 80.85,62.27
+VCCIO on IN1 (solid shape): outline of 118 points within 80.33,49.59 82.92,62.32
+VCCIO on IN2 (solid shape): outline of 148 points within 63.82,32.75 69.28,37.58
+VCCIO on IN2 (solid shape): outline of 6325 points within 75.75,37.27 114.14,62.88
+VCCLDOSRAM_1P24 on TOP (solid shape): 82.87,34.28 82.87,33.08 82.98,32.97 82.98,31.65 82.92,31.58 82.92,31.05 83.22,30.74 83.22,30.42 82.92,30.11 82.92,29.81 82.76,29.65 82.41,29.65 82.31,29.75 82.31,31.27 81.9,31.68 81.9,32.47 82.13,32.47 82.13,32.42 82.14,32.37 82.15,32.32 82.18,32.27 82.21,32.22 82.24,32.19 82.28,32.15 82.33,32.13 82.38,32.11 82.43,32.09 82.48,32.09 82.54,32.09 82.59,32.11 82.64,32.13 82.69,32.15 82.73,32.19 82.76,32.22 82.79,32.27 82.82,32.32 82.83,32.37 82.84,32.42 82.84,32.47 82.83,32.53 82.82,32.58 82.79,32.63 82.76,32.67 82.73,32.71 82.69,32.74 82.64,32.77 82.59,32.79 82.54,32.8 82.48,32.8 82.43,32.8 82.38,32.79 82.33,32.77 82.28,32.74 82.24,32.71 82.21,32.67 82.18,32.63 82.15,32.58 82.14,32.53 82.13,32.47 81.9,32.47 81.9,32.83 82.41,33.33 82.41,34.25 82.54,34.38 82.76,34.38
+VCCLDOSRAM_1P24 on SVCC (solid shape): 82.91,45.58 83.01,45.35 83.24,45.26 83.37,45.29 83.48,45.37 83.63,45.22 83.63,42.38 83.62,42.37 83.56,42.33 83.52,42.27 82.31,41.06 82.25,40.98 82.23,40.88 82.23,40.74 81.93,40.39 82.23,40.03 82.23,36.18 82.25,36.08 82.31,36 83.12,35.19 83.12,33.75 83.01,33.64 80.33,33.64 80.3,33.66 80.26,33.68 79.95,34 79.95,35.93 79.93,36.02 79.87,36.11 79.31,36.67 79.31,36.69 79.31,36.94 79.47,37.06 79.53,37.26 79.51,37.38 79.44,37.48 80.12,38.16 80.18,38.24 80.2,38.34 80.2,39.04 80.25,39.23 80.2,39.41 80.2,39.91 80.39,40.2 80.2,40.5 80.2,40.67 80.44,41.01 80.2,41.35 80.2,41.72 80.31,41.97 80.2,42.22 80.2,42.57 80.31,42.69 80.36,42.84 80.89,43.37 80.93,43.43 80.96,43.49 81.07,43.61 81.11,43.78 81.07,43.93 80.96,44.05 80.96,45.19 80.98,45.2 81.16,45.39 81.25,45.35 81.35,45.33 81.55,45.4 81.67,45.58
+VCCPLL on TOP (solid shape): outline of 400 points within 91.3,42.87 109.71,47.23
+VCCPLL_OC on TOP (solid shape): 64.7,54.6 65.72,54.6 65.85,54.47 65.85,53.71 65.72,53.58 63.82,53.58 63.6,53.8 63.6,53.81 63.6,54.63 63.69,54.72 64.58,54.72
+VCCPLL_OC on TOP (solid shape): outline of 211 points within 76.26,49.08 80.86,51.29
+VCCRTC on TOP (solid shape): 67.24,27.16 67.24,25.26 66.99,25.01 66.36,25.01 66.23,25.13 66.23,25.39 66.48,25.64 66.48,27.16 66.61,27.29 67.12,27.29
+VCCRTC on IN2 (solid shape): outline of 210 points within 81.21,44.56 83.46,47.57
+VCCSA on TOP (solid shape): outline of 1503 points within 82.31,42.45 119.57,53.45
+VCCSA on BOTTOM (solid shape): outline of 140 points within 90.27,47.41 93.12,51.62
+VCCSA on BOTTOM (solid shape): 83.52,50.77 83.52,48.46 83.58,48.46 83.61,48.45 83.63,48.41 83.63,48.17 83.52,48.06 83.48,48.06 83.46,48.08 83.05,48.09 82.97,47.69 82.97,47.66 82.96,47.63 82.79,47.46 82.25,47.46 82.08,47.62 81.74,47.62 81.71,47.59 81.63,47.56 81.56,47.61 81.45,47.71 81.3,47.75 81.28,47.75 81.24,47.79 81.23,47.81 81.23,47.84 81.23,47.87 81.23,47.97 81.37,48.1 81.45,48.1 81.63,48.17 81.7,48.35 81.7,48.48 81.74,48.56 81.83,48.57 81.93,48.56 82.02,48.58 82.03,48.58 82.63,48.58 82.64,48.58 83.02,49.01 82.45,49.04 82.43,49.02 82.4,49.01 82.03,49.01 82.02,49.02 81.8,49.01 81.68,48.84 81.61,48.76 81.51,48.78 81.25,49.04 81.23,49.04 81.15,49.08 81.14,49.17 81.1,49.43 80.89,49.58 80.87,49.58 80.81,49.65 80.81,49.76 80.95,49.9 82.48,49.9 82.61,50.03 82.61,50.06 82.65,50.09 82.65,50.27 82.52,50.4 82.49,50.4 82.36,50.53 82.36,50.77 82.42,50.83 82.44,50.83 82.48,50.84 82.56,50.91 82.58,50.91 83.37,50.91
+VCCSA on BOTTOM (solid shape): outline of 325 points within 112.69,35.98 128.89,44.66
+VCCSA on SVCC (solid shape): outline of 111 points within 80.96,33.39 126.3,51.29
+VCCST on TOP (solid shape): outline of 677 points within 90.49,44.29 111.19,48.88
+VCCST on BOTTOM (solid shape): 107.74,74.61 107.78,74.6 107.79,74.56 107.79,70.31 107.58,70.1 106.91,70.1 106.67,70.34 106.67,70.85 106.68,70.89 106.72,70.9 107.12,70.9 107.48,71.05 107.63,71.41 107.58,71.62 107.45,71.8 107.32,71.93 107.32,73.17 107.48,73.34 107.59,73.5 107.63,73.7 107.48,74.06 107.12,74.21 106.93,74.17 106.76,74.06 106.75,74.05 106.7,74.03 106.67,74.08 106.67,74.46 106.82,74.61
+VCCSTG on BOTTOM (solid shape): 100.9,56.2 101.84,56.2 101.92,56.12 101.92,55.61 101.89,55.59 101.03,55.59 100.82,55.38 100.82,55.28 100.65,55.1 100.39,55.1 100.16,55.33 100.16,55.64 100.26,55.74 100.26,56.12 100.39,56.25 100.85,56.25
+VDDQ_VTT on TOP (solid shape): 68.51,120.59 68.55,120.57 68.57,120.53 68.57,119.81 68.52,119.65 68.54,119.48 68.54,119.46 68.53,119.43 68.45,119.35 67.68,119.35 67.46,119.14 66.97,119.14 66.89,119.21 65.72,119.21 65.69,119.23 65.67,119.26 65.67,119.35 65.69,119.39 65.72,119.4 66.46,119.4 66.48,119.42 67.02,119.42 67.09,119.34 67.45,119.34 67.57,119.45 67.68,119.57 67.68,119.92 67.5,120.1 67.12,120.1 66.97,119.95 66.72,119.95 66.53,119.95 66.48,120 65.72,120 65.69,120.02 65.67,120.05 65.67,120.15 65.69,120.19 65.72,120.2 66.46,120.2 66.46,120.2 66.86,120.2 67.02,120.36 67.11,120.36 67.37,120.36 67.6,120.59
+VDDQ_VTT on TOP (solid shape): outline of 170 points within 26.99,84.16 43.5,99.05
+VIN on TOP (solid shape): 65.31,121.19 65.34,121.19 65.36,121.17 65.37,121.14 65.37,118.55 65.7,118.22 65.7,116.8 65.54,116.65 64.34,116.65 64.16,116.83 64.16,116.9 64.21,116.95 64.21,117.51 65.37,117.51 65.37,118.3 65.17,118.3 65.17,117.51 64.97,117.51 64.97,118.29 64.77,118.29 64.77,117.51 64.57,117.51 64.57,118.29 64.37,118.29 64.37,117.51 64.21,117.51 64.21,118.46 64.3,118.55 64.3,121.14 64.31,121.17 64.32,121.19 64.35,121.19
+VIN on TOP (solid shape): 73.21,125.72 73.21,119.85 73.01,119.65 71.77,119.65 71.75,119.66 71.17,119.66 71.07,119.76 71.07,120.75 69.35,122.46 69.35,122.7 69.54,122.84 69.61,123.06 69.5,123.33 69.23,123.44 69.15,123.43 69.07,123.41 69.04,123.41 68.9,123.56 68.9,123.77 68.9,123.78 68.92,123.91 68.9,124.04 68.9,124.05 68.9,125.18 68.9,125.21 69.07,125.37 69.13,125.56 69.12,125.61 69.11,125.66 69.12,125.69 69.31,125.87 73.06,125.87
+VIN on TOP (solid shape): outline of 6068 points within 52.28,14.06 141.92,118.6
+VIN on BOTTOM (solid shape): 67.12,109.84 67.75,109.84 68.39,109.21 68.39,107.56 68.26,107.43 66.61,107.43 65.72,108.32 65.72,109.84 65.97,110.1 66.86,110.1
+VIN on BOTTOM (solid shape): 79.17,105.48 83.74,105.48 83.88,105.34 83.88,105.09 83.88,105.09 83.88,104.41 83.75,104.28 82.1,104.28 81.8,103.97 81.8,103.34 82.05,103.08 84.06,103.08 84.19,102.96 84.19,102.93 84.31,102.81 84.31,102.03 84.11,101.83 82.43,101.84 78.88,101.84 78.86,101.83 78.79,101.83 78.68,101.94 78.68,103.59 77.74,104.53 77.74,105.09 77.3,105.52 77.3,105.78 77.38,105.85 78.8,105.85
+VIN on BOTTOM (solid shape): 131.57,48.03 131.57,46.06 131.51,45.93 131.49,45.78 131.49,44.85 131.51,44.83 131.53,44.8 131.51,44.76 131.13,44.38 130.22,44.38 129.55,45.05 129.55,45.55 129.54,45.66 129.5,45.77 129.5,45.86 129.47,45.89 129.47,45.9 129.44,45.94 129.39,45.97 129.38,45.97 129.35,46.01 129.25,46.01 129.25,46.01 128.84,46.01 128.84,46.01 127.39,46.01 127.29,45.91 127.29,44.31 127.04,44.06 124.42,44.06 123.96,44.51 122.72,44.51 122.46,44.77 122.46,45.91 122.31,46.06 121.37,46.06 121.35,46.09 121.22,46.09 120.97,46.34 120.97,47.36 121.22,47.61 124.04,47.61 124.22,47.43 129.45,47.43 130.26,48.25 131.35,48.25
+VIN on BOTTOM (solid shape): 119.09,36.82 119.06,36.79 118.93,36.79 118.91,36.82 118.73,36.82 118.65,36.74 118.65,35.7 118.81,35.55 120.05,35.55 120.31,35.29 120.76,35.29 120.84,35.22 120.84,33.94 121.13,33.65 122.23,33.65 123.12,34.54 127.21,34.54 128.13,33.63 128.13,32.66 128.1,32.64 126.12,32.64 125.55,32.07 123.21,32.07 122.87,32.41 122.44,32.41 121.84,31.81 118.82,31.81 118.2,32.43 118.2,34.38 117.8,34.78 117.79,34.83 117.79,35.02 117.81,35.04 117.85,35.07 117.87,35.12 117.9,35.16 117.91,35.21 117.92,35.27 117.92,35.32 117.91,35.37 117.89,35.43 117.87,35.48 117.83,35.53 117.92,35.62 117.92,35.69 118.41,35.69 118.41,36.48 118.17,36.48 118.17,35.69 117.92,35.69 117.92,36.64 117.79,36.77 117.79,39.38 119.09,39.38
+VIN on BOTTOM (solid shape): 139.05,67.98 139.08,67.97 139.09,67.96 139.1,67.93 139.1,65.42 139.08,65.39 138.95,65.39 138.7,65.14 138.7,65.08 138.68,65.08 138.68,64.29 138.81,64.16 139.19,64.16 139.71,63.64 139.73,63.61 139.76,63.57 139.79,63.55 139.82,63.53 139.9,63.45 140.28,63.45 140.4,63.33 140.4,62.9 140.04,62.55 139.79,62.55 139.63,62.39 139.63,61.96 139.53,61.86 138.88,61.86 138.85,61.87 138.82,61.92 138.8,61.97 138.76,62.02 138.72,62.06 138.68,62.09 138.63,62.11 138.57,62.13 138.52,62.14 138.49,62.14 138.04,62.14 137.76,61.86 137.6,61.86 137.37,62.09 137.37,64.04 137.62,64.29 138.43,64.29 138.43,65.08 138.18,65.08 138.18,64.29 137.93,64.29 137.93,64.3 137.93,65.11 137.81,65.24 137.81,67.93 137.81,67.96 137.83,67.97 137.86,67.98
+VIN on BOTTOM (solid shape): 126.43,77.79 126.43,77.08 125.69,76.34 124.9,76.34 123.05,74.48 123.05,74.26 123.56,73.75 123.56,73.57 122.48,72.49 122.46,72.49 122.19,72.31 122.08,72 122.18,71.7 122.43,71.51 122.44,71.51 122.92,71.03 127.11,71.03 127.16,71.08 127.21,71.08 127.47,71.33 127.47,72.53 127.65,72.71 127.65,73.26 127.68,73.33 127.71,73.4 127.71,73.41 127.76,73.46 127.77,73.46 128.01,73.7 131.46,73.7 131.99,74.23 134.07,74.23 134.28,74.03 134.28,73.09 133.72,72.53 133.26,72.53 133.01,72.27 133.01,70.34 132.42,69.76 132.42,69.12 132.27,68.97 130.29,68.97 129.6,69.66 122.82,69.66 122.16,70.32 120.58,70.32 120.35,70.56 120.35,70.61 120.36,70.64 120.36,71.08 120.25,71.35 119.98,71.46 119.96,71.46 119.82,71.43 119.7,71.35 119.63,71.32 119.56,71.35 119.29,71.61 117.55,71.61 117.28,71.35 117.19,71.35 117.15,71.37 117.14,71.39 116.96,71.57 116.72,71.64 116.7,71.64 116.44,71.89 116.44,72.07 117.39,73.01 117.69,73.01 118.12,72.58 119.09,72.58 119.19,72.68 119.24,72.68 120.1,73.54 120.38,73.54 123.84,77 123.84,77.63 124.93,78.73 125.49,78.73
+VIN on BOTTOM (solid shape): outline of 83 points within 134.45,30.59 145.73,37.88
+VIN on BOTTOM (solid shape): outline of 210 points within 46.49,14.08 79.86,20.05
+VIN on BOTTOM (solid shape): outline of 604 points within 54.57,111.49 73.34,125.97
+VIN_BLIGHT on BOTTOM (solid shape): 64.96,107.81 64.96,107.3 65.72,106.54 66.48,106.54 66.61,106.67 68.26,106.67 68.39,106.54 68.39,105.65 67.75,105.02 67.31,105.02 67.25,105.03 66.15,105.03 66.09,105.02 65.72,105.02 64.83,105.9 64.17,105.9 63.92,105.65 63.43,105.65 62.67,106.41 62.67,106.68 62.7,106.71 63.2,106.71 63.2,107.25 63.59,107.25 63.59,107.19 63.6,107.14 63.62,107.09 63.65,107.04 63.68,107 63.72,106.96 63.77,106.92 63.82,106.9 63.87,106.88 63.93,106.87 63.98,106.87 64.04,106.87 64.09,106.89 64.14,106.91 64.19,106.94 64.23,106.98 64.27,107.02 64.3,107.06 64.33,107.11 64.34,107.17 64.35,107.22 64.35,107.28 64.34,107.33 64.33,107.39 64.3,107.44 64.27,107.48 64.23,107.53 64.19,107.56 64.14,107.59 64.09,107.61 64.04,107.63 63.98,107.63 63.93,107.63 63.87,107.62 63.82,107.6 63.77,107.58 63.72,107.54 63.68,107.51 63.65,107.46 63.62,107.41 63.6,107.36 63.59,107.31 63.59,107.25 63.2,107.25 63.2,107.54 63,107.54 63,106.71 62.7,106.71 62.7,107.54 62.67,107.57 62.67,107.68 62.93,107.94 64.83,107.94
DVDD_IO on TOP (solid shape): 203.19,28.92 203.78,28.92 203.87,28.86 203.86,28.76 203.86,28.38 204.2,28.21 204.42,28.32 204.52,28.55 204.56,28.59 204.71,28.59 205.17,27.82 205.12,27.77 204.1,27.77 204,27.67 202.4,27.67 202.37,27.7 202.37,28.87 202.42,28.92 202.63,28.92 202.7,28.99 203.11,28.99
GND on TOP (solid shape): 142.56,73.9 142.56,73.14 141.67,72.25 138.36,72.25 137.73,72.88 137.73,74.15 142.3,74.15
GND on TOP (solid shape): 20.64,98.28 20.64,96.38 20.38,96.13 19.37,96.13 18.86,96.63 18.86,98.16 19.24,98.54 20.38,98.54
GND on TOP (solid shape): 22.72,28.69 22.72,26.1 22.69,26.07 21.83,26.07 21.8,26.1 21.8,28.66 21.86,28.71 22.69,28.71
GND on TOP (solid shape): 65.72,56.37 65.72,55.1 65.47,54.85 63.18,54.85 61.91,56.12 61.91,56.37 62.04,56.5 65.59,56.5
GND on TOP (solid shape): 86.17,71.61 86.17,68.82 86.04,68.69 84.64,68.69 84.55,68.79 84.55,71.71 84.64,71.8 85.98,71.8
GND on TOP (solid shape): 65.59,65.77 65.59,64.89 65.46,64.76 62.04,64.76 61.91,64.88 61.91,65.77 62.04,65.9 65.47,65.9
GND on TOP (solid shape): 66.71,71.13 66.71,70.24 66.53,70.06 62.06,70.06 62.06,70.09 61.94,70.22 61.94,71.41 62.24,71.72 66.13,71.72
