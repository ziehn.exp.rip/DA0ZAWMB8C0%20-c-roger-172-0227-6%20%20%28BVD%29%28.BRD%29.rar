# Allegro board da0zawmb8c0-c-roger-172-0227-6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD14: length 27.2
  IN3 w0.102: v2(133.01,85.41) 133.01,85.6 132.63,85.98 132.63,87.46 131.23,88.86 130.78,88.86 129.62,90.02 129.62,90.54 129.42,90.74 129.42,91.91 129.4,91.93 129.4,95 127.39,97.01 120.46,97.01 120.1,97.37 v2(120.08,97.37)
  BOTTOM w0.127: v2(133.01,85.41) 133.41,85.01 VRAM1.J3 ; U8.G27 119.34,97.93 119.44,98.03 R316.2 119.94,97.51 v2(120.08,97.37)
FBA_CMD15: length 27.5
  IN3 w0.102: v2(132.21,85.41) 131.83,85.03 130.31,85.03 130.21,85.13 130.21,85.61 129.6,86.22 129.6,87.59 129.27,87.92 127.47,87.92 126.02,89.37 126.02,94.49 125.38,95.13 118.98,95.13 118.6,95.52 118.09,95.52 116.27,97.33 v2(116.27,97.37)
  BOTTOM w0.102: U8.G26 115.24,97.93 115.65,97.52
  BOTTOM w0.127: v2(116.27,97.37) 116.11,97.52 115.65,97.52 ; VRAM1.L3 131.81,85 v2(132.21,85.41)
FBA_CMD16: length 27.6
  TOP w0.127: v2(113.73,102.49) 114.19,102.03 v1(119.82,102.03) 120.65,102.03 122.03,103.41 122.03,106 126.47,110.44 131.93,110.44 132.61,109.75 132.61,108.21 v2(132.21,107.81)
  BOTTOM w0.127: v2(113.73,102.49) 113.7,102.49 113.33,102.12 U8.M24 ; VRAM2.G12 131.81,107.4 v2(132.21,107.81)
FBA_CMD17: length 26.1
  TOP w0.127: v2(112.92,102.49) 113.6,101.8 117.19,101.8 117.41,101.59 120.84,101.59 122.46,103.21 122.46,105.82 126.65,110.01 131.67,110.01 v2(132.21,109.46)
  BOTTOM w0.127: VRAM2.H10 132.61,109.01 132.21,109.41 v2(132.21,109.46) ; v2(112.92,102.49) 112.53,102.1 U8.M23
FBA_CMD18: length 25.8
  IN3 w0.102: v2(114.53,100.85) 114.88,100.49 118.22,100.49 119.52,101.79 119.67,101.79 122.26,104.38 131.89,104.38 132.62,105.12 132.62,108.21 v2(132.21,108.62)
  BOTTOM w0.102: U8.K24 113.64,100.41 114.06,100.82 114.5,100.82 v2(114.53,100.85)
  BOTTOM w0.127: VRAM2.H11 132.61,108.21 132.21,108.61 v2(132.21,108.62)
FBA_CMD19: length 29.6
  IN3 w0.102: v2(133.81,108.62) 133.39,108.2 133.39,107.65 133.08,107.34 133.08,103.92 132.42,103.26 121.8,103.26 119.87,101.33 119.57,101.33 118.53,100.29 114.84,100.29 114.15,99.59 114.15,98.96 113.98,98.79 113.6,98.79 113.35,99.05 113.35,99.43 112.93,99.84 v2(112.93,100.01)
  BOTTOM w0.102: U8.K23 v2(112.93,100.01)
  BOTTOM w0.127: v2(133.81,108.62) 133.81,108.61 134.21,108.21 VRAM2.K11
FBA_CMD20: length 24.8
  TOP w0.127: v2(133.81,109.46) 133.76,109.46 132.35,110.87 126.29,110.87 121.6,106.18 121.6,103.61 120.58,102.6 118.04,102.6 117.61,103.03 116.6,103.03 116.25,102.69 v2(116.25,102.61)
  BOTTOM w0.127: U8.M27 v2(116.25,102.61) ; VRAM2.K10 134.21,109.01 133.81,109.41 v2(133.81,109.46)
FBA_CMD21: length 30
  TOP w0.127: v2(115.34,102.55) 115.89,103.1 116.03,103.1 116.39,103.47 117.82,103.47 118.17,103.11 120.46,103.11 121.16,103.82 121.16,106.36 126.11,111.3 v1(133.16,111.3) 134.62,111.3 135.81,110.11 135.81,108.21 v2(135.41,107.81)
  BOTTOM w0.127: U8.M26 114.93,102.14 v2(115.34,102.55) ; v2(135.41,107.81) 135.01,107.41 VRAM2.L12
FBA_CMD22: length 28.4
  IN3 w0.102: v2(114.5,102.46) 114.8,102.16 117.56,102.16 118.04,102.65 118.04,103.8 118.35,104.1 118.35,105.45 124.65,111.75 131.76,111.75 132.27,112.25 132.27,113.27 132.78,113.78 134.24,113.78 134.61,113.41 v2(134.61,113.4)
  BOTTOM w0.127: VRAM2.K4 134.22,113.8 134.61,113.41 v2(134.61,113.4) ; U8.M25 v2(114.5,102.46)
FBA_CMD23: length 26.7
  IN3 w0.102: v2(115.5,100.88) 115.98,101.35 118.59,101.35 121.09,103.86 121.09,105.27 125.74,109.92 132.85,109.92 134.61,111.67 v2(134.61,112.61)
  BOTTOM w0.127: VRAM2.K5 134.22,113 134.61,112.61 v2(134.61,112.61) ; v2(115.5,100.88) 115.46,100.88 114.99,100.41 U8.K26
FBA_CMD24: length 30.5
  IN3 w0.102: v2(133.01,114.21) 132.63,114.59 131.05,114.59 130.21,113.75 130.21,113.12 129.75,112.66 124.04,112.66 117.79,106.41 117.16,106.41 115.31,104.57 115.31,103.94 114.32,102.94 113.56,102.94 113.35,102.73 113.35,102.22 112.41,101.28 111.97,101.28 111.69,101 111.69,100.43 v2(112.11,100.01)
  BOTTOM w0.127: U8.K22 111.71,100.41 v2(112.11,100.01) ; VRAM2.J4 133.41,113.81 133.01,114.21 v2(133.01,114.21)
FBA_CMD25: length 31.3
  IN3 w0.102: v2(133.81,112.61) 133.81,112.61 133.43,112.99 132.75,112.99 132.59,112.83 132.59,111.94 131.94,111.29 124.95,111.29 118.81,105.14 118.81,103.11 117.66,101.96 113.47,101.96 112.51,101 112.51,99.61 v2(112.93,99.19)
  BOTTOM w0.127: v2(133.81,112.61) 133.81,112.61 133.42,113 VRAM2.J5 ; v2(112.93,99.19) 112.53,99.59 U8.J23
FBA_CMD26: length 30.8
  IN3 w0.102: v2(133.01,113.4) 133.02,113.41 133.66,113.41 134.2,112.86 134.2,112.03 132.55,110.37 125.46,110.37 119.73,104.64 119.73,103.1 118.19,101.56 113.86,101.56 113.52,101.22 113.52,100.22 v2(113.73,100.01)
  BOTTOM w0.102: v2(113.73,100.01) U8.J25
  BOTTOM w0.127: VRAM2.H4 132.62,113.8 133.01,113.41 v2(133.01,113.4)
FBA_CMD27: length 29.5
  IN3 w0.102: v2(133.01,112.61) 133.01,111.49 132.35,110.83 125.26,110.83 119.26,104.84 119.26,103.14 117.89,101.76 113.77,101.76 113.32,101.31 113.32,99.83 113.75,99.41 v2(113.75,99.19)
  BOTTOM w0.127: v2(133.01,112.61) 133.01,112.61 132.62,113 VRAM2.H5 ; v2(113.75,99.19) U8.J24
FBA_CMD28: length 25.7
  IN3 w0.102: v2(131.41,114.21) 131.41,114 131.81,113.6 131.81,112.43 131.58,112.2 124.34,112.2 117.89,105.75 117.89,104.3 117.44,103.85 v2(117.44,102.6)
  BOTTOM w0.127: v2(131.41,114.21) 131.42,114.21 131.81,114.6 VRAM2.G3 ; U8.K27 116.23,100.41 117.44,101.61 v2(117.44,102.6)
FBA_CMD29: length 29.2
  TOP w0.127: v2(133.01,114.99) 133.01,114.8 132.57,114.36 132.57,112.31 132.1,111.83 126.03,111.83 120.73,106.53 120.73,104.77 R317.1 119.58,103.62 v2(118.43,103.62)
  BOTTOM w0.127: VRAM2.J2 133.41,115.4 133.01,115.01 v2(133.01,114.99) ; U8.K25 114.5,100.04 116.37,100.04 116.57,100.24 116.83,100.24 117.87,101.28 117.87,102.81 118.43,103.36 v2(118.43,103.62)
FBA_CMD30: length 34.6
  IN3 w0.102: v2(133.81,114.21) 133.97,114.21 134.38,114.62 135.62,114.62 135.82,114.41 135.82,111.37 134.99,110.53 134.99,104.18 133.16,102.35 122.74,102.35 121.75,101.36 v2(121.22,101.36)
  BOTTOM w0.127: VRAM2.J3 133.8,114.21 v2(133.81,114.21) ; v2(121.22,101.36) 120.37,100.51 119.76,100.51 119.3,100.05 R314.1 118.94,99.81 115.93,99.81 U8.J27
FBA_CMD31: length 32.8
  IN3 w0.102: v2(115.3,99.21) 116.16,100.06 118.98,100.06 119.92,101 120.2,101 122.01,102.81 132.73,102.81 134.23,104.31 134.23,110.52 135.32,111.6 135.32,112 135.01,112.3 135.01,113.8 134.61,114.21 v2(134.61,114.21)
  BOTTOM w0.127: v2(115.3,99.21) 115.3,99.24 U8.J26 ; VRAM2.L3 135,114.6 134.61,114.21 v2(134.61,114.21)
FBA_DBI0: length 36.7
  TOP w0.165: v2(109.5,95.82) 109.7,95.61 109.7,94.31 110.01,94 110.01,93.51 110.86,92.65 110.86,91.75 112.3,90.31 122.45,90.31 v1(124.26,88.5) 126.12,86.63 126.12,85.37 127.03,84.46 136.14,84.46 136.8,83.81 v2(137.81,83.81)
  BOTTOM w0.165: U8.D19 109.15,95.5 109.47,95.82 v2(109.5,95.82) ; v2(137.81,83.81) 137.42,84.2 VRAM1.D2
FBA_DBI1: length 37.7
  IN1 w0.102: v2(137.01,93.41) 137.39,93.79 137.39,94.56 137.22,94.73 ; 107.25,97.12 106.77,97.12 106.67,97.01 106.67,96.43 106.48,96.25 105.82,96.25 v2(105.45,95.87)
  IN1 w0.152: 107.25,97.12 109.15,97.12 109.21,97.06 109.86,97.06 109.92,97.12 111.91,97.12 111.93,97.14 114.46,97.14 114.49,97.12 115,97.12 115.72,97.83 117.25,97.83 118.06,98.64 132.28,98.64 132.74,98.18 133.5,98.18 135.51,96.18 135.77,96.18 137.22,94.73
  BOTTOM w0.165: U8.D14 105.03,95.45 v2(105.45,95.87) ; VRAM1.D13 137.41,93.01 v2(137.01,93.41)
FBA_DBI2: length 28.1
  IN1 w0.152: v2(129.01,92.61) 128.9,92.49 127.47,92.49 126.54,91.55 124.86,91.55 123.01,89.7 109.86,89.7 109.05,90.51 107.74,90.51 107,91.26 v2(107,91.55)
  BOTTOM w0.102: v2(107,91.55) 107.22,91.77 107.22,93.64 107.17,93.69 107.17,93.97 107.51,94.32 U8.C17
  BOTTOM w0.165: VRAM1.P13 129.41,93 v2(129.01,92.61)
FBA_DBI3: length 24.8
  BOTTOM w0.079: 126.68,84.82 126.82,84.69 128.34,84.69 128.46,84.57 129.04,84.57 VRAM1.P2
  BOTTOM w0.165: 126.68,84.82 126.55,84.82 126.2,85.18 126.2,87.08 122.46,90.82 v1(119.78,90.82) 113.1,90.82 112.01,91.91 112.01,92.5 112.27,92.76 112.27,93.47 112.08,93.66 112.08,94.09 111.63,94.54 U8.C22
FBA_DBI4: length 27.9
  IN1 w0.102: 137.94,104.99 138.19,105.25 138.19,105.57 137.81,105.95 v2(137.81,106.21)
  IN1 w0.152: 137.94,104.99 137.27,104.33 126.49,104.33 126.24,104.08 118.3,104.08 117.37,103.15 114.96,103.15 114.36,103.74 114.05,103.74 v2(113.73,104.07)
  BOTTOM w0.165: VRAM2.P13 137.42,106.6 v2(137.81,106.21) ; U8.P24 113.39,103.73 v2(113.73,104.07)
FBA_DBI5: length 28
  IN1 w0.102: 136.65,114.6 137.41,114.6 v2(137.81,115.01)
  IN1 w0.152: 136.65,114.6 135.85,113.8 128.56,113.8 128.54,113.83 125.34,113.83 122.99,111.48 120.88,111.48 119.18,109.78 116.34,109.78 114.84,108.29 v2(114.51,108.29)
  BOTTOM w0.165: VRAM2.P2 137.8,115.01 v2(137.81,115.01) ; U8.W24 113.77,108.29 v2(114.51,108.29)
FBA_DBI6: length 17.7
  TOP w0.165: v2(114.53,109.93) 115.08,109.93 116.31,111.16 121.94,111.16 v1(122.13,111.35) 125.19,114.41 128.28,114.41 128.86,114.99 v2(129.01,114.99)
  BOTTOM w0.165: v2(114.53,109.93) U8.AA25 ; v2(129.01,114.99) 129.01,115.01 129.41,115.4 VRAM2.D2
FBA_DBI7: length 16.3
  BOTTOM w0.079: 126.66,107.22 126.79,107.09 128.34,107.09 128.46,106.97 128.97,106.97 129.34,106.6 VRAM2.D13
  BOTTOM w0.165: 126.66,107.22 126.47,107.4 v1(123.38,107.4) 119,107.4 118.11,106.52 116.13,106.52 116.01,106.4 115.39,106.4 115.15,106.64 114.56,106.64 U8.U25
FBA_EDC0: length 36.9
  TOP w0.102: 136.46,84.93 136.66,84.93 136.71,84.99 137.43,84.99 v2(137.81,84.61)
  TOP w0.165: v2(109.54,96.65) 109.97,96.23 109.97,94.42 110.27,94.11 110.27,93.62 111.13,92.77 111.13,92.22 112.55,90.79 122.63,90.79 v1(123.46,89.96) 126.59,86.83 126.59,85.56 127.22,84.93 136.46,84.93
  BOTTOM w0.165: VRAM1.C2 138.21,84.21 v2(137.81,84.61) ; U8.E19 109.15,96.26 v2(109.54,96.65)
FBA_EDC1: length 37.5
  IN1 w0.102: v2(105.46,95.07) 105.79,95.41 107.23,95.41 107.28,95.36 107.63,95.36 107.68,95.41 111.36,95.41 111.4,95.45 114.87,95.45 115.12,95.71 ; 135.55,94.73 135.82,94.45 135.82,93.1 135.93,93 137.41,93 v2(137.81,93.41)
  IN1 w0.152: 115.12,95.71 115.87,96.46 120.46,96.46 121.62,97.62 131.79,97.62 134.19,95.22 135.05,95.22 135.55,94.73
  BOTTOM w0.165: v2(105.46,95.07) 105.87,94.66 U8.C15 ; VRAM1.C13 138.21,93.01 v2(137.81,93.41)
FBA_EDC2: length 28
  IN1 w0.152: v2(129.01,93.41) 128.61,93 127.26,93 126.81,92.54 125.13,92.54 122.8,90.21 110.07,90.21 109.26,91.02 107.95,91.02 107.5,91.47 107.5,91.81 107.25,92.06 106.64,92.06 v2(106.39,91.81)
  BOTTOM w0.102: v2(106.39,91.81) 107.01,92.43 107.01,93.19 106.67,93.53 U8.B16
  BOTTOM w0.165: v2(129.01,93.41) 128.61,93 VRAM1.R13
FBA_EDC3: length 23.5
  BOTTOM w0.079: 126.6,84.52 128.13,84.52 128.45,84.2 VRAM1.R2
  BOTTOM w0.165: 126.6,84.52 126.55,84.57 126.3,84.57 125.92,84.95 125.92,86.68 v1(123.42,89.18) 122.25,90.35 112.9,90.35 111.72,91.53 111.72,92.59 112,92.87 112,93.28 111.63,93.65 U8.B22
FBA_EDC4: length 26.9
  IN1 w0.102: 137.03,104.89 137.39,105.25 137.39,106.59 v2(137.81,107.01)
  IN1 w0.152: v2(114.57,104.15) 115.39,104.15 116.01,103.53 117.02,103.53 118.07,104.58 126.02,104.58 126.28,104.83 136.98,104.83 137.03,104.89
  BOTTOM w0.165: v2(114.57,104.15) 114.5,104.15 114.13,104.52 U8.R25 ; VRAM2.R13 138.21,106.61 v2(137.81,107.01)
FBA_EDC5: length 29.6
  IN1 w0.102: v2(137.81,115.81) 137.41,115.4 136.71,115.4
  IN1 w0.152: v2(112.93,108.27) 113.15,108.27 113.58,108.7 114.88,108.7 115.92,109.75 115.92,110.35 116.23,110.66 119.34,110.66 120.67,111.99 122.78,111.99 126.19,115.39 133.41,115.39 133.5,115.3 136.61,115.3 136.71,115.4
  BOTTOM w0.165: v2(137.81,115.81) 138.21,115.41 VRAM2.R2 ; v2(112.93,108.27) 112.93,108.25 U8.W23
FBA_EDC6: length 16.2
  TOP w0.165: v2(118.25,111.64) 121.76,111.64 v1(124.21,114.09) 125.54,115.43 127.84,115.43 v2(128.21,115.81)
  BOTTOM w0.165: VRAM2.C2 128.21,115.8 v2(128.21,115.81) ; U8.AB26 115.11,110.33 115.5,110.73 117.54,110.73 118.25,111.44 v2(118.25,111.64)
FBA_EDC7: length 14.6
  BOTTOM w0.079: 126.6,106.92 128.13,106.92 128.45,106.6 VRAM2.C13
  BOTTOM w0.165: U8.T26 114.93,105.68 115.38,106.13 116.12,106.13 116.24,106.25 118.51,106.25 118.8,106.54 v1(119.7,106.54) 125.69,106.54 126.07,106.92 126.6,106.92
FBA_VREFC_1: length 5.4
  TOP w0.508: v1(133.71,97.24) 133.66,97.29 133.66,97.9 C505.1 133.56,98.06 133.56,99.02 R410.2 R407.2 R411.2 133.16,101.08 132.65,100.57 v1(132.65,100.19)
FBA_VREFC_2: length 6.4
  TOP w0.508: R25284.2 R25283.2 C506.1 ; C506.1 v1(133.04,102.12) ; C506.1 R25282.2 133.81,105.15 v2(133.81,105.41)
  BOTTOM w0.33: VRAM2.J14 133.42,105.8 v2(133.81,105.41)
FBVDD_EN: length 6.8
  BOTTOM w0.102: U11.4 100.38,121.79 100.52,121.65 102.04,121.65 102.17,121.78 103.06,121.78 103.57,122.29 103.57,122.41 103.77,122.62 v1(104.23,122.62) 104.23,122.85 103.94,123.13 R25469.1 103.44,123.43 103.43,123.42 R325.2
FBVDDQ_EN: length 108.4
  IN3 w0.089: v1(104.66,124.22) 104.66,124.19 104.63,124.17 104.63,124.1 104.22,123.68 101.33,123.68 100.8,123.15 96.05,123.15 95.25,122.36 95.25,119.03 96.19,118.09 96.19,102.31 97.15,101.35 97.15,98.92 98.49,97.59 98.49,96.27 98.68,96.08 98.68,95.12 99.47,94.33 100,94.33 102.07,92.26 103.01,92.26 103.51,92.76 104.29,92.76 104.58,92.47 104.58,91.31 105.86,90.03 108.78,90.03 111,87.81 121.79,87.81 124.69,84.91 124.69,83.05 125.95,81.79 128.77,81.79 129.52,81.05 138.5,81.05 142.71,76.84 142.71,65.83 142.82,65.72 142.82,65.02 142.76,64.96 v1(142.76,64.65)
  BOTTOM w0.102: R25469.2 104.72,124.11 104.66,124.17 v1(104.66,124.22)
  BOTTOM w0.254: v1(142.76,64.65) 142.76,64.96 142.91,65.11 142.91,65.57 142.84,65.65 142.84,66.41 142.26,66.98 PR9095.2
G5335-AGND-1: length 8.7
  BOTTOM w0.203: v2(121.09,42.28) 120.99,42.28 120.74,42.02 119.31,42.02 119.04,41.74 PC232.2 ; PC228.2 121.88,40.47 v1(122.74,39.61) ; PR270.2 121.86,37 121.46,37.41 121.45,37.41 121.08,37.77 PR273.1 ; PU16.4 120.49,37.84 120.69,38.04 PR273.1 ; PR273.1 121.08,38.38 121.22,38.52 121.45,38.52 121.55,38.62 PR272.2 121.83,39.05 v1(122.08,38.8)
G5335-AGND-2: length 4.1
  TOP w0.254: 140.51,66.24 v1(140.81,66.54)
  BOTTOM w0.254: PC9090.2 142.26,68.58 v1(142.28,68.6) ; v1(142.37,63.37) PR9097.2 ; v1(140.3,68.87) 140.42,68.87 140.5,68.95 140.9,68.95 141.21,69.25 PC9091.2 ; v1(140.81,66.54) 140.71,66.44 PU9004.4
  vias: v1(142.25,67.09)
G5335-BST-1: length 2.1
  TOP w0.203: v2(117.23,41.11) 117.63,40.72 PR277.2
  BOTTOM w0.203: PU16.20 117.54,40.8 v2(117.23,41.11)
G5335-BST-2: length 3.5
  BOTTOM w0.254: PU9004.20 137.56,69.38 137.89,69.72 138.96,69.72 139.18,69.94
  BOTTOM w0.508: PR9089.2 139.56,70.32 139.18,69.94
G5335-EN-1: length 3.1
  BOTTOM w0.203: PR274.1 PC228.1 120.46,39.84 120.46,39.09 120.2,38.84 PU16.2
G5335-EN-2: length 25.1
  TOP w0.254: v1(131.71,77.13) 131.41,76.83 PQ9086.2
  IN2 w0.203: v1(131.71,77.13) 131.63,77.13 130.31,75.81 130.31,72.43 132.79,69.95 135.76,69.95 136.99,68.72 139.41,68.72 140.22,67.91 140.22,66.42 v1(140.99,65.65)
  BOTTOM w0.254: PU9004.2 140.26,67.44 140.78,67.96 PC9090.1 PR9095.1 141.48,66.52 141.56,66.44 PR9096.2 141.18,65.65 v1(140.99,65.65)
G5335-FB-1: length 3.6
  BOTTOM w0.203: PU16.5 120.74,37.34 PR270.1 121.54,36.54 PC225.1 PR269.2
G5335-FB-2: length 3.9
  BOTTOM w0.254: PU9004.5 140.25,65.94 140.45,65.74 140.45,65.41 140.98,64.88 PC9089.1 PR9094.2 141.07,62.9 PR9097.1
G5335-LX-1: length 2.8
  TOP w0.508: PC235.1 114.23,40.52 v1(113.45,40.52) 112.05,40.52 v2(111.87,40.35)
G5335-LX-2:
  vias: v1(135.47,69.4)
G5335-PFM-1: length 2.3
  BOTTOM w0.203: PR98.1 PR272.1 120.92,39.05 120.23,38.36 120.2,38.34 PU16.3
G5335-PFM-2: length 2.5
  TOP w0.254: v1(140.9,67.35) 141.08,67.52 PR9091.1 141.41,67.93 141.46,67.88 PR9093.1
  BOTTOM w0.254: PU9004.3 140.49,66.94 v1(140.9,67.35)
G5335-PWRGD-1: length 2.1
  BOTTOM w0.203: PR276.1 120.46,40.58 v1(120.38,40.5) 119.79,39.91 PU16.1
G5335-PWRGD-2: length 2.6
  BOTTOM w0.254: PU9004.1 140.07,67.94 140.48,68.34 140.84,68.34 141.27,68.77 141.53,68.77 141.81,69.05 PR9090.1
G5335-SS-1: length 1.1
  BOTTOM w0.203: PC232.1 119.04,40.83 119.04,40.83 PU16.23
G5335-SS-2: length 2
  BOTTOM w0.254: PU9004.23 139.32,68.69 140.09,69.46 PC9091.1
G5335-TON-1: length 1.5
  BOTTOM w0.203: PU16.6 120.06,36.84 120.58,36.31 PR268.1
G5335-TON-2: length 1.7
  BOTTOM w0.254: PR9086.1 139.81,64.14 PU9004.6
G5335-VCC-1: length 2.7
  TOP w0.508: PR104.2 117.97,38.95 118.68,39.66 v1(118.68,40.17) 118.68,40.68 v1(118.43,40.93)
G5335-VCC-2: length 5.5
  BOTTOM w0.254: PU9004.21 138.06,69.13 138.26,69.33 139.39,69.33 140.09,70.04 140.4,70.04 140.99,70.62 PR9087.2
  BOTTOM w0.508: PC9075.1 140.99,71.58 140.98,71.57 140.98,71.05 140.99,71.04 PR9087.2
G_MBCLK_R: length 6.4
  TOP w0.102: v1(61.23,17.69) 60.47,17.69 R591.2 59.87,17.61 C6605.1 59.25,17.39 R25356.2 58.45,17.74 59.24,18.52 U32.4
G_MBDATA_R: length 6
  TOP w0.102: C6604.1 63.07,19.73 R590.2 ; R590.2 63.08,18.98 v1(63.1,18.96) ; R590.2 R25355.2 62.57,21.2 62.31,21.46 U32.6
GC6_FB_EN: length 3.5
  TOP w0.102: R372.1 R394.1 89.72,93.03 89.72,92.82 89.42,92.52 88.78,92.52 88.72,92.45 Q16.2
GC6_FB_EN_N17: length 7.6
  TOP w0.102: R372.2 91.04,95.4 92.14,94.3 92.95,94.3 v2(93.46,93.79)
  BOTTOM w0.102: v2(93.46,93.79) 93.08,93.41 93.08,92.87 93.17,92.78 93.71,92.78 93.96,93.04 93.96,93.17 94.24,93.46 94.48,93.46 94.85,93.83 U8.B2
GC6_FB_EN_Q: length 133.5
  TOP w0.079: 79.31,39.64 79.67,39.99 79.67,40.52 79.37,40.82 79.37,40.96 v2(79.32,41.02)
  TOP w0.102: v1(85.15,93.46) 85.15,93.69 v1(84.62,94.22) 84.31,94.52 84.31,95.53 84.45,95.67 86.14,95.67 86.57,95.24 Q14.3 87,95.75 87.38,96.13 88.81,96.13 89.22,96.53 91.43,96.53 92.29,97.4 92.52,97.4 93.79,98.67 v2(93.79,98.77) ; v2(72.96,33.29) 72.99,33.29 73.19,33.49 74.51,33.49 75.9,34.89 76.26,34.89 76.97,35.6 76.97,38.39 77.24,38.66 79,38.66 79.31,38.98 79.31,39.64
  IN1 w0.089: v2(79.32,41.02) 77.78,41.02 76.9,41.9 76.9,42.91 77.02,43.04 77.02,43.55 76.9,43.67 76.9,44.82 76.92,44.84 76.92,46.08 77.14,46.29 78.34,46.29 78.46,46.18 79.15,46.18 79.4,46.43 79.4,46.79 79.59,46.98 81.6,46.98 81.85,47.23 81.85,47.41 84.62,50.18 84.62,64.2 82.64,66.18 82.64,73.47 82.82,73.65 82.82,74.54 83.03,74.75 83.03,78.97 83.96,79.89 83.96,84.8 83.45,85.3 83.45,89.97 84.52,91.04 84.52,92.82 v1(85.15,93.46)
  IN3 w0.089: v2(93.79,98.77) 94.35,99.33 94.35,100.32 93.53,101.13 93.53,108.57 94.04,109.08 94.04,110.22 93.45,110.81 93.45,113.58 v1(93.41,113.63)
  BOTTOM w0.079: v2(79.32,41.02) 79.69,41.39 U1.CC29
  BOTTOM w0.102: v2(72.96,33.29) 72.99,33.29 73.14,33.13 73.14,32.7 74.23,31.61 74.23,29.93 76.1,28.06 R25431.1 76.38,27.54 v1(76.38,25.89) 76.38,25.31 R25430.2 ; v1(93.41,113.63) 93.86,114.09 93.86,114.49 94.02,114.64 94.02,119.29 94.4,119.67 98,119.67 100.06,117.61 101.56,117.61 101.68,117.73 U11.1
GC6FBEN_Q_EC: length 2
  TOP w0.102: TP9021.1 181.65,27.29 182.14,27.78 U37.2
GPD7: length 14.4
  BOTTOM w0.079: 70.93,41.39 71.02,41.48 71.02,41.6 74.06,44.63 74.9,44.63 74.97,44.67 75.16,44.67 75.23,44.64 75.63,44.64 75.72,44.55 U1.BV35
  BOTTOM w0.102: R152.1 65.44,39.7 66.25,38.89 v1(66.25,38.59) 66.33,38.52 66.56,38.52 66.74,38.7 R157.2 66.92,38.49 67.14,38.26 68.08,38.26 68.64,38.82 68.64,39.1 70.93,41.39
GPD9: length 4.3
  TOP w0.079: 76.18,45.28 78.49,45.28 v2(78.81,45.6)
  TOP w0.102: 76.18,45.28 75.75,45.71 TP6.1
  BOTTOM w0.089: U1.BT30 79.04,45.93 78.81,45.7 v2(78.81,45.6)
GPIO10_VREF: length 94.1
  TOP w0.102: v1(97.88,96.02) 98.14,96.02 98.36,96.24 R398.2
  TOP w0.381: v1(137.58,101.13) 137.03,100.58 Q20.2 ; R398.2 98.74,95.73 98.05,95.05 v2(98,95.05)
  IN1 w0.508: v2(98,95.05) 96.99,94.05 96.99,91.09 96.42,90.51 96.42,83.81 97.79,82.43 107.45,82.43 111.62,86.6 v1(115,86.6)
  IN2 w0.508: v1(115,86.6) 115.17,86.6 116.01,85.76 116.01,82.74 118.17,80.58 121.27,80.58 123.53,82.84 124.73,82.84 125.79,81.77 137.73,81.77 139.15,80.35 142.2,80.35 142.68,80.83 142.68,88 142.3,88.38 142.3,97.78 138.95,101.13 v1(137.58,101.13)
  BOTTOM w0.381: v2(98,95.05) U8.C5
GPP_B18: length 21
  TOP w0.079: 79.97,36.82 80.19,37.03 80.19,37.59 79.82,37.96 79.82,38.72 79.51,39.02 79.51,39.43 80.06,39.98 v2(80.06,40.2)
  TOP w0.102: R120.1 77.27,22.85 76.77,23.35 76.77,23.63 76.51,23.9 R122.2 76.31,24.57 v1(76.47,24.73) 76.47,25.18 76.87,25.59 76.87,26.07 77.25,26.45 77.25,27.32 77.06,27.51 77.06,28.98 76.93,29.11 76.93,32.17 78.55,33.79 78.55,35.39 79.97,36.82
  BOTTOM w0.079: v2(80.06,40.2) 80.01,40.2 79.69,40.52 U1.CE29
GPP_B23: length 14.8
  BOTTOM w0.079: 70.86,38.28 70.98,38.39 70.98,38.67 72.29,39.99 72.29,40.58 73.36,41.64 74.86,41.64 74.98,41.53 76.41,41.53 U1.CC34
  BOTTOM w0.102: R89.1 65.18,37.24 65.31,37.37 R90.2 66.51,37.61 66.71,37.81 67.96,37.81 68.46,37.3 69.89,37.3 70.86,38.28
GPP_F10: length 2
  TOP w0.102: v2(87.82,37.68) 88.17,37.32 88.17,36.59 TP21.1
  BOTTOM w0.079: U1.CK17 87.42,37.29 v2(87.82,37.68)
GPP_F23: length 19.5
  TOP w0.102: v2(87.82,39.53) 87.82,39.61 88.58,40.37 89.08,40.37 89.52,39.93 89.52,39.74 89.83,39.43 89.83,38.75 90.36,38.21 90.36,36.93 91.87,35.42 93.17,35.42 94.06,34.53 94.65,34.53 94.79,34.39 94.79,33.76 94.85,33.7 94.85,33 95.39,32.46 95.39,32.25 v1(96.99,30.65) R158.2 97.85,30.58 98.82,29.61 R153.1
  BOTTOM w0.079: v2(87.82,39.53) 87.67,39.53 U1.CF17
GPP_H21: length 17.8
  BOTTOM w0.079: U1.CF25 81.61,39.37 81.61,37.97 81.19,37.55 80.68,37.55 80.58,37.45 80.58,37.07 80.83,36.82 80.83,36.56 80.7,36.43 80.7,36.18 80.73,36.16 80.73,35.83 80.7,35.8 80.7,34.33 80.86,34.17 80.86,32.68 80.99,32.55
  BOTTOM w0.102: v1(77.86,26.66) 77.56,26.96 77.56,27.8 77.66,27.9 R144.1 78.04,28.18 78.47,28.61 80.83,28.61 80.84,28.62 80.89,28.62 81.13,28.86 81.13,30.8 80.99,30.94 80.99,32.55
GPP_H23: length 1.5
  TOP w0.102: v2(81.14,37.03) 81.06,36.95 81.06,36.33 TP20.1
  BOTTOM w0.079: v2(81.14,37.03) 81.45,37.03 81.58,36.9 U1.CM26
GPU_CHOKE_THERMAL: length 186.7
  TOP w0.102: v2(70.83,106.82) 70.7,106.94 PR9025.1 ; U37.126 185.65,29.1 185.45,28.9 184.66,28.9 184.19,29.37 184.19,30.48 183.89,30.77 181.95,30.77 R25502.1 181.08,31 180.07,32.01 180.07,32.54 179.74,32.87 v2(179.74,32.96)
  IN1 w0.089: v2(70.83,106.82) 70.78,106.82 70.78,106.82 70.78,106.06 70.93,105.9 72.66,105.9 72.84,105.72 72.84,104.5 v2(74.43,102.91)
  IN2 w0.089: v2(74.43,102.91) 74.43,102.81 75.44,101.8 78.35,101.8 80.79,99.36 85.93,99.36 87.9,97.39 87.9,96.96 89.77,95.08 89.77,91.3 94.75,86.33 94.75,84.81 96.89,82.67 100.4,82.67 101.01,82.06 101.01,79.34 100.49,78.83 100.49,77.16 100.42,77.09 100.42,74.81 100.11,74.5 100.11,71.57 100.22,71.45 100.22,71.21 102.7,68.73 103.3,68.73 105.08,66.95 109.92,66.95 110.38,66.49 112.01,66.49 113.51,64.99 114.94,64.99 115.5,64.43 115.5,62.56 114.8,61.86 114.8,54.97 114.49,54.65 114.49,52.54 115.14,51.89 115.14,50.36 115.39,50.11 115.39,48.04 113.85,46.5 113.85,44.1 114.4,43.56 117.11,43.56 117.47,43.19 117.47,42.74 117.86,42.35 118.11,42.35 119.21,41.25 119.21,40.62 120.76,39.07 120.76,38.55 122.09,37.22 123.83,37.22 124.86,36.19 125.76,36.19 128.06,38.49 134.83,38.49 135.06,38.72 135.06,41.17 137.22,43.33 140.37,43.33 142.44,41.27 142.97,41.27 143.49,40.75 143.49,40.2 146.92,36.77 146.92,36.2 147.33,35.79 147.87,35.79 147.91,35.75 148.26,35.75 148.54,35.46 153.05,35.46 153.35,35.17 155.85,35.17 156.72,36.04 159.2,36.04 159.87,35.36 162.63,35.36 163.49,34.5 164.36,34.5 164.6,34.27 164.6,34.21 165.33,33.48 166.87,33.48 167.12,33.73 179.07,33.73 179.74,33.06 v2(179.74,32.96)
GPU_EVENT#: length 89.3
  TOP w0.079: 81.14,35.67 81.52,36.05 81.52,37.37 81.36,37.54 81.36,40.92 80.89,41.39 79.87,41.39 79.67,41.59 79.21,41.59 v2(78.83,41.97)
  TOP w0.102: 81.14,35.67 80.81,35.34 80.81,33.23 80.91,33.13 80.91,31.27 81.32,30.86 81.32,28.9 80.85,28.43 80.1,28.43 79.77,28.1 79.77,25.51 79.72,25.46 79.72,25.01 79.82,24.9 79.82,24.5 79.78,24.46 R25482.2 ; v1(86.05,97.76) 86.55,98.26 86.55,98.56 85.7,99.41 D4.1
  IN2 w0.089: v1(85.79,86.98) 85.66,87.11 85.66,88.89 86.98,90.21 86.98,96.84 v1(86.05,97.76)
  IN3 w0.089: v2(78.83,41.97) 78.83,42.18 79.05,42.4 79.05,43.92 79.31,44.18 79.56,44.18 79.67,44.28 79.67,44.94 79.46,45.15 78.6,45.15 78.44,45.31 78.44,45.9 78.53,45.99 78.98,45.99 79.29,46.31 79.29,46.66 80.58,47.95 80.95,47.95 81.19,48.2 81.19,50.41 81.09,50.51 81.09,50.81 81.3,51.03 81.3,52.25 81.7,52.64 81.7,63.64 86.18,68.12 86.18,85.23 85.28,86.13 85.28,86.47 v1(85.79,86.98)
  BOTTOM w0.079: v2(78.83,41.97) 78.83,41.77 79.04,41.56 U1.CC30
GPU_EVENT#_GPU: length 5.5
  TOP w0.102: R373.1 88.72,98.67 R25490.1 88.68,99.39 88.68,99.5 88.78,99.61 88.78,99.88 88.1,100.57 D4.2 87.39,100.57 86.47,99.66 v1(86.47,99.45)
GPU_GPIO0: length 10.6
  BOTTOM w0.102: U8.C6 98.03,94.23 98.03,92.72 97.78,92.47 97.01,92.47 96.75,92.2 95.83,92.2 95.23,91.61 92.32,91.61 90.66,89.95 R370.2
GPU_GPIO2: length 13.3
  TOP w0.102: R373.2 91.17,98.67 93.38,100.87 94.14,100.87 96.71,98.31 96.71,97.93 v2(97.12,97.52)
  BOTTOM w0.102: v2(97.12,97.52) 98.61,97.52 98.84,97.29 98.84,95.85 98.43,95.43 U8.D6
GPU_GPIO6: length 7
  BOTTOM w0.102: R376.2 90.87,90.92 92.02,92.07 95.04,92.07 95.64,92.66 96.36,92.66 U8.A4
GPU_GPIO21: length 10.2
  BOTTOM w0.102: U8.C4 96.33,94.23 96.33,93.59 96.2,93.46 95.69,93.46 95.54,93.31 95.54,92.89 94.95,92.3 91.92,92.3 91.03,91.4 89.47,91.4 89.32,91.55 R404.1
GPU_PEX_RST_HOLD#: length 12.7
  BOTTOM w0.102: U8.D5 97.18,95.03 97.18,92.96 96.65,92.43 95.73,92.43 95.14,91.84 92.23,91.84 90.88,90.49 89.58,90.49 89.42,90.33 89.42,90.18 89.11,89.88 88.95,89.88 R399.1
GPU_PWR_GD: length 56
  TOP w0.203: v2(75.2,105.98) 75.2,106.01 75.42,106.23 75.42,106.59 74.58,107.43 PR9008.1
  IN1 w0.089: v1(92.39,118.32) 92.37,118.32 92.26,118.22 91.56,118.22 88.85,115.52 88.85,110.07 88.03,109.25 88.03,107.93 88.23,107.74 88.23,103.03 87.56,102.37 85.49,102.37 83.6,104.26 77.7,104.26 76.87,105.09 76.72,105.09 76.59,105.22 v1(76.54,105.22) 76.54,105.45 76.01,105.98 v2(75.2,105.98)
  BOTTOM w0.102: v1(76.54,105.22) 76.59,105.17 76.59,104.89 76.49,104.78 76.49,104.48 76.87,104.1 77.74,104.1 78.37,103.47 78.37,99.3 v1(78.27,99.2) 77.97,98.9 77.71,98.9 77.3,98.49 77.3,97.04 76.9,96.63 76.9,95.74 76.63,95.48 PR9079.2 ; R324.1 99.08,119.24 98.19,120.13 93.97,120.13 92.39,118.55 v1(92.39,118.32)
GPUT_CLK_L: length 125.5
  TOP w0.102: Q13.4 174.31,30.93 173.57,30.19 R365.1 173.34,29.75 v2(173.16,29.58)
  IN2 w0.089: v2(133.42,42.09) 133.3,41.96 131.49,41.96 130.43,43.02 130.43,49.05 131.14,49.76 131.14,56.36 132.46,57.68 132.46,61.67 131.14,62.99 131.14,64 128.85,66.29 128.85,67.92 123.62,73.15 123.62,76.2 120.3,79.52 117.78,79.52 114.77,82.53 114.77,83.91 114.31,84.36 113.21,84.36 111.54,86.04 108.44,86.04 106.74,87.74 105.73,87.74 103.16,90.31 103.16,91.02 101.32,92.86 v2(101.32,95.02)
  IN3 w0.089: v2(133.42,42.09) 134.72,40.79 134.72,36.52 136,35.24 136,34.74 136.77,33.97 139.23,33.97 141.29,31.91 141.29,31.44 142.74,30 147.52,30 147.71,30.19 150.86,30.19 151.39,29.66 155.73,29.66 156.02,29.37 167.47,29.37 167.76,29.09 170.22,29.09 170.62,28.69 172.53,28.69 173.16,29.32 v2(173.16,29.58)
  BOTTOM w0.102: v2(101.32,95.02) U8.D9
GPUT_DATA_L: length 127.6
  TOP w0.102: v2(170.98,29.09) 170.98,29.12 170.97,29.13 170.97,29.75 171.13,29.91 R362.1 171.13,30.28 170.78,30.64 170.78,31.63 171.53,32.39 Q13.1
  IN2 w0.089: v2(133.49,42.73) 133.06,42.3 131.63,42.3 130.77,43.17 130.77,48.91 131.48,49.62 131.48,56.22 132.8,57.54 132.8,61.81 131.48,63.13 131.48,64.15 129.2,66.43 129.2,68.06 123.96,73.29 123.96,76.34 120.44,79.86 117.92,79.86 115.11,82.68 115.11,84.05 114.45,84.71 113.36,84.71 111.68,86.38 108.58,86.38 106.87,88.1 105.86,88.1 103.52,90.44 103.52,91.15 101.81,92.85 101.81,95.26 101.66,95.41 100.82,95.41 100.45,95.04 v2(99.68,95.04)
  IN3 w0.089: v2(133.49,42.73) 133.49,42.56 135.06,40.99 135.06,36.82 136.35,35.53 136.35,34.88 136.91,34.31 139.37,34.31 141.64,32.05 141.64,31.58 142.88,30.34 147.37,30.34 147.57,30.54 151,30.54 151.53,30 155.87,30 156.15,29.73 168.08,29.73 168.38,29.43 170.67,29.43 170.98,29.12 v2(170.98,29.09)
  BOTTOM w0.102: U8.D8 99.7,95.06 v2(99.68,95.04)
GSPI1_MOSI: length 15.5
  TOP w0.079: 75.25,42.49 76.62,42.49 76.67,42.45 78.89,42.45 79.36,41.97 v2(79.41,41.97)
  TOP w0.102: 75.25,42.49 74.9,42.49 74.81,42.58 67.63,42.58 65.75,40.71 R124.2
  BOTTOM w0.079: U1.CA30 79.07,42.42 79.39,42.09 79.39,41.99 v2(79.41,41.97)
H_CPU_SVIDALRT#: length 8.6
  BOTTOM w0.079: U1.AA3 96.58,67.17 96.68,67.15 96.76,67.15 96.99,67.22 97.04,67.22 97.24,67.17 97.26,67.17 99.63,67.17 100.37,67.91 101.36,67.91
  BOTTOM w0.102: R64.1 103.03,69.79 101.81,68.57 101.81,68.08 101.64,67.91 101.36,67.91
H_CPU_SVIDCLK: length 54.1
  TOP w0.102: PR7003.2 140.7,60.64 140.5,60.84 v2(140.5,61.07)
  IN1 w0.089: v2(104.61,70.85) 104.81,70.85 106.97,68.69 109.36,68.69 110,69.33 112.95,69.33 117.12,73.5 119.36,73.5 121.71,71.16 122.9,71.16 124.45,72.71 129.8,72.71 131.13,71.38 131.13,70.05 133.62,67.56 133.62,64.04 134.42,63.24 137.16,63.24 138.66,61.75 139.83,61.75 v2(140.5,61.07)
  BOTTOM w0.102: v2(140.5,61.07) 140.5,61.07 140.47,61.05 140.47,60.87 140.83,60.51 PR7015.1 ; R66.2 101.87,69.18 102.96,70.27 103.87,70.27 104.46,70.85 v2(104.61,70.85) 104.76,70.7 R65.2
H_CPU_SVIDDAT: length 52
  TOP w0.102: PR7001.2 138.77,60.48 v2(139.3,61)
  IN1 w0.089: v2(103.64,70.67) 103.9,70.42 103.9,69.25 105.26,67.89 109.69,67.89 110.44,68.64 113.24,68.64 117.41,72.81 119.08,72.81 121.43,70.46 123.21,70.46 124.78,72.03 129.42,72.03 130.45,71 130.45,69.74 132.88,67.31 132.88,63.65 134.01,62.52 136.59,62.52 138.11,61 v2(139.3,61)
  BOTTOM w0.102: PR7019.1 138.88,60.61 139.27,61 139.3,61 v2(139.3,61) ; v2(103.64,70.67) 102.64,70.67 R68.2
H_CPU_SVIDDAT_R: length 8.5
  BOTTOM w0.079: 102.23,70.88 102.12,70.77 101.86,70.77 101.4,70.31 R68.1 101.4,69.88 101,69.48 101,69.2 99.48,67.68 96.98,67.68 U1.AA2
  BOTTOM w0.102: R67.2 102.93,71.28 102.68,71.03 102.38,71.03 102.23,70.88
H_PROCHOT#: length 150.5
  TOP w0.102: v2(169.89,28.71) 169.89,28.05 170.06,27.88 170.06,27.79 170.77,27.09 172.73,27.09 172.9,26.92 172.9,22.7 173.04,22.57 173.04,21.65 172.83,21.45 172.83,20.36 172.8,20.33 C6618.2 173.09,19.95 v1(173.47,19.57) 173.47,19.08 173.27,18.88 Q6509.3 ; v2(137.5,29.96) 137.86,30.31 137.86,31.31 139.01,32.47 139.45,32.47 139.66,32.68 139.66,32.98 140.42,33.74 140.42,34.78 v2(140.6,34.96)
  IN1 w0.089: v2(116.9,66.89) 115.78,65.77 111.57,65.77 110.68,66.66 105.75,66.66 103.27,69.14 103.27,70.93 104.63,72.3 v2(104.63,72.4)
  IN3 w0.089: v2(169.89,28.71) 169.43,28.26 163.66,28.26 163.02,28.9 155.64,28.9 155.36,29.19 151.2,29.19 150.66,29.72 148.04,29.72 147.84,29.52 142.55,29.52 141.22,30.85 138.39,30.85 v2(137.5,29.96) ; v2(140.6,34.96) 140.6,35.33 139.81,36.12 137.94,36.12 137.53,36.53 137.53,37.58 138.21,38.26 141.03,38.26 141.31,38.54 141.31,43.04 142.8,44.53 142.8,45.75 143.14,46.09 143.14,47.08 144.73,48.67 144.73,51.53 143.57,52.69 143.57,53.86 143.19,54.24 142.2,54.24 141.44,55 141.44,56.04 138.49,58.99 138.49,59.47 137.96,60.01 v2(137.96,60.44) 137.96,63.82 137.27,64.5 136.16,64.5 134.94,63.28 133.92,63.28 133.62,63.59 133.62,67.96 129.45,72.12 124.47,72.12 122.81,70.46 119.71,70.46 116.9,67.65 v2(116.9,66.89)
  BOTTOM w0.102: PR7012.2 138.24,61.55 138.36,61.43 138.36,60.84 v2(137.96,60.44) ; PU1.10 136.78,30.31 137.37,30.9 PR22.1 137.38,30.64 137.5,30.51 v2(137.5,29.96) ; R23.1 105.37,71.92 104.89,72.4 v2(104.63,72.4) 104.48,72.25 R9.1
H_VCCST_PWRGD: length 7.2
  BOTTOM w0.102: v1(101.28,55.21) 101.28,54.69 R54.2 101,54.54 100.09,53.63 100.09,53.47 99.03,52.41 98.33,52.41 97.72,51.8 97.72,51.36 96.72,50.36 U1.BJ2
H_VCCST_PWRGD_R: length 4.3
  BOTTOM w0.102: R52.1 103.06,53.33 v1(103.16,53.22) ; R52.1 103.3,53.93 103.52,54.14 D1.2 ; R52.1 C9.2 101.59,53.93 101.43,54.09 R54.1
HDMI_EQ0: length 5.1
  TOP w0.102: U23.8 19.52,81.26 19.39,81.39 18.48,81.39 18.1,81.77 18.1,82.02 v1(17.58,82.53) R749.1 R746.1
HDMI_EQ1: length 5.3
  TOP w0.102: v1(22.9,85.51) 23.05,85.36 R747.1 22.93,84.7 22.41,84.19 22.41,83.92 R748.1 22.47,82.85 22.47,81.59 22.52,81.54 U23.2
HDMI_HPD: length 20.7
  TOP w0.102: Q6507.3 17.98,88.51 16.83,88.51 R1250.2 VC2.1 R25297.1 15.94,84.95 v2(16.44,85.46) ; v1(21.52,75.09) U23.21
  IN1 w0.089: v1(21.52,75.09) 19.22,77.39 19.22,80.95 18.73,81.44 18.73,84.06 17.33,85.46 v2(16.44,85.46)
HDMI_HPD_C: length 6.8
  TOP w0.102: R25297.2 C616.1 13.93,83.93 v1(13.68,83.68) 11.77,81.77 11.12,81.77 CN37.19
HDMI_HPD_CON: length 208.8
  TOP w0.102: R750.1 20.39,85.47 20.76,85.84 v1(20.76,86.22)
  IN1 w0.089: v1(20.76,86.22) 20.76,84.95 22.54,83.17 22.54,81.38 23.69,80.23 23.69,75.22 24.1,74.81 24.1,73.6 25.47,72.23 25.47,65.92 23.81,64.27 23.81,62.91 21.65,60.75 21.65,58.21 19.56,56.12 18.86,56.12 18.48,55.74 18.48,52.82 19,52.29 19,50.3 17.05,48.34 17.05,39.23 16.72,38.9 16.72,34.25 17.05,33.92 17.05,33.56 17.33,33.29 17.89,33.29 18.88,32.29 18.88,27.47 18.71,27.29 15.66,27.29 12.81,24.45 11.52,24.45 10.55,23.48 10.55,19.87 11.33,19.1 11.33,18.27 11.38,18.22 11.38,17.5 11.75,17.13 11.75,15.48 11.06,14.8 11.06,13.17 11.61,12.63 11.61,12.05 12.15,11.51 12.15,2.48 12.45,2.17 38.81,2.17 39.59,2.95 39.59,4.01 39.04,4.56 39.04,5.57 42.24,8.77 46.5,8.77 47.11,9.38 47.11,10.39 48.4,11.68 48.4,12.35 50.13,14.08 55.68,14.08 56.4,14.79 v2(56.4,17)
  IN3 w0.089: v2(95.87,33.13) 95.45,32.71 95.45,30.67 94.19,29.41 93.33,29.41 93.05,29.13 91.87,29.13 90.45,27.71 87.67,27.71 86.83,26.88 86.83,25.71 87.36,25.18 87.36,24.42 86.46,23.52 82.93,23.52 77.11,17.7 71.77,17.7 71.06,16.99 62.39,16.99 61.93,17.46 59.17,17.46 59.1,17.53 58.22,17.53 58.1,17.66 56.68,17.66 56.4,17.38 v2(56.4,17)
  BOTTOM w0.079: U1.CN6 94.55,35.71 94.55,35.42 94.68,35.29 95.06,35.29 95.31,35.04 95.31,34.56 95.87,34 v2(95.87,33.13)
HDMI_MB_HPD_R: length 8.9
  TOP w0.102: v1(20.13,86.62) Q6507.1 19.05,86.18 18.32,85.45 R25294.1 R750.2 19.61,85.14 20.38,84.37 20.38,83.17 20.71,82.84 20.71,82.44 21.02,82.14 U23.5
HDMI_SCLK: length 38.9
  TOP w0.102: U23.19 20.52,74.65 R490.2 20.05,74.38 19.82,74.15 19.09,74.15 v1(18.73,73.8) ; Q41.3 23.67,63.98 23.48,63.79 22.86,63.79 C614.1 22.41,63.99 v1(21.78,63.36) ; CN37.15 10.96,79.61 10.96,80.58 11.59,81.22 11.9,81.22 v1(12.05,81.37) 13.63,82.94 D13089.2 14.17,82.47 v2(13.96,82.26)
  IN1 w0.089: v2(13.96,82.26) 14.08,82.38 15.99,82.38 16.5,81.88 16.5,76.03 v1(18.73,73.8) 18.88,73.8 19.24,74.15 19.49,74.15 19.77,73.87 19.77,72.84 21.84,70.77 21.84,70.53 22.14,70.22 22.14,69.91 22.41,69.63 22.41,66.12 21.28,64.99 21.28,63.85 v1(21.78,63.36)
HDMI_SDATA: length 40.3
  TOP w0.102: v2(16.09,81.71) 15.65,81.71 15.47,81.89 D13090.2 15.05,82.28 14.62,81.85 13.12,81.85 12.48,81.22 12.48,80.08 CN37.16 ; U23.20 21.02,74.72 21.58,74.15 21.95,74.15 R491.2 21.95,73.87 21.4,73.32 19.76,73.32 v1(19.37,73.7) ; v1(21.14,63.36) 21.65,62.85 22.53,62.85 C613.1 22.93,62.99 23.3,63.36 24.7,63.36 24.97,63.09 Q41.6
  IN1 w0.089: v1(21.14,63.36) 20.89,63.61 20.89,65.15 22.02,66.28 22.02,69.46 21.74,69.73 21.74,70.06 21.44,70.36 21.44,70.61 19.37,72.68 v1(19.37,73.7) 18.93,73.27 18.68,73.27 16.09,75.86 v2(16.09,81.71)
HOLD#: length 5.7
  TOP w0.102: R109.2 161.6,32.2 v2(161.3,32.5) 161.62,32.82 R107.2 161.62,33.28 162.03,33.68 162.22,33.68 163.13,34.59 TP19.1
  BOTTOM w0.102: v2(161.3,32.5) 161.48,32.5 161.99,33.01 161.99,33.61
HOOK3: length 5
  TOP w0.102: TP55.1 112.69,22.9 R221.1 113.83,23.17 113.67,23.34 R222.2 114.18,23.4 114.72,23.4 115.28,22.85 C248.2
HP-L2: length 18.2
  TOP w0.381: 213.38,45.86 213.16,46.08 R472.2 212.78,46.24 212.74,46.24 211.14,44.64 C589.2 210.37,43.64 210.37,42.63 209.26,41.52 208.09,41.52 205.57,39 205.57,38.59 205.09,38.11 v2(204.43,38.11) ; R474.1 214.72,45.22 214.28,45.66 213.98,45.66
  BOTTOM w0.203: v2(204.43,38.11) 204.77,38.11 205.26,37.63 U20.32
HP-L3: length 3.8
  TOP w0.381: v2(215.25,46.8) 214.99,46.54 C592.2 214.56,46.62 R472.1
  BOTTOM w0.254: v2(215.25,46.8) 214.85,46.4 CN35.4
HP-R2: length 18.7
  TOP w0.381: R475.1 214.36,49.01 213.98,48.63 213.73,48.63 ; v2(204.43,38.67) 204.43,39.19 209.62,44.38 C594.2 209.64,44.4 212.37,47.13 212.52,47.13 213.06,47.66 R473.2 213.16,47.98 213.48,48.31
  BOTTOM w0.203: U20.33 205.66,37.17 205.67,37.19 205.67,38.64 v1(205.52,38.8)
  BOTTOM w0.381: v2(204.43,38.67) 204.56,38.8 v1(205.52,38.8)
HP-R3: length 3.9
  TOP w0.381: v2(215.17,48.2) 215.17,47.72 C593.2 214.07,47.53 R473.1
  BOTTOM w0.254: CN35.2 214.51,47.4 214.72,47.61
  BOTTOM w0.381: v2(215.17,48.2) 215.17,48.07 214.72,47.61
HP_JD#: length 22.9
  IN2 w0.381: v1(199.32,30.07) 199.32,30.84 201.43,32.96 201.43,34.66 202.37,35.6 204.15,35.6 205.32,36.77 205.32,38.87 207.71,41.26 210.81,41.26 211.8,42.25 v1(212.33,42.25)
  BOTTOM w0.305: CN35.13 212.68,41.9 v1(212.33,42.25)
  BOTTOM w0.381: R451.2 199.04,30.5 199.32,30.22 v1(199.32,30.07)
HWPG: length 115.5
  TOP w0.102: 168.47,29.37 D62.2 D51.2 D2016.2 ; 168.47,29.37 169.02,29.37 169.35,29.7 D60.2 169.94,29.7 170.34,29.29 170.34,28.97 170.35,28.96 170.35,28.67 R25312.1 170.72,27.8 170.84,27.67 v2(171.36,27.67) ; 168.47,29.37 D61.2 168.47,31.23 168.34,31.36 D64.2 166.79,33.59 166.41,33.59 166.11,33.88 166.11,34.14 v2(165.97,34.28) ; U37.21 184.49,20.18 v2(185.56,21.25)
  IN1 w0.089: v1(105.27,52.72) 105.4,52.72 105.75,53.07 106.31,53.07 109.18,50.2 109.18,49.62 109.28,49.52 110.42,49.52 111.54,48.4 111.54,47.99 111.66,47.87 111.66,46.91 115.23,43.34 118.86,43.34 120.54,45.02 127.24,45.02 127.97,44.29 130.22,44.29 131.23,45.31 133.51,45.31 135.31,47.1 138.44,47.1 139.46,48.12 142.43,48.12 143.65,46.9 143.65,42.05 144.52,41.18 144.52,40.58 147.68,37.42 147.92,37.42 148.36,36.98 148.74,36.98 148.88,36.84 149.08,36.84 149.53,36.38 153.1,36.38 153.35,36.64 153.68,36.64 153.84,36.79 154.32,36.79 154.71,37.18 154.81,37.18 154.93,37.31 155.29,37.31 156.09,38.11 158.61,38.11 159.45,37.27 160.13,37.27 160.56,36.84 160.56,36.51 160.91,36.16 161.77,36.16 162.73,35.2 164.24,35.2 164.76,34.68 165.47,34.68 165.76,34.39 165.86,34.39 v2(165.97,34.28) ; v2(185.56,21.25) 185.56,21.32 184.56,22.31 180.53,22.31 180.31,22.09 176.28,22.09 175.93,22.44 175.53,22.44 v2(175.53,22.43)
  BOTTOM w0.102: D1.1 104.48,52.61 104.58,52.72 v1(105.27,52.72) ; v2(171.36,27.67) 171.36,27.1 172.33,26.14 173.5,26.14 173.58,26.06 173.58,25.29 175.53,23.35 v2(175.53,22.43)
HWPG_1.5V: length 9.8
  TOP w0.102: PR284.1 168.24,25.01 PR6416.2 168.49,25.36 167.85,26 167.85,26.63 166.86,27.62 166.86,30.09 166.33,30.62 D61.1 166.17,31.09 166.71,31.63 166.71,33.03 v1(166.61,33.13)
HWPG_1.8VS5: length 145.8
  TOP w0.102: v2(165.92,21.55) 165.97,21.6 165.97,23.09 165.44,23.62 165.44,24.15 165.72,24.43 165.72,25.84 165.71,25.85 165.71,26.98 165.9,27.16 166.5,27.16 166.63,27.29 166.63,28.49 166.17,28.95 D62.1 ; v2(41.59,26.9) 41.61,26.88 PR9255.2 PR9256.1
  IN1 w0.089: v2(41.59,26.9) 41.74,26.9 43.38,25.26 48.7,25.26 49.62,24.34 50.51,24.34 v2(51.42,23.43)
  IN2 w0.089: v2(165.92,21.55) 165.64,21.27 164.97,21.27 164.81,21.11 163.38,21.11 163.12,20.85 156.87,20.85 156.8,20.91 137.64,20.91 137.07,21.49 134.86,21.49 134.42,21.04 127.66,21.04 126.21,22.49 121.98,22.49 121.88,22.59 120.81,22.59 119.75,21.53 113.75,21.53 113.4,21.17 110.86,21.17 109.05,19.37 105.06,19.37 104.14,18.44 98.53,18.44 98.38,18.59 96.25,18.59 96.21,18.55 94.35,18.55 89.42,23.48 83.3,23.48 79.13,19.31 75.82,19.31 75.49,18.98 70.24,18.98 69.68,18.43 64.63,18.43 63.41,19.65 60.39,19.65 57.85,22.19 51.67,22.19 51.42,22.44 v2(51.42,23.43)
HWPG_1.35VGFX: length 271.2
  TOP w0.102: v2(97.17,95.92) 96.2,95.92 94.65,97.47 93.15,97.47 91.68,96 90.03,96 89.24,95.21 v2(89.24,95.03) ; v2(63.69,29.45) 64.53,30.29 64.53,31.43 64.32,31.63 64.32,35.17 65.01,35.85 65.01,37.39 R25468.2
  IN2 w0.089: v2(89.24,95.03) 89.11,95.03 87.44,96.71 87.44,97.58 85.85,99.17 80.71,99.17 78.3,101.58 75.23,101.58 74.45,102.36 70.6,102.36 66.22,106.74 66.22,107.81 63.18,110.85 57.65,110.85 57.11,110.31 57.11,109.33 56.6,108.83 55.31,108.83 55.08,108.6 55.08,108 53.25,106.17 53.25,105.32 51.82,103.88 50.52,103.88 49.87,103.24 49.46,103.24 49.19,102.96 49.19,102.6 49.28,102.51 49.28,100.41 48.02,99.15 44.79,99.15 43.56,97.92 31.88,97.92 29.67,95.71 29.67,94.51 27.15,91.99 27.15,89.66 24.52,87.04 24.52,85 25,84.52 25.63,84.52 26.19,83.96 26.19,82.41 25.35,81.57 25.35,74.26 25.68,73.93 25.68,51.05 25.27,50.64 25.27,50.49 24.97,50.18 24.46,50.18 23.99,49.72 23.99,48.35 24.55,47.79 24.85,47.79 25.91,46.73 25.91,43.63 25.32,43.04 25.32,41.37 25.44,41.25 25.44,38.61 26.39,37.67 27.22,36.83 27.22,34.24 27.91,33.55 29.79,33.55 32.78,30.57 v1(34.45,30.57) ; v2(63.69,29.45) 61.89,29.45 61.78,29.35 60.59,29.35 60.41,29.53 60.41,29.91 60.07,30.25 56.01,30.25 55.66,29.91 55.1,29.91 54.47,30.54 53.4,30.54 52.87,30.01 49.57,30.01 49.01,30.57 48.22,30.57 47.18,29.53 46.14,29.53 44.92,30.75 44.92,31.08 43.01,32.98 v2(42.45,32.98)
  IN3 w0.089: v1(34.45,30.57) 36.16,30.57 38.57,32.98 v2(42.45,32.98) ; v1(141.58,69.98) 141.75,69.98 142.52,70.75 142.52,76.42 138.08,80.86 129.44,80.86 128.69,81.6 125.87,81.6 124.5,82.97 124.5,84.83 121.71,87.62 110.92,87.62 108.7,89.84 105.78,89.84 104.07,91.55 104.07,91.81 103.69,92.19 103.21,92.19 103.09,92.07 101.99,92.07 99.92,94.14 99.39,94.14 98.49,95.04 98.49,96 98.21,96.28 97.52,96.28 v2(97.17,95.92)
  BOTTOM w0.254: PR9088.2 PR9090.2 141.9,69.67 v1(141.58,69.98)
HWPG_1VS5: length 57.3
  TOP w0.254: D64.1 166.04,32.33 165.14,33.23 v1(165.14,33.56) 165.14,34.12 v2(165.31,34.3)
  IN2 w0.203: v2(165.31,34.3) 165.31,34.38 165.14,34.56 164.93,34.56 164.55,34.94 163.67,34.94 162.82,35.8 160.76,35.8 160.17,36.38 159.79,36.38 159.45,36.73 159.45,37.15 159.2,37.4 158.52,37.4 158.16,37.04 155.01,37.04 154.79,36.82 154.59,36.82 154.32,36.55 153.95,36.55 153.71,36.31 153.33,36.31 153.07,36.05 149.42,36.05 148.89,36.59 148.38,36.59 147.76,37.21 147.54,37.21 143.93,40.82 143.93,41.43 143.46,41.91 143.46,42.55 142.43,43.57 141.1,43.57 140.74,43.93 137.06,43.93 132.59,39.46 125.79,39.46 124.67,40.58 123.23,40.58 122.16,41.64 121.88,41.64 121.73,41.79 v2(121.58,41.79)
  BOTTOM w0.203: v2(121.58,41.79) 121.39,41.61 PR276.2 PR275.2
HWPG_2.5V: length 160.1
  TOP w0.102: D2016.1 166.17,26.01 165.95,25.79 165.95,24.34 165.67,24.06 165.67,23.72 166.2,23.19 166.2,21.85 166.33,21.72 166.33,21.35 166.13,21.14 166.13,20.44 165.62,19.93 165.62,19.49 v2(165.49,19.37) ; PR186.2 32.19,26.74 v2(32.47,27.01)
  IN2 w0.089: v2(165.49,19.37) 165.32,19.2 163.42,19.2 162.85,18.62 154.99,18.62 154.35,19.27 151.5,19.27 150.96,18.73 149.47,18.73 148.87,18.12 145.1,18.12 144.26,18.96 133.24,18.96 132.41,18.12 130.5,18.12 129.52,19.11 128.39,19.11 128.11,18.83 124.38,18.83 123.92,19.29 120.48,19.29 119.59,18.4 118.93,18.4 118.6,18.07 114.23,18.07 112.88,16.72 108.64,16.72 107.4,15.49 100.55,15.49 99.91,16.13 98.38,16.13 97.59,16.92 95.87,16.92 95.74,16.79 93.9,16.79 88.76,21.93 84.05,21.93 79.2,17.09 72.76,17.09 71.84,16.17 61.06,16.17 59.38,17.85 47.27,17.85 46.44,18.68 46.44,21.49 46.16,21.77 46.16,22.03 45.69,22.5 41.64,22.5 40.28,23.87 40.28,24.21 38.63,25.86 35.75,25.86 35.22,26.39 35.22,27.09 34.71,27.6 32.78,27.6 32.47,27.29 v2(32.47,27.01)
  BOTTOM w0.102: v2(32.47,27.01) 32.24,26.79 32.24,26.3 32.09,26.15 PU14.1
HWPG_VDDR: length 187.1
  TOP w0.102: v2(161.07,36.53) 161.51,36.53 161.86,36.18 162.11,36.18 162.88,35.42 163.45,35.42 164.6,34.27 164.6,33.16 165.54,32.22 165.54,28.82 166.17,28.19 D51.1
  IN2 w0.089: v2(106.44,84.72) 106.44,84.95 105.9,85.48 105.6,85.48 102.32,88.77 98.66,88.77 98.03,89.39 95.79,89.39 92.42,92.77 92.42,97.98 91.15,99.25 91.15,100.27 89.04,102.37 83.64,102.37 81.37,104.64 78.67,104.64 78.09,105.22 77.4,105.22 76.79,105.83 75.57,105.83 75.35,105.61 74.45,105.61 74,106.06 71.52,106.06 71.26,105.8 70.49,105.8 68.81,107.48 68.81,110.51 62.44,116.88 62.19,116.88 v2(61.94,117.13) ; v2(106.87,87.01) 106.87,86.93 108.23,85.57 111.34,85.57 112.96,83.95 112.96,83.67 117.54,79.1 117.54,76.72 119.75,74.51 119.75,74.41 121.63,72.53 121.63,71.87 122.54,70.95 123.52,70.95 130.67,63.81 130.67,62.79 131.99,61.47 131.99,57.88 130.67,56.56 130.67,52.82 129.2,51.34 129.2,49.8 129.96,49.03 129.96,43.76 129.31,43.11 129.31,41.75 130.36,40.7 133.49,40.7 136.97,44.18 140.89,44.18 141.25,43.82 142.54,43.82 143.71,42.65 143.71,42.01 144.28,41.44 144.28,40.82 147.64,37.46 147.86,37.46 148.45,36.87 148.98,36.87 149.55,36.3 152.97,36.3 153.23,36.56 153.61,36.56 153.85,36.8 154.22,36.8 154.49,37.07 154.69,37.07 154.92,37.3 155.28,37.3 156.12,38.14 158.81,38.14 159.57,37.37 160.03,37.37 160.87,36.53 v2(161.07,36.53)
  IN3 w0.089: v2(106.87,87.01) 106.87,85.38 106.44,84.95 v2(106.44,84.72)
  BOTTOM w0.102: PR9265.1 61.81,125.28 61.3,124.78 v1(61.3,124.45) 61.3,123.51 62.14,122.67 62.14,117.33 v2(61.94,117.13)
  BOTTOM w0.203: PR9265.1 62.13,124.86 62.37,124.62 PR267.2
I2CA_SCL: length 10.3
  BOTTOM w0.102: 98.84,92.7 98.84,93.44 U8.B7
  BOTTOM w0.305: 98.84,92.7 98.84,92.17 98.21,91.54 95.95,91.54 95.47,91.05 93.16,91.05 91.6,89.5 R326.1
I2CA_SDA: length 9.1
  BOTTOM w0.305: R25492.1 92.57,89.85 93.34,90.62 95.64,90.62 96.13,91.11 98.39,91.11 99.3,92.02 99.3,92.96 U8.A7
ICMNT: length 80.5
  TOP w0.102: v2(189.09,24.17) 189.16,24.17 189.24,24.24 189.82,24.24 190.48,23.58 192.61,23.58 193.61,22.59 193.61,20.94 193.25,20.59 193.25,19.44 194.04,18.66 195.87,18.66 196.51,18.01 197.45,18.01 197.97,17.5 197.97,16.71 198.1,16.58 U37.67 200.13,16.58 v1(200.95,15.76) 201.19,15.52 C6564.2
  IN2 w0.089: v2(189.09,24.17) 189.09,24.93 189.5,25.34 189.5,26.2 189.24,26.45 188.17,26.45 187.54,25.82 185.66,25.82 185.12,26.35 183.6,26.35 182.79,27.16 180.54,27.16 179.3,28.4 177.61,28.4 177.23,28.78 172.71,28.78 172.63,28.71 170.75,28.71 170.22,29.24 164.54,29.24 164.29,28.99 161.13,28.99 159.87,30.26 155.97,30.26 155.36,30.87 145.69,30.87 144.12,32.44 143.44,32.44 143,32.88 140.78,32.88 140.35,32.45 138.75,32.45 138.51,32.22 v2(136.46,32.22)
  BOTTOM w0.203: PC37.2 137.38,33.49 PR32.1 136.66,32.44 136.46,32.24 v2(136.46,32.22)
ILIM_HI: length 3.1
  TOP w0.102: v1(15.94,47.38) 16.01,47.46 R414.2 16.7,47.62 17.23,48.15 17.59,48.15 17.86,47.88 U14.16
ILIM_LO: length 2.8
  TOP w0.102: U14.15 16.94,48.38 R415.2 16.05,48.62 v1(15.87,48.8)
IMON_CORE: length 2.8
  BOTTOM w0.203: PR7014.2 142.07,50.28 141.95,50.41 141.95,51.35 141.75,51.55 141.12,51.55 PU7000.1
IMON_GT: length 4.3
  BOTTOM w0.203: PU7000.30 138.55,58.67 v1(137.72,59.49) 137.35,59.86 PC423.1 136.19,59.86 PR7004.2
IMON_SA: length 6.5
  TOP w0.102: PC7003.2 v1(140.32,58.48)
  TOP w0.203: v1(142.63,58.05) 142.53,58.05 142.24,58.34 141.65,58.34 141.16,57.85 PR7005.2 141.07,57.77 PC7003.2
  BOTTOM w0.203: PU7000.39 142.53,55.87 142.91,56.25 142.91,57.49 142.63,57.77 v1(142.63,58.05)
IMVP_PWRGD: length 99.7
  TOP w0.102: v2(91.12,23.52) 91.19,23.46 93.28,23.46 93.77,22.96 93.77,22.3 94.25,21.83 97.85,21.83 98.51,22.49 102.21,22.49 104.68,24.96 104.68,25.36 106.82,27.49 106.82,29.22 107.43,29.83 108.35,29.83 110.66,32.14 111.11,32.14 v2(111.52,32.55) ; v2(143.19,35.59) 142.9,35.59 141.85,34.55 Q85.2
  IN1 w0.089: v2(143.19,35.59) 142.88,35.59 142.29,36.19 138.04,36.19 137.83,36.4 127.22,36.4 126.11,35.29 124.54,35.29 124.51,35.32 121.69,35.32 121.09,34.73 119.14,34.73 116.81,32.4 111.66,32.4 v2(111.52,32.55)
  IN3 w0.089: v1(143.34,60.74) 143.27,60.67 143.27,60.64 142.81,60.18 142.81,59.07 143.22,58.66 143.95,58.66 144.04,58.57 144.04,56.96 144.98,56.02 144.98,55.12 146.47,53.63 146.47,48.53 144.49,46.54 144.49,45.53 144.13,45.17 144.13,43.75 143.11,42.73 143.11,40.52 144.36,39.28 144.36,36.36 143.59,35.59 v2(143.19,35.59)
  BOTTOM w0.102: U6504.2 88.4,23.68 88.65,23.93 90.64,23.93 91.04,23.52 v2(91.12,23.52) 91.3,23.7 R25359.2 ; v1(143.34,60.74) 143.27,60.67 143.27,60.51 142.91,60.16 142.2,60.16 142.1,60.26 PR7068.2 PR7067.1
IN_CLK: length 109.6
  TOP w0.102: v1(27.37,84.06) 26.95,83.64 26.95,83.54 26.74,83.34 26.74,82.78 27.41,82.12 27.41,81.61 27.06,81.27 26.07,81.27 26,81.34 C849.1
  IN3 w0.089: v2(94.29,65.81) 94.48,65.81 94.55,65.87 94.55,66.12 94.27,66.4 94.27,69.45 93.96,69.76 92.64,69.76 92.18,70.23 92.18,70.65 92.05,70.78 90.99,70.78 90.59,71.17 90.59,73.8 90.13,74.26 90.13,80.96 89.27,81.82 89.27,87.07 88.21,88.13 87.84,88.13 85.66,90.31 81.44,90.31 80.15,91.6 78.39,91.6 75.97,94.02 75.07,94.02 74.46,94.63 66.99,94.63 66.58,94.22 59.75,94.22 55.43,98.54 44.88,98.54 43.43,97.09 32.78,97.09 30.69,95.01 30.69,94.07 29.02,92.4 29.02,88.23 26.83,86.04 26.83,83.93 26.99,83.78 27.18,83.78 27.37,83.96 v1(27.37,84.06)
  BOTTOM w0.102: U1.AE6 93.89,65.45 93.89,65.73 94.02,65.85 94.25,65.85 v2(94.29,65.81)
IN_CLK#: length 109.6
  TOP w0.102: R1290.1 26,80.86 26.19,81.05 27.15,81.05 27.62,81.52 27.62,82.21 26.96,82.87 26.96,83.25 27.14,83.43 v1(27.37,83.43)
  IN3 w0.089: v2(94.93,65.82) 94.75,65.99 94.75,66.2 94.48,66.48 94.48,69.53 94.04,69.96 92.73,69.96 92.38,70.31 92.38,70.73 92.14,70.98 91.07,70.98 90.79,71.26 90.79,73.88 90.33,74.34 90.33,81.05 89.47,81.91 89.47,87.16 88.3,88.33 87.92,88.33 85.74,90.51 81.53,90.51 80.23,91.81 78.47,91.81 76.06,94.22 75.15,94.22 74.54,94.83 66.91,94.83 66.5,94.42 59.84,94.42 55.51,98.75 44.8,98.75 43.34,97.29 32.69,97.29 30.49,95.09 30.49,94.16 28.81,92.48 28.81,88.31 26.63,86.13 26.63,83.85 26.9,83.58 27.21,83.58 v1(27.37,83.43)
  BOTTOM w0.102: v2(94.93,65.82) 94.68,65.57 U1.AE5
IN_CLK#_R: length 13.3
  TOP w0.102: v1(26.94,80.5) 26.81,80.63 R1290.2
  BOTTOM w0.102: v1(26.94,80.5) 26.94,80.99 26.83,81.09 25.22,81.09 24.58,80.46 19.46,80.46 19.16,80.16 17.67,80.16 17.47,80.36 16.87,80.36 D13087.2 16.27,80.36 15.92,80.36 15.78,80.22 C1679.1
IN_CLK_R: length 13.2
  TOP w0.102: R1291.2 v1(26.94,81.77)
  BOTTOM w0.102: v1(26.94,81.77) 26.94,81.41 26.83,81.31 25.13,81.31 24.49,80.68 19.37,80.68 19.07,80.38 17.76,80.38 17.56,80.58 16.87,80.58 D13088.2 16.27,80.58 15.96,80.58 15.78,80.76 C1681.1
IN_D0: length 114.8
  TOP w0.102: R1285.1 26,75.7 26.1,75.6 27.41,75.6 v1(27.62,75.81)
  IN3 w0.089: v1(27.62,75.81) 27.41,75.59 26.82,75.59 26.54,75.87 26.54,76.92 25.92,77.54 25.92,81.34 27.37,82.79 28.21,82.79 28.84,83.42 28.84,86.68 29.61,87.46 29.61,92.15 31.35,93.89 31.35,94.78 33.07,96.49 49.55,96.49 50.53,95.52 57.57,95.52 59.5,93.59 67.07,93.59 67.5,94.02 74.05,94.02 74.74,93.33 75.73,93.33 78.07,90.99 79.87,90.99 81.44,89.42 83.45,89.42 83.73,89.14 85.98,89.14 87.73,87.4 87.73,87.07 88.63,86.17 88.63,81.6 89.52,80.71 89.52,74.26 89.34,74.09 89.34,71 90.54,69.81 91.7,69.81 92.14,69.37 92.14,68.15 93.25,67.03 93.25,64.87 93.75,64.38 94.35,64.38 94.8,64.83 v2(94.93,64.83)
  BOTTOM w0.102: U1.AF5 94.68,64.43 94.93,64.68 v2(94.93,64.83)
IN_D0#: length 114.8
  TOP w0.102: R1284.1 26,75.28 26.1,75.38 27.41,75.38 v1(27.62,75.17)
  IN3 w0.089: v1(27.62,75.17) 27.41,75.39 26.74,75.39 26.33,75.79 26.33,76.84 25.72,77.46 25.72,81.43 27.28,82.99 28.13,82.99 28.64,83.5 28.64,86.77 29.41,87.54 29.41,92.23 31.15,93.97 31.15,94.86 32.98,96.7 49.64,96.7 50.62,95.72 57.65,95.72 59.58,93.79 66.98,93.79 67.41,94.22 74.14,94.22 74.82,93.53 75.81,93.53 78.15,91.2 79.95,91.2 81.53,89.62 83.53,89.62 83.81,89.34 86.07,89.34 87.93,87.48 87.93,87.16 88.83,86.25 88.83,81.68 89.72,80.79 89.72,74.18 89.55,74 89.55,71.09 90.62,70.01 91.78,70.01 92.34,69.46 92.34,68.24 93.46,67.12 93.46,64.96 93.7,64.72 94.05,64.72 94.19,64.86 v2(94.3,64.86)
  BOTTOM w0.102: v2(94.3,64.86) 94.3,64.5 94.18,64.39 U1.AF6
